#ifndef _ROBOTOCONDENSED_ITALIC68PT7B_H_
#define _ROBOTOCONDENSED_ITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0x00, 0x38, 0x00, 0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0, 0xF0, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x0C, 0x3E, 0x03, 0xC0, 0x1C, 0x78, 0x07, 0x80, 0x7C, 0xF0,
  0x0F, 0x01, 0xF1, 0xE0, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x0F, 0x8F, 0x80,
  0x78, 0x3E, 0x1F, 0x00, 0xF0, 0x78, 0x3E, 0x03, 0xE1, 0xF0, 0x7C, 0x07,
  0x87, 0xC0, 0x78, 0x0F, 0x1F, 0x00, 0xF0, 0x3E, 0x3C, 0x01, 0xF0, 0xF8,
  0xF8, 0x01, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0xC7, 0x80, 0x03, 0xFF, 0x1F,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x7F,
  0x00, 0x01, 0xF1, 0xFF, 0x80, 0x07, 0xC7, 0xFF, 0x00, 0x0F, 0x1F, 0xFF,
  0x00, 0x3E, 0x7E, 0x1F, 0x00, 0xF8, 0xF8, 0x1E, 0x01, 0xE1, 0xE0, 0x3C,
  0x07, 0xC7, 0xC0, 0x78, 0x1F, 0x0F, 0x00, 0xF0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF8, 0x3C, 0x03, 0xC3, 0xE0, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x0F, 0x1F,
  0x01, 0xE0, 0x1E, 0x7C, 0x03, 0xC0, 0x7C, 0xF0, 0x07, 0x80, 0xF9, 0xE0,
  0x0F, 0x01, 0xE1, 0x80, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xBF, 0x01, 0xF0, 0xFE, 0x7E, 0x03, 0xE3, 0xF8, 0x7E, 0x07, 0xCF, 0xE0,
  0xFC, 0x1F, 0x1F, 0x80, 0xFC, 0x3E, 0x7E, 0x01, 0xF8, 0x7C, 0xFC, 0x01,
  0xF9, 0xF9, 0xF8, 0x03, 0xF3, 0xE7, 0xE0, 0x03, 0xFF, 0xCF, 0xC0, 0x07,
  0xFF, 0x1F, 0x80, 0x07, 0xFE, 0x3F, 0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x0F,
  0xF0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFF,
  0x83, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xC1, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF1, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x1F, 0x01, 0xDF, 0x07, 0xC1, 0xF7, 0xF9, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF8,
  0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x10, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0x87, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x9F, 0x3F, 0x0F, 0xCF,
  0x03, 0xF3, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xEF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x00,
  0x7F, 0x8F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x0F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0xFF, 0x80,
  0xFE, 0x7F, 0x80, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7E,
  0x07, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE0,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x03,
  0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0xC7, 0xF0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xF8, 0x0F,
  0xFC, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x04, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xF8, 0x1F, 0x9F, 0x80,
  0x7E, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x3F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x38, 0x0F,
  0x00, 0x3F, 0xFE, 0x00, 0xE0, 0x7C, 0x01, 0xFF, 0xFC, 0x03, 0xC1, 0xE0,
  0x0F, 0xE1, 0xF8, 0x0F, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x3C, 0x3C, 0x01,
  0xF0, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC7, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0xF3, 0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xCF, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x79, 0xF0, 0x0F, 0x00, 0x3C,
  0x01, 0xE7, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0x9F, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0x79, 0xE0, 0x1F, 0x00, 0x78, 0x01,
  0xE7, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0xF8, 0x0F, 0x80, 0x3E, 0x00, 0xF3, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0x8F,
  0x80, 0xF8, 0x07, 0xC0, 0x1E, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0xF8,
  0x0F, 0x80, 0xFC, 0x03, 0xC3, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x0F, 0x80,
  0xF8, 0x1F, 0xC0, 0x78, 0x3E, 0x03, 0xF0, 0xFF, 0x03, 0xE0, 0xF8, 0x07,
  0xFF, 0xBE, 0x3F, 0x03, 0xE0, 0x1F, 0xFC, 0xFF, 0xF8, 0x07, 0x80, 0x3F,
  0xE1, 0xFF, 0xC0, 0x1E, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x78, 0x00, 0x70,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0xE0, 0x07, 0xE0,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x3F, 0x00,
  0x3F, 0xE0, 0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x3F, 0x00, 0x3F, 0xFF,
  0x9F, 0x80, 0x1F, 0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF,
  0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x7E, 0x00, 0x00, 0x1F,
  0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x03, 0xEF,
  0x80, 0x00, 0x3F, 0xFC, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xFC, 0x03, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xF8, 0x07, 0xEF,
  0xC0, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x07, 0xE7,
  0xC0, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xC0, 0x01, 0xF9, 0xF0, 0x07, 0xC7,
  0xC0, 0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x0F, 0xC7,
  0xC0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3,
  0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83,
  0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x83, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x83,
  0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC0, 0x3F, 0x01,
  0xF0, 0x7C, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0x3F, 0x01,
  0xF0, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF1, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFB, 0xF0, 0x1F, 0x80, 0x7E, 0x00,
  0xFB, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xFF, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xC0,
  0x00, 0x3F, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xF8,
  0x07, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xFE,
  0x00, 0x0F, 0xC0, 0x3F, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0xF8, 0x00, 0x7E,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0x07, 0xE3,
  0xE0, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xE0, 0x1F, 0x87, 0xC0, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0xFC, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x07, 0xC7, 0xE0, 0x1F,
  0x80, 0x0F, 0x8F, 0xC0, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x7E, 0x00, 0x1F,
  0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0xF8, 0x03,
  0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xF0, 0x07,
  0xE0, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xCF, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x3C,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE3, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0x8F, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x3C, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC3, 0xE0, 0x7E,
  0x01, 0xF0, 0x3E, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC0,
  0x1F, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x80, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x01, 0xE1, 0xF0, 0x01, 0xF1,
  0xF0, 0x07, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x78, 0xF8, 0x00, 0x7C, 0xF8, 0x01, 0xE7, 0xE0, 0x01, 0xF3, 0xE0,
  0x07, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x7B, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x3C, 0x07,
  0xC3, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x1E, 0x7C, 0x01, 0xFF, 0xC0, 0x1F,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7E,
  0x3F, 0xE0, 0x1F, 0x0F, 0xE0, 0x07, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xE3,
  0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xF7,
  0xE0, 0x7F, 0xF9, 0xF8, 0x0F, 0xF8, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x7E, 0x7F, 0xE0, 0x03, 0xF7, 0xFF,
  0x80, 0x1F, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0xC0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xF8, 0x01, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xF7, 0xEF,
  0xFC, 0x1F, 0xBF, 0xFF, 0xC0, 0xFC, 0xFF, 0xFE, 0x07, 0xC3, 0xFF, 0xC0,
  0x3E, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xF8, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x7F, 0xE1, 0xF8, 0x00, 0xFF, 0xF1,
  0xF8, 0x01, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xFD, 0xF0, 0x07, 0xFE, 0x7D,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0xE7, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xBE,
  0x00, 0x07, 0xFE, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3,
  0xF0, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x10, 0x1F, 0xC0, 0x07, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0xE1, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFD, 0x80,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x7C, 0x00, 0xFF, 0xF8, 0xF8,
  0x03, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xF7, 0xE0, 0x3F, 0xE3, 0xEF, 0x80,
  0xFF, 0x01, 0xFF, 0x01, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xF9, 0xF8, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x80,
  0x03, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x9F, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0x9F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01,
  0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0x7E, 0x01, 0xFE, 0x01, 0xF8,
  0x0F, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x3E, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFB,
  0xF0, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFB,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xCF, 0xF8, 0x1F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x07, 0xE0, 0x07, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x7F, 0xE0, 0x0F,
  0x9F, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F,
  0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x7F, 0xE0, 0x00, 0x7D, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xBF,
  0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0x00, 0x1F, 0x87,
  0xFE, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0x87, 0xC0, 0x3F, 0xFE, 0x7E, 0x07, 0xFF, 0xFB,
  0xF0, 0x3F, 0xFF, 0xDF, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xE7, 0xE0,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x7F, 0x03, 0xEF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x07, 0xF0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x0F,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xE0, 0x07, 0xFE, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0,
  0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x3F, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x7C, 0x00, 0xFE, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x7C, 0x01,
  0xFE, 0x00, 0xFC, 0x7C, 0x01, 0xFE, 0x00, 0xF8, 0x7C, 0x01, 0xFE, 0x01,
  0xF8, 0x7C, 0x03, 0xFE, 0x01, 0xF8, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x7C,
  0x07, 0xFE, 0x03, 0xF0, 0x7C, 0x07, 0xDE, 0x03, 0xE0, 0x7E, 0x0F, 0x9E,
  0x07, 0xE0, 0x7E, 0x0F, 0x9F, 0x07, 0xE0, 0x7E, 0x0F, 0x9F, 0x07, 0xC0,
  0x7E, 0x1F, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x1F, 0x0F, 0x80, 0x3E, 0x3E,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x1F, 0x1F,
  0x00, 0x3E, 0x7C, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x1F, 0x3E, 0x00, 0x3E,
  0xF8, 0x0F, 0x3E, 0x00, 0x3E, 0xF8, 0x0F, 0x7C, 0x00, 0x3F, 0xF0, 0x0F,
  0x7C, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x83, 0xFF,
  0xC0, 0x03, 0xC3, 0xFF, 0xF0, 0x03, 0xE1, 0xFF, 0xFC, 0x01, 0xF1, 0xFC,
  0xFF, 0x01, 0xF0, 0xF8, 0x1F, 0xC0, 0xF8, 0xFC, 0x07, 0xF9, 0xFC, 0x7C,
  0x01, 0xFF, 0xFC, 0x3E, 0x00, 0x7F, 0xFC, 0x1F, 0x00, 0x1F, 0xFE, 0x1F,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 14, 49, 16, 2, -48 },
  { 87, 16, 16, 21, 7, -51 },
  { 119, 34, 48, 36, 3, -48 },
  { 323, 29, 63, 33, 2, -56 },
  { 552, 31, 50, 42, 6, -49 },
  { 746, 31, 50, 36, 2, -49 },
  { 940, 7, 16, 12, 6, -51 },
  { 954, 21, 71, 21, 3, -55 },
  { 1141, 20, 71, 21, -3, -55 },
  { 1319, 26, 28, 28, 4, -48 },
  { 1410, 28, 35, 33, 3, -40 },
  { 1533, 12, 17, 13, -4, -7 },
  { 1559, 14, 5, 16, 1, -23 },
  { 1568, 7, 8, 17, 2, -7 },
  { 1575, 30, 52, 24, -3, -48 },
  { 1770, 28, 50, 33, 3, -49 },
  { 1945, 18, 48, 33, 8, -48 },
  { 2053, 30, 49, 33, 1, -49 },
  { 2237, 28, 50, 33, 2, -49 },
  { 2412, 30, 48, 33, 0, -48 },
  { 2592, 29, 49, 33, 4, -48 },
  { 2770, 25, 49, 33, 4, -48 },
  { 2924, 30, 48, 33, 4, -48 },
  { 3104, 29, 50, 33, 2, -49 },
  { 3286, 25, 49, 33, 5, -49 },
  { 3440, 12, 37, 16, 2, -36 },
  { 3496, 16, 46, 14, -3, -36 },
  { 3588, 26, 30, 29, 2, -37 },
  { 3686, 26, 18, 32, 4, -32 },
  { 3745, 26, 30, 30, 2, -36 },
  { 3843, 22, 50, 28, 6, -49 },
  { 3981, 46, 63, 51, 2, -48 },
  { 4344, 35, 48, 38, -2, -48 },
  { 4554, 32, 48, 36, 2, -48 },
  { 4746, 33, 50, 37, 4, -49 },
  { 4953, 33, 48, 38, 2, -48 },
  { 5151, 33, 48, 33, 2, -48 },
  { 5349, 32, 48, 32, 2, -48 },
  { 5541, 33, 50, 39, 4, -49 },
  { 5748, 39, 48, 41, 2, -48 },
  { 5982, 14, 48, 17, 2, -48 },
  { 6066, 32, 49, 32, 0, -48 },
  { 6262, 38, 48, 36, 2, -48 },
  { 6490, 25, 48, 31, 2, -48 },
  { 6640, 48, 48, 50, 2, -48 },
  { 6928, 39, 48, 41, 2, -48 },
  { 7162, 33, 50, 40, 4, -49 },
  { 7369, 35, 48, 37, 2, -48 },
  { 7579, 34, 57, 40, 3, -49 },
  { 7822, 33, 48, 35, 2, -48 },
  { 8020, 33, 50, 34, 1, -49 },
  { 8227, 31, 48, 34, 6, -48 },
  { 8413, 35, 49, 37, 3, -48 },
  { 8628, 34, 48, 37, 6, -48 },
  { 8832, 46, 48, 50, 7, -48 },
  { 9108, 40, 48, 36, -1, -48 },
  { 9348, 33, 48, 35, 6, -48 },
  { 9546, 37, 48, 35, -1, -48 },
  { 9768, 21, 65, 17, 0, -55 },
  { 9939, 12, 52, 24, 7, -48 },
  { 10017, 21, 65, 17, -4, -55 },
  { 10188, 20, 24, 24, 3, -48 },
  { 10248, 27, 5, 27, -4, 0 },
  { 10265, 11, 10, 20, 7, -51 },
  { 10279, 26, 38, 32, 2, -37 },
  { 10403, 29, 52, 33, 1, -51 },
  { 10592, 27, 38, 30, 2, -37 },
  { 10721, 32, 52, 33, 2, -51 },
  { 10929, 27, 38, 31, 2, -37 },
  { 11058, 23, 52, 21, 3, -52 },
  { 11208, 31, 51, 33, 0, -37 },
  { 11406, 27, 51, 32, 1, -51 },
  { 11579, 14, 49, 15, 1, -49 },
  { 11665, 21, 63, 15, -6, -49 },
  { 11831, 30, 51, 30, 1, -51 },
  { 12023, 15, 51, 15, 1, -51 },
  { 12119, 45, 37, 50, 1, -37 },
  { 12328, 27, 37, 32, 1, -37 },
  { 12453, 28, 38, 33, 2, -37 },
  { 12586, 32, 51, 33, -2, -37 },
  { 12790, 29, 51, 33, 2, -37 },
  { 12975, 20, 37, 20, 1, -37 },
  { 13068, 27, 38, 30, 1, -37 },
  { 13197, 17, 46, 20, 3, -45 },
  { 13295, 27, 37, 32, 3, -36 },
  { 13420, 25, 36, 28, 4, -36 },
  { 13533, 40, 36, 43, 4, -36 },
  { 13713, 32, 36, 29, -2, -36 },
  { 13857, 32, 50, 27, -3, -36 },
  { 14057, 29, 36, 29, 0, -36 },
  { 14188, 21, 65, 20, 2, -53 },
  { 14359, 14, 57, 16, 1, -48 },
  { 14459, 21, 65, 20, -3, -53 },
  { 14630, 33, 13, 39, 3, -26 },
};

const GFXfont RobotoCondensed_Italic68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_ITALIC68PT7B_H_
