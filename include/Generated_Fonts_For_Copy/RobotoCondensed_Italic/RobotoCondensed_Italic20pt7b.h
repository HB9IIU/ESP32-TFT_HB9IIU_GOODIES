#ifndef _ROBOTOCONDENSED_ITALIC20PT7B_H_
#define _ROBOTOCONDENSED_ITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x66, 0x64, 0x4C, 0x00, 0x88, 0x5E, 0xB5, 0x29, 0x00,
  0x04, 0xC1, 0x20, 0xC8, 0x26, 0x7F, 0xC6, 0x41, 0x30, 0x48, 0x36, 0x3F,
  0xC2, 0x41, 0xB0, 0x48, 0x12, 0x00, 0x04, 0x04, 0x1E, 0x3F, 0x23, 0x63,
  0x63, 0x60, 0x38, 0x1C, 0x06, 0x02, 0x86, 0xC6, 0xFC, 0x78, 0x20, 0x20,
  0x70, 0x6C, 0x22, 0x51, 0x69, 0xA4, 0xA1, 0xA0, 0x3E, 0x15, 0x96, 0x5A,
  0x29, 0x10, 0xD0, 0x38, 0x1E, 0x1F, 0x0C, 0xC4, 0x42, 0x61, 0xE0, 0xE0,
  0xF3, 0xCD, 0x66, 0xA1, 0xD8, 0xCE, 0xF3, 0xD8, 0xFA, 0x80, 0x04, 0x31,
  0x84, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x04,
  0x18, 0x20, 0x10, 0x60, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08,
  0x21, 0x86, 0x30, 0xC6, 0x30, 0x80, 0x08, 0x08, 0x09, 0xFF, 0x18, 0x38,
  0x6C, 0x44, 0x0C, 0x08, 0x08, 0x18, 0xFF, 0xFF, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x6D, 0xE8, 0xF0, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x00, 0x1E, 0x37,
  0x63, 0x63, 0x43, 0x43, 0xC3, 0xC3, 0xC2, 0xC2, 0xC6, 0xC6, 0xFC, 0x78,
  0x08, 0xE7, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x21, 0x80, 0x0F,
  0x0D, 0xCC, 0x64, 0x30, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x06, 0x07, 0xF8, 0x1E, 0x36, 0x63, 0x63, 0x03, 0x02, 0x0E, 0x3C, 0x06,
  0x06, 0x86, 0x86, 0xFC, 0x78, 0x01, 0x81, 0xC1, 0xC0, 0xA0, 0xF0, 0xD8,
  0x4C, 0x66, 0x62, 0x21, 0x3F, 0xE0, 0xC0, 0x60, 0x30, 0x1F, 0x9F, 0x8C,
  0x04, 0x02, 0x03, 0xE1, 0xF8, 0x04, 0x03, 0x01, 0xB0, 0x98, 0xC6, 0xC1,
  0xC0, 0x0E, 0x1E, 0x30, 0x20, 0x60, 0x5C, 0x7E, 0xC2, 0xC2, 0xC2, 0xC2,
  0xC6, 0x6C, 0x38, 0x7F, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x00, 0x1E, 0x3F, 0x63, 0x63, 0x63,
  0x36, 0x3C, 0x66, 0xC6, 0xC6, 0x86, 0xC6, 0xFC, 0x78, 0x1C, 0x36, 0x63,
  0x43, 0x43, 0x43, 0x47, 0x7E, 0x3A, 0x06, 0x04, 0x0C, 0x78, 0x70, 0x33,
  0x00, 0x00, 0x00, 0x06, 0x40, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x18,
  0xC4, 0x60, 0x02, 0x1C, 0xF7, 0x8C, 0x1C, 0x0E, 0x0E, 0x04, 0x7F, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0xFE, 0x40, 0xE0, 0xE0, 0x70, 0x63, 0xDE, 0x70,
  0x80, 0x39, 0xFC, 0xE3, 0x0C, 0x61, 0x8C, 0x61, 0x00, 0x00, 0xC3, 0x00,
  0x07, 0xC0, 0x61, 0x86, 0x04, 0x60, 0x36, 0x38, 0xA3, 0x65, 0x32, 0x39,
  0x11, 0x88, 0x8C, 0xCC, 0x66, 0x65, 0x32, 0x29, 0xBB, 0x46, 0x72, 0x00,
  0x18, 0x00, 0x63, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x40,
  0x68, 0x09, 0x83, 0x30, 0x46, 0x1F, 0xC3, 0xF8, 0xC1, 0x10, 0x26, 0x06,
  0x80, 0xC0, 0x1F, 0x87, 0xF3, 0x0C, 0xC3, 0x30, 0xCF, 0xE3, 0xF0, 0x86,
  0x61, 0x98, 0x66, 0x19, 0x86, 0x7F, 0x1F, 0x80, 0x0F, 0x07, 0xE3, 0x0D,
  0x83, 0x60, 0xD0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x6C, 0x13, 0x0C, 0x7E,
  0x0F, 0x00, 0x1F, 0x07, 0xE3, 0x0C, 0xC1, 0x30, 0x4C, 0x13, 0x0C, 0x83,
  0x60, 0xD8, 0x36, 0x19, 0x86, 0x7F, 0x1F, 0x00, 0x1F, 0xC7, 0xF3, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xF0, 0xFC, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xF0, 0xFC,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x00, 0x0F, 0x0F, 0xE3, 0x0D,
  0x83, 0x60, 0x10, 0x0C, 0x7B, 0x1E, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0x7F,
  0x0F, 0x80, 0x18, 0x31, 0x03, 0x30, 0x33, 0x02, 0x30, 0x63, 0x06, 0x3F,
  0xE3, 0xFE, 0x60, 0x46, 0x04, 0x60, 0xC6, 0x0C, 0x40, 0xC4, 0x0C, 0x33,
  0x26, 0x66, 0x64, 0x4C, 0xCC, 0xC8, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x04, 0x06, 0x03, 0x01, 0xB0, 0xD8, 0xC7, 0xE1, 0xE0, 0x18, 0x61,
  0x0C, 0x31, 0x83, 0x38, 0x37, 0x03, 0x60, 0x3C, 0x03, 0xE0, 0x76, 0x06,
  0x20, 0x63, 0x06, 0x30, 0x41, 0x84, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x7F, 0x7F, 0x18, 0x0E, 0x30,
  0x18, 0xE0, 0x71, 0xE0, 0xE3, 0xC3, 0xC7, 0x85, 0x89, 0x1A, 0x12, 0x24,
  0x64, 0xD8, 0xC9, 0x31, 0x9E, 0x63, 0x38, 0xC4, 0x71, 0x08, 0x46, 0x00,
  0x18, 0x31, 0x83, 0x38, 0x33, 0xC2, 0x34, 0x63, 0x46, 0x36, 0x62, 0x26,
  0x62, 0x46, 0x34, 0x61, 0xC6, 0x1C, 0x41, 0xC4, 0x0C, 0x0F, 0x0F, 0xE3,
  0x0D, 0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xB0, 0x6C, 0x1B, 0x0C,
  0x7F, 0x0F, 0x00, 0x1F, 0x83, 0xF8, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC,
  0x31, 0xFE, 0x7F, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x00, 0x0F,
  0x0F, 0xE3, 0x0D, 0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xB0, 0x6C,
  0x1B, 0x0C, 0x7F, 0x0F, 0x80, 0x30, 0x04, 0x1F, 0x87, 0xF3, 0x0C, 0xC3,
  0x30, 0xCC, 0x33, 0xF8, 0xFC, 0x63, 0x18, 0xC6, 0x31, 0x84, 0x41, 0x90,
  0x60, 0x0F, 0x07, 0xE3, 0x0C, 0xC3, 0x30, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x6C, 0x19, 0x86, 0x7F, 0x0F, 0x80, 0xFF, 0xFF, 0xC6, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x00, 0x20,
  0xD8, 0x36, 0x0D, 0x83, 0x60, 0x90, 0x64, 0x1B, 0x06, 0xC1, 0xB0, 0x6C,
  0x13, 0x0C, 0xFE, 0x0F, 0x00, 0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x11,
  0x84, 0x61, 0x10, 0x6C, 0x1A, 0x07, 0x81, 0xC0, 0x30, 0x0C, 0x00, 0xC3,
  0x0B, 0x1C, 0x6C, 0x71, 0xB1, 0xC4, 0xCF, 0x33, 0x2C, 0xCC, 0x92, 0x36,
  0x58, 0xD1, 0x63, 0xC5, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x00,
  0x30, 0x63, 0x18, 0x63, 0x0C, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0x40, 0xCC, 0x31, 0x86, 0x19, 0x83, 0x00, 0xC1, 0xE1, 0xB0, 0xC8,
  0xC6, 0x63, 0x60, 0xA0, 0x70, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x00,
  0x3F, 0xC7, 0xF8, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x0F, 0xF9, 0xFE, 0x00, 0x1C, 0x41, 0x0C, 0x30,
  0xC3, 0x08, 0x21, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x0E, 0x00, 0xCC,
  0xCC, 0x44, 0x46, 0x66, 0x62, 0x22, 0x30, 0x1C, 0x30, 0xC3, 0x08, 0x21,
  0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x20, 0x8E, 0x00, 0x18, 0x63,
  0x8A, 0x69, 0x2C, 0xC0, 0xFF, 0xCC, 0x80, 0x3C, 0xFD, 0x08, 0x33, 0xFC,
  0xF1, 0xC3, 0x8D, 0xF9, 0xD0, 0x10, 0x08, 0x0C, 0x06, 0x03, 0xF1, 0xF8,
  0xC6, 0x43, 0x61, 0xB0, 0xD8, 0x4C, 0x26, 0x37, 0xF3, 0x70, 0x3C, 0x76,
  0x42, 0xC2, 0xC0, 0xC0, 0x80, 0x86, 0xC4, 0xFC, 0x78, 0x01, 0x80, 0xC0,
  0x40, 0x23, 0xB3, 0xF9, 0x0D, 0x86, 0xC2, 0x41, 0x21, 0x90, 0xCC, 0x67,
  0xF1, 0xD0, 0x3C, 0xFD, 0x0E, 0x1C, 0x3F, 0xE0, 0x40, 0xC1, 0xD9, 0xE0,
  0x0C, 0x38, 0xC1, 0x8F, 0x84, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18,
  0x30, 0x00, 0x1C, 0x9F, 0xC8, 0x6C, 0x36, 0x13, 0x09, 0x0C, 0x86, 0x63,
  0x3F, 0x8E, 0x80, 0x40, 0x67, 0xE1, 0xE0, 0x10, 0x10, 0x30, 0x30, 0x3E,
  0x3F, 0x31, 0x21, 0x61, 0x63, 0x63, 0x63, 0x43, 0xC2, 0xC2, 0x10, 0x80,
  0x03, 0x18, 0x84, 0x63, 0x18, 0xC4, 0x23, 0x00, 0x04, 0x10, 0x00, 0x0C,
  0x30, 0x82, 0x18, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x33, 0x8E, 0x00, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x39, 0x98, 0x98, 0x58, 0x78, 0x3C, 0x1B, 0x0D,
  0x84, 0x42, 0x33, 0x18, 0x18, 0x84, 0x63, 0x18, 0xC4, 0x23, 0x18, 0xC4,
  0x23, 0x00, 0x3E, 0x78, 0xFF, 0xE2, 0x18, 0x98, 0x43, 0x61, 0x09, 0x8C,
  0x26, 0x31, 0x98, 0xC6, 0x43, 0x1B, 0x08, 0x6C, 0x21, 0x00, 0x3E, 0x3F,
  0x31, 0x61, 0x61, 0x63, 0x63, 0x63, 0x43, 0xC2, 0xC2, 0x3C, 0x76, 0x43,
  0xC3, 0xC3, 0xC3, 0x83, 0x82, 0xC6, 0xEC, 0x78, 0x3F, 0x1F, 0x88, 0x6C,
  0x36, 0x1B, 0x0D, 0x84, 0x86, 0x43, 0x7F, 0x37, 0x18, 0x0C, 0x04, 0x02,
  0x00, 0x3B, 0x77, 0x43, 0xC3, 0xC2, 0x86, 0x86, 0x86, 0xC6, 0xEE, 0x74,
  0x0C, 0x0C, 0x0C, 0x0C, 0x3C, 0xF3, 0x18, 0x61, 0x86, 0x18, 0x43, 0x0C,
  0x00, 0x1E, 0x3F, 0x23, 0x20, 0x30, 0x1C, 0x06, 0x02, 0x42, 0x7E, 0x3C,
  0x31, 0x3E, 0xC6, 0x31, 0x88, 0x46, 0x31, 0xC6, 0x00, 0x63, 0x43, 0x43,
  0xC2, 0xC2, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0x74, 0xC2, 0xC6, 0x46, 0x4C,
  0x4C, 0x48, 0x58, 0x70, 0x70, 0x70, 0x20, 0xC6, 0x3C, 0x62, 0xCE, 0x64,
  0xA6, 0x4A, 0x45, 0xAC, 0x52, 0x87, 0x28, 0x63, 0x86, 0x30, 0x63, 0x00,
  0x23, 0x19, 0x8D, 0x82, 0x81, 0xC0, 0xC0, 0x60, 0x78, 0x6C, 0x22, 0x31,
  0x80, 0x31, 0x8C, 0x63, 0x10, 0x4C, 0x13, 0x05, 0x81, 0x60, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x40, 0x30, 0x38, 0x0E, 0x00, 0x3F, 0x03, 0x06, 0x06,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xFE, 0x04, 0x61, 0x0C, 0x30, 0xC3,
  0x08, 0x63, 0x8C, 0x10, 0x61, 0x04, 0x10, 0x41, 0x06, 0x08, 0x11, 0x13,
  0x33, 0x22, 0x26, 0x66, 0x44, 0x44, 0xC0, 0x10, 0x60, 0x82, 0x08, 0x20,
  0x86, 0x08, 0x30, 0xC6, 0x10, 0xC3, 0x0C, 0x30, 0x86, 0x20, 0x30, 0xBC,
  0x73, 0xF0, 0xE0,
};

const GFXglyph RobotoCondensed_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 5, 1, -14 },
  { 8, 5, 5, 6, 2, -15 },
  { 12, 10, 14, 11, 1, -14 },
  { 30, 8, 18, 10, 1, -16 },
  { 48, 9, 14, 12, 2, -14 },
  { 64, 9, 14, 11, 1, -14 },
  { 80, 2, 5, 3, 2, -15 },
  { 82, 6, 21, 6, 1, -16 },
  { 98, 6, 21, 6, -1, -16 },
  { 114, 8, 8, 8, 1, -14 },
  { 122, 8, 11, 10, 1, -12 },
  { 133, 3, 5, 4, -1, -2 },
  { 135, 5, 1, 5, 0, -6 },
  { 136, 2, 2, 5, 1, -2 },
  { 137, 9, 15, 7, -1, -14 },
  { 154, 8, 14, 10, 1, -14 },
  { 168, 6, 14, 10, 2, -14 },
  { 179, 9, 14, 10, 0, -14 },
  { 195, 8, 14, 10, 1, -14 },
  { 209, 9, 14, 10, 0, -14 },
  { 225, 9, 14, 10, 1, -14 },
  { 241, 8, 14, 10, 1, -14 },
  { 255, 9, 14, 10, 1, -14 },
  { 271, 8, 14, 10, 1, -14 },
  { 285, 8, 14, 10, 1, -14 },
  { 299, 4, 11, 5, 0, -11 },
  { 305, 5, 14, 4, -1, -11 },
  { 314, 7, 9, 9, 1, -11 },
  { 322, 8, 7, 9, 1, -10 },
  { 329, 7, 9, 9, 1, -11 },
  { 337, 6, 14, 8, 2, -14 },
  { 348, 13, 18, 15, 1, -14 },
  { 378, 11, 14, 11, -1, -14 },
  { 398, 10, 14, 11, 0, -14 },
  { 416, 10, 14, 11, 1, -14 },
  { 434, 10, 14, 11, 0, -14 },
  { 452, 10, 14, 10, 0, -14 },
  { 470, 10, 14, 9, 0, -14 },
  { 488, 10, 14, 11, 1, -14 },
  { 506, 12, 14, 12, 0, -14 },
  { 527, 4, 14, 5, 1, -14 },
  { 534, 9, 14, 9, 0, -14 },
  { 550, 12, 14, 11, 0, -14 },
  { 571, 8, 14, 9, 0, -14 },
  { 585, 15, 14, 15, 0, -14 },
  { 612, 12, 14, 12, 0, -14 },
  { 633, 10, 14, 12, 1, -14 },
  { 651, 11, 14, 11, 0, -14 },
  { 671, 10, 16, 12, 1, -14 },
  { 691, 10, 14, 10, 0, -14 },
  { 709, 10, 14, 10, 0, -14 },
  { 727, 9, 14, 10, 2, -14 },
  { 743, 10, 14, 11, 1, -14 },
  { 761, 10, 14, 11, 2, -14 },
  { 779, 14, 14, 15, 2, -14 },
  { 804, 11, 14, 11, 0, -14 },
  { 824, 9, 14, 10, 2, -14 },
  { 840, 11, 14, 10, 0, -14 },
  { 860, 6, 19, 5, 0, -16 },
  { 875, 4, 15, 7, 2, -14 },
  { 883, 6, 19, 5, -1, -16 },
  { 898, 6, 7, 7, 1, -14 },
  { 904, 8, 1, 8, -1, 0 },
  { 905, 3, 3, 6, 2, -15 },
  { 907, 7, 11, 9, 1, -11 },
  { 917, 9, 15, 10, 0, -15 },
  { 934, 8, 11, 9, 1, -11 },
  { 945, 9, 15, 10, 1, -15 },
  { 962, 7, 11, 9, 1, -11 },
  { 972, 7, 15, 6, 1, -15 },
  { 986, 9, 15, 10, 0, -11 },
  { 1003, 8, 15, 9, 0, -15 },
  { 1018, 5, 15, 4, 0, -15 },
  { 1028, 6, 19, 4, -2, -15 },
  { 1043, 9, 15, 9, 0, -15 },
  { 1060, 5, 15, 4, 0, -15 },
  { 1070, 14, 11, 15, 0, -11 },
  { 1090, 8, 11, 9, 0, -11 },
  { 1101, 8, 11, 10, 1, -11 },
  { 1112, 9, 15, 10, 0, -11 },
  { 1129, 8, 15, 10, 1, -11 },
  { 1144, 6, 11, 6, 0, -11 },
  { 1153, 8, 11, 9, 0, -11 },
  { 1164, 5, 13, 6, 1, -13 },
  { 1173, 8, 11, 9, 1, -11 },
  { 1184, 8, 11, 8, 1, -11 },
  { 1195, 12, 11, 13, 1, -11 },
  { 1212, 9, 11, 9, 0, -11 },
  { 1225, 10, 15, 8, -1, -11 },
  { 1244, 8, 11, 9, 0, -11 },
  { 1255, 6, 20, 6, 1, -16 },
  { 1270, 4, 17, 5, 0, -14 },
  { 1279, 6, 20, 6, -1, -16 },
  { 1294, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_Italic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_ITALIC20PT7B_H_
