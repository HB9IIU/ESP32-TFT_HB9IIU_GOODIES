#ifndef _ROBOTOCONDENSED_ITALIC72PT7B_H_
#define _ROBOTOCONDENSED_ITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0,
  0x01, 0xC0, 0x00, 0x1F, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x40, 0xF8, 0x0F, 0x00, 0x38, 0xF8, 0x07, 0x80, 0x3E, 0x7C, 0x03,
  0xC0, 0x3E, 0x3E, 0x01, 0xE0, 0x1F, 0x1E, 0x00, 0xF0, 0x1F, 0x0F, 0x00,
  0x78, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x81, 0xE0,
  0x1F, 0x0F, 0x80, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0x87, 0xC0, 0x3E,
  0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC3, 0xE0, 0x07, 0xFF, 0xE3, 0xE0, 0x01,
  0xFF, 0xE3, 0xE0, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0x1F, 0xC1, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x3F,
  0x80, 0x00, 0x7C, 0x7F, 0xF0, 0x00, 0x7C, 0x7F, 0xF8, 0x00, 0x3E, 0x3F,
  0xFE, 0x00, 0x3E, 0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x07, 0xC0, 0x1F, 0x1F,
  0x01, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x0F, 0x0F, 0x80,
  0xF0, 0x07, 0x87, 0xC0, 0x78, 0x03, 0xC7, 0xC0, 0x3C, 0x03, 0xE7, 0xC0,
  0x1E, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0xF8, 0xE0, 0x07, 0xC0, 0xF8, 0x20,
  0x01, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xF8,
  0x3F, 0x9F, 0x80, 0xFC, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0x3E,
  0x3F, 0x81, 0xFC, 0x1F, 0x1F, 0xC0, 0x7E, 0x1F, 0x9F, 0xC0, 0x3F, 0x8F,
  0xCF, 0xE0, 0x0F, 0xC7, 0xC7, 0xE0, 0x07, 0xF7, 0xE7, 0xF0, 0x01, 0xFB,
  0xF3, 0xF8, 0x00, 0xFF, 0xF1, 0xFC, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x1F,
  0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x7F, 0x01, 0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x0F, 0x80, 0x03,
  0x80, 0xF8, 0x0E, 0x7E, 0x0F, 0x87, 0xE7, 0xFC, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x3E, 0x00, 0x0F, 0xE3, 0xF0,
  0x01, 0xFC, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0x38, 0x01, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xEF, 0xCF, 0xF1, 0xF1, 0xF0, 0x7E,
  0x38, 0x0F, 0xC4, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x1F, 0xC0,
  0x00, 0x3E, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x0E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xDF, 0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC7, 0xFC, 0x7F, 0xE0, 0x3F, 0x8F, 0xF8, 0x03,
  0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xC3,
  0xF8, 0x0F, 0xF8, 0x7F, 0xCF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xBF, 0x00, 0xFF, 0xE7, 0xE0, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x01,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0x80,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xC0, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xE0,
  0x7C, 0x01, 0xF8, 0x0F, 0x80, 0xF0, 0x3C, 0x01, 0xF8, 0x0F, 0x80, 0x3C,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC3, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xE3, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x78, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x3E, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x9F, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x8F, 0x80, 0xFC, 0x01, 0xF0,
  0x03, 0xC7, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xE3, 0xC0, 0x3E, 0x00, 0x7C,
  0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF1, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x0F,
  0xE0, 0x1E, 0x0F, 0x80, 0x7E, 0x0F, 0xF0, 0x1F, 0x07, 0xC0, 0x3F, 0x8F,
  0xF8, 0x1F, 0x01, 0xE0, 0x0F, 0xFF, 0x3F, 0x3F, 0x00, 0xF0, 0x07, 0xFF,
  0x9F, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3C, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xF7, 0x7F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF,
  0xF8, 0xFC, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xFF, 0xE7, 0xF0, 0x03,
  0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x07, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xE7,
  0xF8, 0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xBF, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x01, 0xFD, 0xF8, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0x83,
  0xF0, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7C,
  0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0x7E, 0x01,
  0xF9, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xEF, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7D, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x1F,
  0xDF, 0x00, 0x07, 0xF0, 0x0F, 0xCF, 0xC0, 0x03, 0xF8, 0x07, 0xE7, 0xE0,
  0x01, 0xF8, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0x7E,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x00, 0xFE, 0x1F, 0x00, 0x3F, 0x80, 0x7E,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFE, 0x00, 0xFC,
  0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x0F, 0xE0,
  0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE0,
  0x01, 0xF1, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0xFC, 0x03, 0xF8, 0x00, 0x7E,
  0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xBF, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x01, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x83,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xC0,
  0xFC, 0x01, 0xFB, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x1E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x3E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x0F, 0x87,
  0xE0, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x03, 0xE1,
  0xF0, 0x00, 0xFC, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0xF8,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x1E,
  0x7E, 0x00, 0x07, 0xCF, 0x80, 0x0F, 0x3F, 0x00, 0x03, 0xEF, 0x80, 0x07,
  0x9F, 0x00, 0x01, 0xF7, 0xC0, 0x03, 0xDF, 0x80, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F,
  0x8F, 0x80, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C,
  0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x3F,
  0xC0, 0x0F, 0xC7, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xBF, 0x01, 0xFF, 0xF3, 0xF0, 0x0F, 0xFC, 0x3F, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xF1, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xCF, 0xFF,
  0xF8, 0x3F, 0x3F, 0xFF, 0xC0, 0xFC, 0x7F, 0xFE, 0x03, 0xF0, 0x7F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x1F,
  0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x9F, 0x80, 0x00, 0xFF, 0xC7, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x60, 0x3F, 0x00, 0x1F, 0x03, 0xFC, 0x03, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xC0, 0x0F, 0xFF, 0xC7, 0xE0,
  0x0F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x3F, 0x00,
  0x03, 0xFF, 0x3F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x80, 0x01, 0xFC, 0x00, 0xE0, 0x01, 0xFC,
  0x00, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF1, 0xFF, 0x80, 0x1F, 0xBF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x03,
  0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x03, 0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x07, 0xE0, 0x7F,
  0x80, 0x07, 0xE0, 0xFF, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF1, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xF7, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0x8F, 0xFC, 0x00, 0xFD, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFF, 0x01, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x1F, 0xBF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFE, 0x00, 0xFC, 0x7F, 0xFE, 0x00,
  0x7E, 0x1F, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0xFC, 0x03, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF,
  0xEF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xCF,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0xCF, 0xF0, 0x3F, 0x7F, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE0,
  0x01, 0xFB, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xE0, 0x07, 0xE3, 0xF0,
  0x07, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0xFF,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x7C, 0x07,
  0xE0, 0x7C, 0x07, 0xDF, 0x01, 0xF8, 0x1F, 0x03, 0xF7, 0xC0, 0xFC, 0x07,
  0xC0, 0xF9, 0xF0, 0x3F, 0x01, 0xF0, 0x7E, 0x7C, 0x0F, 0x80, 0x7C, 0x1F,
  0x1F, 0x07, 0xE0, 0x1F, 0x0F, 0xC7, 0xC1, 0xF0, 0x07, 0xC3, 0xE1, 0xF0,
  0xFC, 0x01, 0xF0, 0xF8, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x0F, 0x8F, 0x80,
  0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0xF9, 0xF0, 0x01, 0xFB,
  0xE0, 0x3E, 0x7C, 0x00, 0x7F, 0xF8, 0x0F, 0xBF, 0x00, 0x1F, 0xFC, 0x03,
  0xEF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFB, 0xF8, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xF0, 0xFF, 0xF0, 0x00, 0x78, 0x7F, 0xFE, 0x00, 0x3E, 0x3F, 0xFF, 0xC0,
  0x0F, 0x8F, 0xFF, 0xF8, 0x07, 0xE7, 0xF0, 0xFF, 0x01, 0xF1, 0xF8, 0x1F,
  0xE0, 0xFC, 0xFC, 0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0x8F, 0x80,
  0x0F, 0xFF, 0xC3, 0xE0, 0x01, 0xFF, 0xE0, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 15, 52, 17, 2, -51 },
  { 99, 17, 17, 22, 7, -54 },
  { 136, 36, 51, 38, 3, -51 },
  { 366, 30, 68, 34, 3, -60 },
  { 621, 33, 53, 44, 7, -52 },
  { 840, 33, 53, 38, 2, -52 },
  { 1059, 8, 17, 12, 6, -54 },
  { 1076, 21, 74, 22, 4, -58 },
  { 1271, 21, 75, 22, -3, -58 },
  { 1468, 28, 30, 30, 4, -51 },
  { 1573, 30, 37, 35, 3, -42 },
  { 1712, 12, 18, 14, -4, -8 },
  { 1739, 15, 5, 17, 1, -24 },
  { 1749, 8, 8, 18, 2, -7 },
  { 1757, 32, 55, 26, -3, -51 },
  { 1977, 29, 53, 34, 4, -52 },
  { 2170, 19, 51, 34, 8, -51 },
  { 2292, 32, 52, 34, 1, -52 },
  { 2500, 30, 53, 34, 2, -52 },
  { 2699, 32, 51, 34, 0, -51 },
  { 2903, 31, 52, 34, 4, -51 },
  { 3105, 27, 52, 34, 4, -51 },
  { 3281, 31, 51, 34, 5, -51 },
  { 3479, 31, 53, 34, 2, -52 },
  { 3685, 27, 52, 34, 5, -52 },
  { 3861, 13, 39, 17, 2, -38 },
  { 3925, 17, 48, 15, -3, -38 },
  { 4027, 26, 32, 31, 3, -39 },
  { 4131, 27, 21, 33, 4, -35 },
  { 4202, 28, 32, 32, 2, -39 },
  { 4314, 24, 53, 30, 6, -52 },
  { 4473, 49, 66, 54, 2, -50 },
  { 4878, 37, 51, 40, -2, -51 },
  { 5114, 34, 51, 38, 2, -51 },
  { 5331, 35, 53, 40, 4, -52 },
  { 5563, 36, 51, 40, 2, -51 },
  { 5793, 35, 51, 35, 2, -51 },
  { 6017, 34, 51, 34, 2, -51 },
  { 6234, 35, 53, 41, 4, -52 },
  { 6466, 41, 51, 43, 2, -51 },
  { 6728, 15, 51, 17, 2, -51 },
  { 6824, 34, 52, 34, 0, -51 },
  { 7045, 40, 51, 38, 2, -51 },
  { 7300, 26, 51, 33, 2, -51 },
  { 7466, 51, 51, 53, 2, -51 },
  { 7792, 41, 51, 43, 2, -51 },
  { 8054, 36, 53, 42, 4, -52 },
  { 8293, 37, 51, 39, 2, -51 },
  { 8529, 35, 61, 42, 4, -52 },
  { 8796, 35, 51, 37, 2, -51 },
  { 9020, 34, 53, 36, 2, -52 },
  { 9246, 34, 51, 36, 6, -51 },
  { 9463, 37, 52, 39, 3, -51 },
  { 9704, 37, 51, 39, 6, -51 },
  { 9940, 49, 51, 53, 7, -51 },
  { 10253, 42, 51, 39, -1, -51 },
  { 10521, 35, 51, 37, 6, -51 },
  { 10745, 39, 51, 37, -1, -51 },
  { 10994, 22, 70, 18, 0, -59 },
  { 11187, 13, 55, 26, 7, -51 },
  { 11277, 22, 70, 18, -4, -59 },
  { 11470, 21, 26, 26, 3, -51 },
  { 11539, 28, 5, 28, -4, 0 },
  { 11557, 13, 10, 22, 7, -54 },
  { 11574, 28, 40, 33, 2, -39 },
  { 11714, 30, 55, 34, 1, -54 },
  { 11921, 29, 40, 32, 2, -39 },
  { 12066, 34, 55, 35, 2, -54 },
  { 12300, 28, 40, 33, 2, -39 },
  { 12440, 23, 55, 22, 4, -55 },
  { 12599, 33, 54, 34, 0, -39 },
  { 12822, 29, 54, 34, 1, -54 },
  { 13018, 15, 52, 16, 1, -52 },
  { 13116, 23, 67, 16, -7, -52 },
  { 13309, 32, 54, 31, 1, -54 },
  { 13525, 16, 54, 16, 1, -54 },
  { 13633, 48, 39, 53, 1, -39 },
  { 13867, 29, 39, 34, 1, -39 },
  { 14009, 30, 40, 35, 2, -39 },
  { 14159, 33, 54, 34, -2, -39 },
  { 14382, 31, 54, 35, 2, -39 },
  { 14592, 22, 39, 21, 1, -39 },
  { 14700, 27, 40, 32, 2, -39 },
  { 14835, 18, 48, 21, 3, -47 },
  { 14943, 29, 39, 34, 3, -38 },
  { 15085, 27, 38, 30, 4, -38 },
  { 15214, 42, 38, 45, 5, -38 },
  { 15414, 33, 38, 31, -2, -38 },
  { 15571, 34, 53, 29, -3, -38 },
  { 15797, 30, 38, 31, 0, -38 },
  { 15940, 23, 69, 21, 2, -56 },
  { 16139, 15, 61, 17, 1, -51 },
  { 16254, 22, 69, 21, -3, -56 },
  { 16444, 34, 14, 41, 4, -28 },
};

const GFXfont RobotoCondensed_Italic72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_ITALIC72PT7B_H_
