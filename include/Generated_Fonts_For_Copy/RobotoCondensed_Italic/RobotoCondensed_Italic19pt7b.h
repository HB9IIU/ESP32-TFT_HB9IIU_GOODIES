#ifndef _ROBOTOCONDENSED_ITALIC19PT7B_H_
#define _ROBOTOCONDENSED_ITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x22, 0x66, 0x66, 0x44, 0xCC, 0x00, 0x88, 0x5D, 0x99, 0xA0, 0x04,
  0x86, 0xC2, 0x41, 0x27, 0xF8, 0x90, 0x48, 0x6C, 0x24, 0x7F, 0x99, 0x09,
  0x04, 0x82, 0x40, 0x04, 0x0C, 0x1C, 0x3E, 0x63, 0x63, 0x60, 0x60, 0x38,
  0x1C, 0x06, 0x06, 0x86, 0x86, 0xFC, 0x78, 0x20, 0x20, 0x70, 0xD0, 0x91,
  0x92, 0x94, 0x6C, 0x08, 0x10, 0x37, 0x29, 0x49, 0xC9, 0x09, 0x0E, 0x1C,
  0x36, 0x22, 0x26, 0x26, 0x3C, 0x30, 0x78, 0xD9, 0x8F, 0x8E, 0x86, 0xCE,
  0x7B, 0xEA, 0x04, 0x21, 0x0C, 0x21, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0x82,
  0x0C, 0x30, 0x41, 0x82, 0x00, 0x10, 0x60, 0x82, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0x82, 0x18, 0x61, 0x0C, 0x61, 0x08, 0x00, 0x08, 0x30, 0x6F, 0xF3,
  0x85, 0x12, 0x24, 0x08, 0x18, 0x18, 0x18, 0xFF, 0xFE, 0x10, 0x30, 0x30,
  0x30, 0x6D, 0xE8, 0xF0, 0x48, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x00, 0x1C, 0x36,
  0x62, 0x43, 0x43, 0xC2, 0xC2, 0xC2, 0xC6, 0xC6, 0x86, 0xC4, 0xCC, 0x78,
  0x0B, 0xFE, 0x31, 0x08, 0x46, 0x31, 0x88, 0x46, 0x30, 0x0E, 0x1D, 0x8C,
  0x64, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x07,
  0xF8, 0x1C, 0x36, 0x62, 0x42, 0x02, 0x06, 0x0C, 0x38, 0x04, 0x06, 0x86,
  0x84, 0xDC, 0x78, 0x03, 0x03, 0x07, 0x0F, 0x0B, 0x1B, 0x12, 0x22, 0x66,
  0x46, 0xFF, 0x06, 0x04, 0x04, 0x3F, 0x3F, 0x20, 0x20, 0x60, 0x7C, 0x7E,
  0x06, 0x02, 0x02, 0xC6, 0xC6, 0x6C, 0x78, 0x0E, 0x38, 0xC3, 0x06, 0x0B,
  0xB9, 0xE3, 0xC7, 0x8F, 0x1E, 0x26, 0xCF, 0x00, 0x7F, 0x00, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x00,
  0x1C, 0x36, 0x63, 0x63, 0x62, 0x26, 0x38, 0x44, 0xC6, 0x86, 0x86, 0x84,
  0xCC, 0x78, 0x1C, 0x6D, 0x8A, 0x1C, 0x38, 0x51, 0xB7, 0x3E, 0x08, 0x10,
  0x63, 0x8C, 0x00, 0x33, 0x00, 0x00, 0x00, 0x44, 0x18, 0xC0, 0x00, 0x00,
  0x00, 0x23, 0x18, 0x8C, 0x00, 0x02, 0x18, 0xE7, 0x0C, 0x0E, 0x07, 0x04,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x40, 0xE0, 0xE0, 0x70, 0xE7,
  0x38, 0x40, 0x7B, 0xF8, 0xC3, 0x0C, 0x63, 0x18, 0x61, 0x00, 0x00, 0xC3,
  0x00, 0x07, 0xC0, 0xC6, 0x10, 0x32, 0x01, 0x67, 0x94, 0xC9, 0xC8, 0x99,
  0x99, 0x99, 0x19, 0x11, 0x93, 0x29, 0xB2, 0x9D, 0xC8, 0x00, 0xC0, 0x06,
  0x20, 0x3E, 0x00, 0x01, 0x00, 0xE0, 0x38, 0x1E, 0x04, 0x83, 0x20, 0x88,
  0x62, 0x18, 0xCF, 0xF3, 0x0C, 0x83, 0x60, 0xD0, 0x10, 0x1F, 0x04, 0x63,
  0x0C, 0xC3, 0x31, 0x8C, 0xE3, 0xF0, 0x84, 0x61, 0x98, 0x66, 0x19, 0x8C,
  0x47, 0x1F, 0x80, 0x0F, 0x1D, 0xC8, 0x6C, 0x14, 0x0A, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x58, 0x66, 0x61, 0xE0, 0x1F, 0x04, 0xE3, 0x08, 0xC3,
  0x30, 0xCC, 0x32, 0x0C, 0x83, 0x60, 0x98, 0x66, 0x19, 0x8C, 0x4E, 0x1F,
  0x00, 0x1F, 0xC4, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0xFC, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x1F, 0xC0, 0x1F, 0xC4, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0xFC, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x00, 0x1F, 0x1D, 0xC8, 0x6C, 0x14, 0x02, 0x03, 0x01, 0x8F, 0xC1, 0xE0,
  0xB0, 0x58, 0x67, 0xF1, 0xE0, 0x10, 0x22, 0x0C, 0xC1, 0x98, 0x33, 0x06,
  0x60, 0x88, 0x11, 0xFE, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x44, 0x08, 0x83,
  0x00, 0x22, 0x66, 0x66, 0x44, 0xCC, 0xCC, 0x88, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x30, 0x98, 0xC6, 0xC1, 0xC0,
  0x10, 0x62, 0x18, 0xC6, 0x19, 0x83, 0x60, 0x78, 0x0F, 0x01, 0xE0, 0x76,
  0x0C, 0xC1, 0x8C, 0x31, 0x84, 0x30, 0x83, 0x00, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x7E, 0x18, 0x0C,
  0x60, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x28, 0xB1, 0xE2, 0xC5, 0x8B, 0x36,
  0x64, 0x91, 0x96, 0x46, 0x53, 0x19, 0xCC, 0x46, 0x31, 0x18, 0xC0, 0x18,
  0x23, 0x0C, 0xE1, 0x9E, 0x33, 0xC6, 0x68, 0x89, 0x11, 0x36, 0x62, 0xCC,
  0x59, 0x8F, 0x30, 0xC4, 0x18, 0x83, 0x00, 0x0F, 0x1D, 0xC8, 0x6C, 0x14,
  0x0A, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x58, 0x67, 0xE1, 0xE0, 0x1F,
  0x84, 0x73, 0x0C, 0xC1, 0x30, 0xCC, 0x32, 0x0C, 0x8E, 0x7F, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x00, 0x1F, 0x1D, 0xC8, 0x6C, 0x14, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x58, 0x67, 0xE1, 0xF0, 0x18, 0x04, 0x1F,
  0x04, 0x63, 0x0C, 0xC3, 0x30, 0xCC, 0x62, 0x38, 0xF8, 0x62, 0x18, 0x86,
  0x31, 0x8C, 0x43, 0x10, 0x40, 0x0F, 0x06, 0xE3, 0x08, 0xC3, 0x30, 0x0C,
  0x01, 0xC0, 0x3C, 0x03, 0x00, 0x4C, 0x11, 0x0C, 0x77, 0x0F, 0x00, 0xFF,
  0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x60, 0xD8, 0x26, 0x09, 0x86, 0x41, 0x90, 0x6C, 0x1B, 0x04, 0xC1,
  0x30, 0xCC, 0x33, 0x08, 0xEE, 0x1F, 0x00, 0x81, 0xE0, 0xF0, 0xD8, 0x6C,
  0x26, 0x31, 0x10, 0x98, 0x48, 0x2C, 0x1E, 0x0E, 0x07, 0x01, 0x00, 0xC6,
  0x1E, 0x30, 0xB1, 0x8D, 0x9C, 0x6C, 0xA2, 0x65, 0x33, 0x69, 0x9A, 0x48,
  0xD3, 0xC7, 0x9E, 0x38, 0xE1, 0xC7, 0x0C, 0x18, 0x60, 0x80, 0x30, 0xC6,
  0x18, 0x66, 0x0C, 0xC0, 0xB0, 0x1C, 0x03, 0x80, 0x60, 0x1E, 0x03, 0xC0,
  0xC8, 0x31, 0x86, 0x31, 0x82, 0x00, 0xC1, 0xE1, 0xB1, 0x88, 0xC4, 0xC3,
  0x61, 0xE0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x00, 0x3F, 0xC0,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0xC0, 0x3F, 0xC0, 0x1C, 0x43, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x86,
  0x18, 0x41, 0x0C, 0x30, 0xC3, 0x80, 0x9B, 0x6C, 0x92, 0x4D, 0xB2, 0x48,
  0x1C, 0x30, 0x82, 0x08, 0x61, 0x86, 0x10, 0x41, 0x0C, 0x30, 0xC3, 0x08,
  0x23, 0x80, 0x11, 0xCE, 0x54, 0xA7, 0x20, 0xFE, 0xCC, 0x80, 0x1E, 0x33,
  0x23, 0x03, 0x3F, 0x62, 0x42, 0x46, 0x6E, 0x7E, 0x10, 0x30, 0x30, 0x30,
  0x3E, 0x3B, 0x21, 0x61, 0x61, 0x63, 0x43, 0x43, 0xF6, 0xDC, 0x3C, 0xCF,
  0x1E, 0x18, 0x10, 0x20, 0x42, 0xCC, 0xF0, 0x01, 0x01, 0x03, 0x03, 0x3B,
  0x6E, 0xC2, 0xC6, 0x86, 0x86, 0x86, 0x84, 0xDC, 0x74, 0x3C, 0xCF, 0x1E,
  0x3F, 0xF0, 0x20, 0x40, 0xCC, 0xF0, 0x1C, 0xE3, 0x08, 0xF9, 0x86, 0x18,
  0x61, 0x04, 0x30, 0xC3, 0x00, 0x1D, 0x9B, 0x98, 0x4C, 0x64, 0x32, 0x19,
  0x0C, 0x84, 0x6E, 0x1F, 0x01, 0x80, 0xCC, 0xC3, 0xC0, 0x10, 0x30, 0x30,
  0x30, 0x3E, 0x3B, 0x23, 0x63, 0x63, 0x63, 0x42, 0x42, 0xC6, 0xC6, 0x13,
  0x00, 0x32, 0x26, 0x66, 0x64, 0x4C, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x86,
  0x18, 0x61, 0x04, 0x10, 0xC3, 0x0C, 0xE3, 0x80, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x31, 0x30, 0xB0, 0xF0, 0x78, 0x34, 0x13, 0x09, 0x8C, 0x46, 0x30,
  0x11, 0x33, 0x32, 0x22, 0x66, 0x64, 0x4C, 0x2E, 0x71, 0xBD, 0xC8, 0xC6,
  0xC6, 0x36, 0x31, 0xB1, 0x89, 0x08, 0x48, 0x42, 0xC6, 0x36, 0x31, 0x80,
  0x2E, 0x3B, 0x23, 0x63, 0x63, 0x63, 0x42, 0x42, 0xC6, 0xC6, 0x3C, 0xCF,
  0x0E, 0x18, 0x30, 0x61, 0xC3, 0xCC, 0xF0, 0x2E, 0x3B, 0x21, 0x61, 0x61,
  0x63, 0x43, 0x43, 0xE6, 0xDC, 0xC0, 0xC0, 0x80, 0x80, 0x3B, 0x66, 0xC2,
  0xC6, 0x86, 0x86, 0x86, 0x84, 0xCC, 0x7C, 0x0C, 0x0C, 0x0C, 0x08, 0x2C,
  0xF2, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x00, 0x1E, 0x36, 0x23, 0x20, 0x38,
  0x0C, 0x06, 0xC6, 0x6E, 0x3C, 0x21, 0x3C, 0xC6, 0x21, 0x08, 0xC6, 0x38,
  0xC0, 0x42, 0x42, 0x46, 0xC6, 0xC6, 0xC6, 0x84, 0x8C, 0xDC, 0x7C, 0xC7,
  0x8F, 0x32, 0x64, 0x8B, 0x14, 0x38, 0x60, 0xC0, 0xC4, 0x79, 0x8F, 0x39,
  0x67, 0x65, 0xE8, 0xAD, 0x1C, 0xE3, 0x18, 0x63, 0x08, 0x40, 0x63, 0x26,
  0x36, 0x1C, 0x18, 0x18, 0x38, 0x6C, 0x4C, 0xC4, 0x31, 0x98, 0x8C, 0xC2,
  0x61, 0x60, 0xB0, 0x50, 0x38, 0x18, 0x0C, 0x04, 0x06, 0x0E, 0x07, 0x00,
  0x3F, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0, 0xFC, 0x08, 0x63,
  0x0C, 0x30, 0x82, 0x18, 0xC3, 0x04, 0x10, 0x41, 0x0C, 0x10, 0x40, 0x80,
  0x11, 0x33, 0x32, 0x22, 0x26, 0x64, 0x44, 0x44, 0xC0, 0x10, 0x60, 0x82,
  0x08, 0x61, 0x86, 0x0C, 0x31, 0x8C, 0x30, 0xC3, 0x08, 0x63, 0x00, 0x70,
  0xBC, 0xF3, 0xD0, 0xC0,
};

const GFXglyph RobotoCondensed_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 5, 1, -14 },
  { 8, 4, 5, 6, 2, -14 },
  { 11, 9, 14, 10, 1, -14 },
  { 27, 8, 18, 9, 1, -16 },
  { 45, 8, 14, 12, 2, -14 },
  { 59, 8, 14, 10, 1, -14 },
  { 73, 2, 4, 3, 2, -14 },
  { 74, 6, 19, 6, 1, -15 },
  { 89, 6, 19, 6, -1, -15 },
  { 104, 7, 8, 8, 1, -14 },
  { 111, 8, 10, 9, 1, -12 },
  { 121, 3, 5, 4, -1, -2 },
  { 123, 4, 1, 5, 0, -6 },
  { 124, 3, 2, 5, 0, -2 },
  { 125, 9, 15, 7, -1, -14 },
  { 142, 8, 14, 9, 1, -14 },
  { 156, 5, 14, 9, 2, -14 },
  { 165, 9, 14, 9, 0, -14 },
  { 181, 8, 14, 9, 1, -14 },
  { 195, 8, 14, 9, 0, -14 },
  { 209, 8, 14, 9, 1, -14 },
  { 223, 7, 14, 9, 1, -14 },
  { 236, 9, 14, 9, 1, -14 },
  { 252, 8, 14, 9, 1, -14 },
  { 266, 7, 14, 9, 1, -14 },
  { 279, 4, 10, 4, 0, -10 },
  { 284, 5, 13, 4, -1, -10 },
  { 293, 7, 8, 8, 1, -10 },
  { 300, 7, 7, 9, 1, -10 },
  { 307, 7, 8, 8, 1, -10 },
  { 314, 6, 14, 8, 2, -14 },
  { 325, 12, 17, 14, 1, -13 },
  { 351, 10, 14, 11, -1, -14 },
  { 369, 10, 14, 10, 0, -14 },
  { 387, 9, 14, 10, 1, -14 },
  { 403, 10, 14, 11, 0, -14 },
  { 421, 10, 14, 9, 0, -14 },
  { 439, 10, 14, 9, 0, -14 },
  { 457, 9, 14, 11, 1, -14 },
  { 473, 11, 14, 11, 0, -14 },
  { 493, 4, 14, 5, 1, -14 },
  { 500, 9, 14, 9, 0, -14 },
  { 516, 11, 14, 10, 0, -14 },
  { 536, 8, 14, 9, 0, -14 },
  { 550, 14, 14, 14, 0, -14 },
  { 575, 11, 14, 11, 0, -14 },
  { 595, 9, 14, 11, 1, -14 },
  { 611, 10, 14, 10, 0, -14 },
  { 629, 9, 16, 11, 1, -14 },
  { 647, 10, 14, 10, 0, -14 },
  { 665, 10, 14, 10, 0, -14 },
  { 683, 8, 14, 10, 2, -14 },
  { 697, 10, 14, 10, 1, -14 },
  { 715, 9, 14, 10, 2, -14 },
  { 731, 13, 14, 14, 2, -14 },
  { 754, 11, 14, 10, 0, -14 },
  { 774, 9, 14, 10, 2, -14 },
  { 790, 10, 14, 10, 0, -14 },
  { 808, 6, 18, 5, 0, -15 },
  { 822, 3, 15, 7, 2, -14 },
  { 828, 6, 18, 5, -1, -15 },
  { 842, 5, 7, 7, 1, -14 },
  { 847, 7, 1, 7, -1, 0 },
  { 848, 3, 3, 6, 2, -15 },
  { 850, 8, 10, 9, 0, -10 },
  { 860, 8, 14, 9, 0, -14 },
  { 874, 7, 10, 9, 1, -10 },
  { 883, 8, 14, 9, 1, -14 },
  { 897, 7, 10, 9, 1, -10 },
  { 906, 6, 14, 6, 1, -14 },
  { 917, 9, 14, 9, 0, -10 },
  { 933, 8, 14, 9, 0, -14 },
  { 947, 4, 14, 4, 0, -14 },
  { 954, 6, 18, 4, -2, -14 },
  { 968, 9, 14, 8, 0, -14 },
  { 984, 4, 14, 4, 0, -14 },
  { 991, 13, 10, 14, 0, -10 },
  { 1008, 8, 10, 9, 0, -10 },
  { 1018, 7, 10, 9, 1, -10 },
  { 1027, 8, 14, 9, 0, -10 },
  { 1041, 8, 14, 9, 1, -10 },
  { 1055, 6, 10, 6, 0, -10 },
  { 1063, 8, 10, 8, 0, -10 },
  { 1073, 5, 12, 5, 1, -12 },
  { 1081, 8, 10, 9, 1, -10 },
  { 1091, 7, 10, 8, 1, -10 },
  { 1100, 11, 10, 12, 1, -10 },
  { 1114, 8, 10, 8, 0, -10 },
  { 1124, 9, 14, 8, -1, -10 },
  { 1140, 8, 10, 8, 0, -10 },
  { 1150, 6, 18, 6, 1, -15 },
  { 1164, 4, 17, 5, 0, -14 },
  { 1173, 6, 18, 6, -1, -15 },
  { 1187, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_Italic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_ITALIC19PT7B_H_
