#ifndef _ROBOTOCONDENSED_ITALIC28PT7B_H_
#define _ROBOTOCONDENSED_ITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x80,
  0x00, 0x03, 0x0E, 0x30, 0x6D, 0x3C, 0xF3, 0xCB, 0x29, 0x80, 0x01, 0x8C,
  0x06, 0x30, 0x19, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0xC1, 0xFF, 0xCF, 0xFF,
  0x06, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x30, 0x7F, 0xF3, 0xFF, 0xC1, 0x98,
  0x0C, 0x60, 0x31, 0x80, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x7C, 0x0F, 0xE1, 0xCE, 0x18, 0x73, 0x87, 0x30, 0x73, 0x80,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0C, 0x00, 0xCC, 0x0C,
  0xC0, 0xCE, 0x1C, 0x73, 0xC7, 0xF8, 0x3E, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x07, 0xC0, 0xC4, 0x2C, 0x63, 0x84, 0x68, 0x4C, 0xCC, 0x8F, 0xD8,
  0x7B, 0x00, 0x60, 0x06, 0x00, 0xCE, 0x1B, 0xF1, 0xB3, 0x32, 0x16, 0x21,
  0xC6, 0x3C, 0x23, 0x03, 0xE0, 0x1C, 0x07, 0x80, 0x7E, 0x07, 0x38, 0x30,
  0xC1, 0x86, 0x0C, 0x70, 0x67, 0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0xEE, 0x76, 0x33, 0x71, 0xDB, 0x07, 0xD8, 0x3C, 0xE0, 0xC7, 0x0F, 0x1F,
  0xF8, 0x7C, 0xE0, 0x6D, 0xB6, 0xB0, 0x00, 0x81, 0xC1, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0x02, 0x00, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C,
  0x18, 0x30, 0x70, 0x60, 0xC0, 0x80, 0x03, 0x00, 0x60, 0x08, 0x23, 0x07,
  0x6E, 0xFF, 0xC3, 0xC0, 0xF0, 0x1B, 0x06, 0x61, 0xC6, 0x10, 0x80, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0xFF, 0xFF, 0xFE, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0xCE, 0x77, 0x31,
  0x00, 0x7D, 0xF0, 0xDF, 0x00, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0x07, 0x80, 0xFE, 0x1C, 0x63, 0x86, 0x30, 0x73, 0x07, 0x70,
  0x77, 0x07, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xE0,
  0xCE, 0x0C, 0x61, 0xC7, 0x38, 0x7F, 0x01, 0xE0, 0x02, 0x1E, 0x7E, 0x76,
  0xCE, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x03, 0xC0, 0x7F, 0x87, 0x1C, 0x30, 0x73, 0x83,
  0x9C, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xF9, 0xFF,
  0xC0, 0x07, 0x81, 0xFC, 0x38, 0xE3, 0x06, 0x30, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0xC0, 0xCC,
  0x0C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x01, 0xB8, 0x1D, 0x80, 0xCC, 0x0C, 0x60, 0xE7, 0x0E,
  0x38, 0x61, 0xC7, 0x0C, 0x7F, 0xFB, 0xFF, 0xC0, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0xC1, 0xCF, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x33, 0x83, 0x8C, 0x1C, 0x60, 0xC3, 0x8E, 0x0F, 0xE0, 0x3C,
  0x00, 0x01, 0xC0, 0xF8, 0x3C, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0xBC,
  0x7F, 0xCF, 0x19, 0xC3, 0xB0, 0x76, 0x0E, 0xC1, 0xD8, 0x3B, 0x06, 0x61,
  0xCE, 0x30, 0xFE, 0x0F, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x07,
  0xC0, 0xFE, 0x1C, 0xE1, 0x87, 0x38, 0x73, 0x07, 0x30, 0x63, 0x86, 0x18,
  0xC1, 0xFC, 0x3F, 0x87, 0x1C, 0x60, 0xCE, 0x0C, 0xC0, 0xCC, 0x0C, 0xE1,
  0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x0F, 0x0F, 0xE3, 0x1D, 0xC3, 0x60, 0xF8,
  0x3E, 0x0F, 0x03, 0xE0, 0xF8, 0x76, 0x3D, 0xFF, 0x3D, 0x80, 0x60, 0x38,
  0x0C, 0x07, 0x07, 0x87, 0xC1, 0xC0, 0x31, 0xCC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x73, 0x00, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0xC3, 0x1C, 0x63, 0x8C, 0x00, 0x00, 0x40, 0x70, 0x7C, 0x7C,
  0x7C, 0x3C, 0x0E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0x04, 0x3F, 0xE7,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x20, 0x07, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x70, 0x7C, 0x3E, 0x1F, 0x03, 0x80, 0x40,
  0x00, 0x1F, 0x0F, 0xE7, 0x39, 0x86, 0xE1, 0xC0, 0x60, 0x18, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07,
  0x01, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1C, 0x0E, 0x03, 0x00, 0x60,
  0xC0, 0x0C, 0x30, 0x00, 0x8C, 0x1E, 0x11, 0x87, 0xE3, 0x21, 0x8C, 0x6C,
  0x61, 0x8D, 0x8C, 0x21, 0xA1, 0x8C, 0x3C, 0x61, 0x85, 0x8C, 0x30, 0xB1,
  0x84, 0x36, 0x31, 0x86, 0xC6, 0x30, 0x98, 0xCE, 0x33, 0x1F, 0x7C, 0x61,
  0xCF, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x81, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x18,
  0x60, 0x70, 0xC0, 0xC1, 0xC3, 0xFF, 0x87, 0xFF, 0x1C, 0x06, 0x30, 0x0C,
  0xE0, 0x19, 0x80, 0x37, 0x00, 0x70, 0x1F, 0xE0, 0xFF, 0x86, 0x1E, 0x70,
  0x73, 0x81, 0x9C, 0x0C, 0xC0, 0xE6, 0x06, 0x30, 0xF3, 0xFF, 0x1F, 0xF8,
  0xE0, 0xC6, 0x07, 0x30, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x67, 0x0F, 0x3F,
  0xF1, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xE3, 0x87, 0x07, 0x38, 0x0C,
  0xC0, 0x33, 0x00, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0xE6, 0x03, 0x18, 0x0C, 0x70, 0x71, 0xE3, 0x83, 0xFC,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xC1, 0x87, 0x0E, 0x0E, 0x38, 0x18, 0xE0,
  0x63, 0x01, 0x8C, 0x06, 0x30, 0x19, 0xC0, 0x67, 0x01, 0x9C, 0x0E, 0x60,
  0x39, 0x80, 0xC6, 0x03, 0x38, 0x1C, 0xE0, 0xE3, 0x87, 0x0F, 0xF8, 0x3F,
  0x80, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0xFF, 0x1F, 0xF8, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0xC6, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0xFE, 0x1F, 0xF0, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xE3,
  0x86, 0x07, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x1F, 0x98, 0x7E, 0x60, 0x19, 0x80, 0xE6, 0x03, 0x98, 0x0E, 0x70,
  0x30, 0xE3, 0xC3, 0xFE, 0x03, 0xE0, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06,
  0x38, 0x06, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0C,
  0x7F, 0xFC, 0x7F, 0xFC, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18,
  0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x38, 0xC0, 0x30, 0x1C, 0x61,
  0x86, 0x38, 0xE3, 0x8C, 0x30, 0xC7, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x8C,
  0x30, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x73,
  0x83, 0x9C, 0x18, 0xE1, 0xC3, 0x9E, 0x1F, 0xE0, 0x3C, 0x00, 0x18, 0x0E,
  0x30, 0x38, 0x60, 0xE1, 0xC3, 0x83, 0x8E, 0x07, 0x3C, 0x0C, 0x70, 0x19,
  0xC0, 0x37, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xDC, 0x07, 0x38, 0x0C, 0x30,
  0x18, 0x70, 0x70, 0x60, 0xE0, 0xE1, 0xC1, 0xC3, 0x01, 0xC6, 0x03, 0x80,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0xFF, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x78, 0x07, 0x9F, 0x00, 0xF3, 0xE0,
  0x3E, 0x6C, 0x07, 0xCD, 0x81, 0xF1, 0xB0, 0x36, 0x36, 0x0E, 0xCE, 0xE1,
  0xB9, 0xCC, 0x77, 0x39, 0x8C, 0xC6, 0x33, 0x98, 0xC6, 0x63, 0x18, 0xDC,
  0x67, 0x1B, 0x1C, 0xE3, 0xE3, 0x9C, 0x38, 0x63, 0x07, 0x0C, 0x60, 0xC1,
  0x80, 0x1C, 0x07, 0x1C, 0x06, 0x1C, 0x06, 0x3E, 0x06, 0x3E, 0x06, 0x3E,
  0x0E, 0x37, 0x0E, 0x33, 0x0C, 0x33, 0x0C, 0x73, 0x8C, 0x71, 0x9C, 0x71,
  0x9C, 0x61, 0xDC, 0x60, 0xD8, 0x60, 0xD8, 0xE0, 0xF8, 0xE0, 0x78, 0xE0,
  0x78, 0xC0, 0x78, 0xC0, 0x30, 0x07, 0xC0, 0x7F, 0x87, 0x1C, 0x70, 0x77,
  0x01, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x0E, 0xE0, 0xE3, 0x8E, 0x1F, 0xE0,
  0x3E, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0x83, 0x8E, 0x07, 0x38, 0x1C, 0xE0,
  0x33, 0x01, 0xCC, 0x07, 0x30, 0x39, 0xC1, 0xE7, 0xFF, 0x1F, 0xF0, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xE3, 0x87, 0x07, 0x38, 0x0C, 0xC0, 0x37,
  0x00, 0xDC, 0x03, 0x70, 0x0D, 0x80, 0x76, 0x01, 0xD8, 0x07, 0xE0, 0x1B,
  0x80, 0x66, 0x03, 0x98, 0x0C, 0x70, 0x71, 0xE3, 0x83, 0xFC, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x02, 0x00, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x30,
  0x73, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x07, 0x30, 0x3B, 0x87, 0x9F, 0xF8,
  0xFF, 0x06, 0x1C, 0x30, 0xE1, 0x83, 0x1C, 0x18, 0xE0, 0xE7, 0x07, 0x30,
  0x19, 0x80, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0x1C, 0x70, 0x73, 0x03, 0x98,
  0x0C, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x33, 0x01, 0x98, 0x0C, 0xE0, 0xE7, 0x8E, 0x1F, 0xF0, 0x3E, 0x00,
  0x7F, 0xFB, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x18, 0x0E, 0x70,
  0x18, 0xE0, 0x31, 0xC0, 0x63, 0x01, 0xC6, 0x03, 0x8C, 0x07, 0x38, 0x0C,
  0x70, 0x18, 0xE0, 0x31, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0x9C, 0x06, 0x38,
  0x0C, 0x70, 0x38, 0x60, 0x60, 0xE3, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0x60,
  0x0C, 0xC0, 0x39, 0x80, 0x63, 0x01, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x1C,
  0x18, 0x30, 0x30, 0xE0, 0x61, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x38, 0x07,
  0x60, 0x06, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0xC0, 0xF8, 0x18, 0x1B, 0x07, 0x03, 0x60, 0xF0, 0xEC, 0x1E,
  0x19, 0x86, 0xC3, 0x30, 0xD8, 0xE6, 0x3B, 0x18, 0xC6, 0x63, 0x18, 0xCC,
  0xE3, 0x31, 0x98, 0x66, 0x33, 0x0C, 0xC6, 0xE1, 0xB0, 0xD8, 0x36, 0x1B,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0x80, 0xC0, 0x30, 0x18,
  0x00, 0x1C, 0x07, 0x1C, 0x0E, 0x0C, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x06,
  0x70, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x18, 0x60, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x30, 0xE0, 0x38, 0x60, 0x1D, 0x80, 0xE7, 0x03, 0x1C, 0x1C,
  0x30, 0xE0, 0xC3, 0x83, 0x9C, 0x0E, 0x60, 0x1B, 0x80, 0x6C, 0x01, 0xF0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0x07, 0x83, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x7C, 0x3C,
  0x00, 0xC6, 0x31, 0x8C, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0x18, 0xC6, 0x31,
  0x8C, 0x71, 0x8C, 0x07, 0x87, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x3C, 0x1E, 0x00, 0x06, 0x0E,
  0x0E, 0x1A, 0x1B, 0x3B, 0x33, 0x73, 0x63, 0xE3, 0xFF, 0xFF, 0xF0, 0xE3,
  0x0C, 0x60, 0x0F, 0x83, 0xF8, 0xE3, 0x38, 0x60, 0x0E, 0x01, 0x87, 0xF3,
  0xFE, 0x71, 0xDC, 0x3B, 0x07, 0x60, 0xCE, 0x79, 0xFF, 0x1E, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x1B, 0xC1, 0xFE, 0x3C,
  0x73, 0x83, 0x38, 0x33, 0x03, 0x30, 0x33, 0x03, 0x70, 0x37, 0x07, 0x60,
  0x67, 0x0E, 0x79, 0xE7, 0xFC, 0xEF, 0x80, 0x0F, 0x83, 0xF8, 0xE3, 0x38,
  0x76, 0x07, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x03, 0x70, 0xEE,
  0x38, 0xFE, 0x0F, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x3D, 0xC7, 0xFE, 0x38, 0xE3, 0x83, 0x18, 0x19, 0xC1, 0xCE,
  0x0E, 0x60, 0x73, 0x03, 0x18, 0x18, 0xC0, 0xC7, 0x0E, 0x38, 0xF0, 0xFF,
  0x03, 0xD8, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x38, 0x76, 0x0F, 0xC1, 0xFF,
  0xFF, 0xFE, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x46, 0x18, 0xFF, 0x0F, 0x80,
  0x03, 0x81, 0xE0, 0xE0, 0x70, 0x1C, 0x06, 0x07, 0xF1, 0xF8, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x00, 0x07, 0x98, 0xFF, 0xC7, 0x1C, 0x70, 0x63, 0x03, 0x38,
  0x19, 0xC1, 0xCE, 0x0E, 0x60, 0x63, 0x03, 0x18, 0x18, 0xE1, 0xC7, 0x1E,
  0x1F, 0xF0, 0x7B, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x38, 0xE1, 0xFE, 0x03,
  0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x1B,
  0xC1, 0xFE, 0x3C, 0x63, 0x87, 0x38, 0x73, 0x07, 0x30, 0x63, 0x06, 0x70,
  0x67, 0x06, 0x60, 0xE6, 0x0E, 0x60, 0xC6, 0x0C, 0xE0, 0xC0, 0x18, 0xC6,
  0x00, 0x18, 0xC6, 0x73, 0x9C, 0xC6, 0x33, 0x9C, 0xC6, 0x31, 0x80, 0x01,
  0x81, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0xF8, 0x78, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x61, 0xC3, 0x1C, 0x19, 0xC1, 0xCE, 0x0E, 0xE0, 0x6E,
  0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0E, 0x60, 0x63, 0x83, 0x0C, 0x18, 0x60,
  0xC3, 0x8E, 0x0C, 0x00, 0x18, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC7,
  0x1C, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC0, 0x1B, 0xC7, 0x83, 0xFD,
  0xF8, 0xF1, 0xE3, 0x9C, 0x38, 0x73, 0x87, 0x06, 0x60, 0xE1, 0xCC, 0x18,
  0x39, 0x83, 0x07, 0x70, 0x60, 0xCE, 0x0C, 0x19, 0x83, 0x83, 0x30, 0x70,
  0xE6, 0x0C, 0x1C, 0xC1, 0x83, 0xB8, 0x30, 0x60, 0x1B, 0xC1, 0xFE, 0x3C,
  0x63, 0x87, 0x38, 0x73, 0x07, 0x30, 0x63, 0x06, 0x70, 0x67, 0x06, 0x60,
  0xE6, 0x0E, 0x60, 0xC6, 0x0C, 0xE0, 0xC0, 0x0F, 0x83, 0xF8, 0xE3, 0xB8,
  0x36, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xF0, 0x66,
  0x1C, 0xFF, 0x07, 0x80, 0x0D, 0xE0, 0x7F, 0x87, 0x8E, 0x38, 0x31, 0xC1,
  0x8C, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x39, 0xC1, 0xCC, 0x0C, 0x60, 0xE3,
  0x8F, 0x1F, 0xF1, 0xDF, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x0F, 0x73, 0xFF, 0x38, 0xE7, 0x06, 0x60, 0x6E, 0x0E,
  0xE0, 0xEC, 0x0E, 0xC0, 0xCC, 0x0C, 0xC0, 0xCE, 0x1C, 0xE3, 0xC7, 0xFC,
  0x3D, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x1B,
  0x8F, 0xCF, 0xA7, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x80, 0x0F, 0x0F, 0xE3, 0x9D, 0xC3, 0x70, 0xDC, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xEC, 0x1B, 0x06, 0xE3, 0x9F, 0xC3, 0xE0, 0x1C,
  0x30, 0x67, 0xFF, 0xE7, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18,
  0x30, 0x78, 0x70, 0x30, 0x63, 0x06, 0x70, 0x67, 0x06, 0x60, 0xE6, 0x0E,
  0x60, 0xC6, 0x0C, 0xE0, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE3, 0x87, 0xF8,
  0x3D, 0x80, 0xC1, 0xF0, 0x6C, 0x1B, 0x0E, 0xC3, 0x39, 0xC6, 0x61, 0x98,
  0x6C, 0x1B, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x03, 0x00, 0xC1, 0x83, 0xC3,
  0x87, 0xC3, 0x86, 0xC7, 0x8E, 0xC7, 0x8C, 0xC7, 0x8C, 0xCD, 0x9C, 0xCC,
  0x98, 0xD8, 0xD8, 0xF8, 0xF0, 0xF8, 0xF0, 0x70, 0xF0, 0x70, 0xE0, 0x60,
  0xE0, 0x60, 0xC0, 0x1C, 0x38, 0xE3, 0x83, 0x18, 0x19, 0xC0, 0x6C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x7C, 0x07, 0x60, 0x33, 0x83, 0x8C,
  0x38, 0x61, 0xC3, 0x80, 0x18, 0x38, 0xC1, 0x86, 0x1C, 0x30, 0xC1, 0x86,
  0x0E, 0x70, 0x73, 0x03, 0xB8, 0x0D, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0F, 0xFC,
  0xFF, 0xC0, 0x01, 0x01, 0xC1, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x00, 0x0C, 0x30, 0xC3,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x08, 0x0E, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x80, 0xC0, 0x30, 0x38, 0x38, 0x38, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x20, 0x00, 0x1C, 0x0C,
  0xF8, 0x67, 0x71, 0x98, 0xEE, 0xC1, 0xF0, 0x03, 0x80,
};

const GFXglyph RobotoCondensed_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 20, 7, 1, -20 },
  { 16, 6, 7, 9, 3, -21 },
  { 22, 14, 20, 15, 1, -20 },
  { 57, 12, 26, 13, 1, -23 },
  { 96, 12, 20, 17, 3, -20 },
  { 126, 13, 20, 15, 1, -20 },
  { 159, 3, 7, 5, 2, -21 },
  { 162, 9, 28, 9, 1, -22 },
  { 194, 8, 28, 9, -1, -22 },
  { 222, 11, 12, 12, 1, -20 },
  { 239, 12, 14, 14, 1, -16 },
  { 260, 5, 7, 5, -2, -3 },
  { 265, 6, 2, 7, 0, -9 },
  { 267, 3, 3, 7, 1, -3 },
  { 269, 12, 22, 10, -1, -20 },
  { 302, 12, 20, 13, 1, -20 },
  { 332, 8, 20, 13, 3, -20 },
  { 352, 13, 20, 13, 0, -20 },
  { 385, 12, 20, 13, 1, -20 },
  { 415, 13, 20, 13, 0, -20 },
  { 448, 13, 20, 13, 1, -20 },
  { 481, 11, 20, 13, 1, -20 },
  { 509, 12, 20, 13, 2, -20 },
  { 539, 12, 20, 13, 1, -20 },
  { 569, 10, 20, 13, 2, -20 },
  { 594, 5, 15, 6, 1, -15 },
  { 604, 6, 19, 6, -1, -15 },
  { 619, 10, 12, 12, 1, -15 },
  { 634, 11, 7, 13, 1, -13 },
  { 644, 11, 12, 13, 1, -15 },
  { 661, 10, 20, 11, 2, -20 },
  { 686, 19, 26, 21, 1, -20 },
  { 748, 15, 20, 16, -1, -20 },
  { 786, 13, 20, 15, 1, -20 },
  { 819, 14, 20, 15, 1, -20 },
  { 854, 14, 20, 16, 1, -20 },
  { 889, 13, 20, 14, 1, -20 },
  { 922, 13, 20, 13, 1, -20 },
  { 955, 14, 20, 16, 1, -20 },
  { 990, 16, 20, 17, 1, -20 },
  { 1030, 6, 20, 7, 1, -20 },
  { 1045, 13, 20, 13, 0, -20 },
  { 1078, 15, 20, 15, 1, -20 },
  { 1116, 10, 20, 13, 1, -20 },
  { 1141, 19, 20, 21, 1, -20 },
  { 1189, 16, 20, 17, 1, -20 },
  { 1229, 13, 20, 16, 2, -20 },
  { 1262, 14, 20, 15, 1, -20 },
  { 1297, 14, 23, 16, 1, -20 },
  { 1338, 13, 20, 14, 1, -20 },
  { 1371, 13, 20, 14, 1, -20 },
  { 1404, 13, 20, 14, 2, -20 },
  { 1437, 15, 20, 15, 1, -20 },
  { 1475, 15, 20, 15, 2, -20 },
  { 1513, 19, 20, 21, 3, -20 },
  { 1561, 16, 20, 15, 0, -20 },
  { 1601, 14, 20, 14, 2, -20 },
  { 1636, 15, 20, 14, 0, -20 },
  { 1674, 9, 27, 7, 0, -23 },
  { 1705, 5, 22, 10, 3, -20 },
  { 1719, 9, 27, 7, -2, -23 },
  { 1750, 8, 10, 10, 1, -20 },
  { 1760, 10, 2, 11, -1, 0 },
  { 1763, 5, 4, 8, 3, -21 },
  { 1766, 11, 15, 13, 1, -15 },
  { 1787, 12, 21, 13, 0, -21 },
  { 1819, 11, 15, 13, 1, -15 },
  { 1840, 13, 21, 13, 1, -21 },
  { 1875, 11, 15, 13, 1, -15 },
  { 1896, 10, 21, 9, 1, -21 },
  { 1923, 13, 21, 13, 0, -15 },
  { 1958, 12, 21, 13, 0, -21 },
  { 1990, 5, 20, 6, 1, -20 },
  { 2003, 9, 26, 6, -3, -20 },
  { 2033, 13, 21, 12, 0, -21 },
  { 2068, 6, 21, 6, 1, -21 },
  { 2084, 19, 15, 20, 0, -15 },
  { 2120, 12, 15, 13, 0, -15 },
  { 2143, 11, 15, 14, 1, -15 },
  { 2164, 13, 21, 13, -1, -15 },
  { 2199, 12, 21, 14, 1, -15 },
  { 2231, 9, 15, 8, 0, -15 },
  { 2248, 10, 15, 12, 1, -15 },
  { 2267, 7, 18, 8, 1, -18 },
  { 2283, 12, 15, 13, 1, -15 },
  { 2306, 10, 15, 12, 2, -15 },
  { 2325, 16, 15, 18, 2, -15 },
  { 2355, 13, 15, 12, -1, -15 },
  { 2380, 13, 21, 11, -1, -15 },
  { 2415, 12, 15, 12, 0, -15 },
  { 2438, 9, 27, 8, 1, -22 },
  { 2469, 6, 24, 7, 0, -20 },
  { 2487, 9, 27, 8, -1, -22 },
  { 2518, 14, 6, 16, 1, -12 },
};

const GFXfont RobotoCondensed_Italic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_ITALIC28PT7B_H_
