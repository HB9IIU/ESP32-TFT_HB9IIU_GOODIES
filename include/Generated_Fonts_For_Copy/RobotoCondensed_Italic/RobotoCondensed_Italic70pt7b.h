#ifndef _ROBOTOCONDENSED_ITALIC70PT7B_H_
#define _ROBOTOCONDENSED_ITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C,
  0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x60, 0xF8, 0x0F, 0x80, 0x38, 0x7C, 0x07, 0xC0, 0x3E, 0x3C,
  0x03, 0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x1F, 0x07,
  0x80, 0x7C, 0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x01, 0xE0, 0x1E, 0x0F, 0x80,
  0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x0F, 0x87, 0x80, 0x3E, 0x07, 0x87, 0xC0,
  0x1F, 0x0F, 0xC7, 0xC0, 0x07, 0xFF, 0xC3, 0xC0, 0x01, 0xFF, 0xC3, 0xE0,
  0x00, 0xFF, 0xC3, 0xE0, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x3F, 0x80, 0x00, 0x7C, 0x3F, 0xF0, 0x00, 0x7C, 0x3F, 0xFC, 0x00, 0x3E,
  0x3F, 0xFE, 0x00, 0x3E, 0x3E, 0x0F, 0x80, 0x3E, 0x1E, 0x07, 0xC0, 0x1F,
  0x1F, 0x01, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x0F,
  0x07, 0xC0, 0x3C, 0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0x81, 0xF0, 0x0F, 0x07,
  0x80, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0x03, 0xE3,
  0xC0, 0x1F, 0x01, 0xF0, 0xE0, 0x07, 0x80, 0xF0, 0x20, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03,
  0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0xFC, 0x7F,
  0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0x0F, 0xE7, 0xF0, 0x1F, 0x1F, 0xC3, 0xF0,
  0x3F, 0x3F, 0x83, 0xF8, 0x3E, 0x3F, 0x81, 0xF8, 0x3E, 0x7F, 0x01, 0xFC,
  0x3E, 0x7E, 0x00, 0xFC, 0x7E, 0x7E, 0x00, 0xFE, 0x7C, 0xFE, 0x00, 0x7F,
  0xFC, 0xFC, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x3F,
  0xF0, 0xFC, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x7F,
  0xF0, 0x3F, 0xF3, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD,
  0xFC, 0x07, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF,
  0x9F, 0x3E, 0x78, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x20, 0x0F, 0x80, 0x4F, 0x81, 0xE0, 0x7D, 0xFC, 0x3C,
  0x3F, 0xFF, 0xF7, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F,
  0xCF, 0xC0, 0x07, 0xF0, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x07, 0x80, 0x10, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xDF, 0x9F,
  0xC7, 0xE7, 0x81, 0xFB, 0x80, 0x7C, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFD, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x04,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F,
  0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF8, 0x01,
  0xF3, 0xFF, 0x80, 0xFD, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x0F, 0xF1, 0xFF, 0x00, 0xFC, 0x7F, 0x80, 0x3F, 0x9F, 0xC0,
  0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0x01, 0xFC, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x9F, 0x80, 0x1F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x07, 0xFE, 0x3F,
  0xC7, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFC,
  0x07, 0xFF, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x0E, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0xFF, 0x80,
  0x3C, 0x1F, 0x00, 0x3F, 0xFF, 0x80, 0x78, 0x3E, 0x00, 0xFF, 0x3F, 0x80,
  0xF0, 0x78, 0x03, 0xF0, 0x1E, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x7C, 0x03,
  0xC3, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0x8F, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x79, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF3,
  0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE7, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xDF,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xBE, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0x3C, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x79, 0xE0,
  0x1F, 0x00, 0x7C, 0x00, 0xF3, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xE7, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0x9F, 0x01, 0xF8, 0x03, 0xC0, 0x0F, 0x3E, 0x03,
  0xF0, 0x0F, 0x80, 0x1E, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0xF8, 0x0F,
  0x80, 0x7E, 0x00, 0xF1, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC3, 0xE0, 0x3F,
  0x03, 0xF8, 0x07, 0x87, 0xC0, 0x3E, 0x0F, 0xF0, 0x1E, 0x0F, 0x80, 0x7E,
  0x3D, 0xE0, 0x7C, 0x1F, 0x00, 0xFF, 0xFB, 0xE3, 0xF0, 0x1E, 0x01, 0xFF,
  0xE7, 0xFF, 0xC0, 0x3C, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x78, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3E, 0x7F, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xFC, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x03,
  0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFF,
  0x3F, 0x00, 0x1F, 0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0xE3, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x03, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF8,
  0x00, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0x00,
  0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0x9F,
  0xC0, 0x00, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x07, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x7C,
  0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x3E, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0x80, 0x0F, 0xC7,
  0xE0, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF8, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x3E,
  0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x1F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x8F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE7,
  0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF7, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFF,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x00, 0x7E,
  0x01, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFF,
  0x80, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x00, 0xFC, 0x03,
  0xF7, 0xC0, 0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x01, 0xFC, 0x03, 0xF3, 0xE0,
  0x01, 0xF8, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0x07, 0xF3, 0xF0, 0x01, 0xF8,
  0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x07, 0xE1,
  0xF8, 0x03, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x0F, 0xE0, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x3F, 0x80, 0x0F, 0x8F,
  0xC0, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x3F,
  0x00, 0x07, 0xDF, 0xC0, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xFF, 0x80,
  0x7E, 0x00, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x7E, 0x00,
  0x01, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF1,
  0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF1, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF1,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE1, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE1,
  0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xC1,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x01,
  0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x01,
  0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x01,
  0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0xF1, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0xF3, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0xF3, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00,
  0xF3, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7C, 0xF0,
  0x03, 0xE7, 0x80, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0x7C, 0x3E, 0x03, 0xE3,
  0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01,
  0xF0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xF1, 0xF8, 0x3F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFF, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xE7, 0xF0, 0x1F, 0xF8, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF1, 0xFF,
  0x80, 0x0F, 0xDF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x81,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFE, 0x00,
  0x3F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x7D, 0xFF, 0xFF,
  0x83, 0xF7, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0x00,
  0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0xFC, 0x00,
  0x7F, 0xFC, 0x7E, 0x00, 0x7F, 0xFF, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0,
  0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF7, 0xE0, 0x00,
  0x7F, 0xF3, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF3, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0x03, 0xF8, 0x00, 0xF0, 0x3F, 0x80, 0x7F, 0x07,
  0xFE, 0x7F, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0x00, 0x3F, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0x3F,
  0x00, 0xFF, 0xFF, 0xBE, 0x01, 0xFF, 0xFF, 0xBE, 0x01, 0xFC, 0x03, 0xFE,
  0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xC0,
  0x01, 0xFF, 0xCF, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0x7F, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF3, 0xFF, 0x80,
  0x3F, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x04, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFC, 0x07,
  0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x07, 0xE0, 0xFE,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0xFC, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xCF, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x7F, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE1, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0x1F, 0xF0, 0x03, 0xF7, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x3F, 0xF8, 0x00, 0x1F, 0x3F, 0xFE, 0x00, 0x0F, 0xBF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xF0,
  0x07, 0xDF, 0x9F, 0xF8, 0x07, 0xEF, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xF8,
  0x01, 0xF8, 0xFF, 0xF8, 0x00, 0xFC, 0x3F, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x8F, 0xC0, 0x7F, 0xFF, 0x3E, 0x03, 0xFF,
  0xFE, 0xF8, 0x1F, 0xF9, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0x83, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xBF, 0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF0, 0x1F, 0x9F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFC, 0x40, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x07,
  0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00,
  0xFE, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3F,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xFE,
  0x00, 0x7E, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xFE, 0x00, 0xFC,
  0xFC, 0x03, 0xFE, 0x00, 0xF8, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0xFC, 0x07,
  0xFE, 0x01, 0xF0, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xFE, 0x03,
  0xF0, 0xFC, 0x0F, 0xBE, 0x03, 0xE0, 0xFC, 0x0F, 0xBE, 0x07, 0xE0, 0x7C,
  0x1F, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x3E, 0x0F, 0xC0, 0x7C, 0x3F, 0x1F,
  0x0F, 0xC0, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x1F, 0x1F, 0x80,
  0x7C, 0x7C, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x1F, 0x1F, 0x00, 0x7C, 0xF8,
  0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x1F, 0x7E,
  0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0x7C, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE,
  0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xF0, 0x7F, 0xF8, 0x00, 0x78, 0x3F, 0xFF, 0x00, 0x3E, 0x1F, 0xFF, 0xE0,
  0x0F, 0x87, 0xFF, 0xF8, 0x03, 0xE3, 0xF0, 0x7F, 0x01, 0xF0, 0xF8, 0x0F,
  0xE0, 0xFC, 0x7E, 0x01, 0xFF, 0xFE, 0x1F, 0x00, 0x3F, 0xFF, 0x87, 0xC0,
  0x0F, 0xFF, 0xC1, 0xF0, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 15, 51, 17, 2, -50 },
  { 97, 16, 17, 22, 7, -53 },
  { 131, 35, 50, 37, 3, -50 },
  { 350, 29, 65, 34, 3, -58 },
  { 586, 33, 52, 43, 6, -51 },
  { 801, 32, 52, 37, 2, -51 },
  { 1009, 7, 16, 12, 6, -53 },
  { 1023, 20, 72, 21, 4, -56 },
  { 1203, 21, 72, 22, -3, -56 },
  { 1392, 27, 29, 29, 4, -50 },
  { 1490, 29, 37, 34, 3, -42 },
  { 1625, 12, 17, 13, -4, -8 },
  { 1651, 15, 5, 17, 1, -24 },
  { 1661, 7, 8, 18, 2, -7 },
  { 1668, 31, 54, 25, -3, -50 },
  { 1878, 29, 52, 34, 3, -51 },
  { 2067, 18, 50, 34, 8, -50 },
  { 2180, 31, 51, 34, 1, -51 },
  { 2378, 29, 52, 34, 2, -51 },
  { 2567, 31, 50, 34, 0, -50 },
  { 2761, 30, 51, 34, 4, -50 },
  { 2953, 26, 51, 34, 4, -50 },
  { 3119, 31, 50, 34, 4, -50 },
  { 3313, 30, 52, 34, 2, -51 },
  { 3508, 26, 51, 34, 5, -51 },
  { 3674, 12, 38, 16, 2, -37 },
  { 3731, 17, 46, 14, -3, -37 },
  { 3829, 26, 31, 30, 2, -38 },
  { 3930, 26, 21, 33, 4, -34 },
  { 3999, 27, 30, 31, 2, -37 },
  { 4101, 23, 52, 29, 6, -51 },
  { 4251, 47, 64, 52, 2, -49 },
  { 4627, 36, 50, 39, -2, -50 },
  { 4852, 33, 50, 37, 2, -50 },
  { 5059, 34, 52, 38, 4, -51 },
  { 5280, 34, 50, 39, 2, -50 },
  { 5493, 34, 50, 34, 2, -50 },
  { 5706, 33, 50, 33, 2, -50 },
  { 5913, 34, 52, 40, 4, -51 },
  { 6134, 40, 50, 42, 2, -50 },
  { 6384, 15, 50, 17, 2, -50 },
  { 6478, 33, 51, 33, 0, -50 },
  { 6689, 39, 50, 37, 2, -50 },
  { 6933, 26, 50, 32, 2, -50 },
  { 7096, 49, 50, 51, 2, -50 },
  { 7403, 40, 50, 42, 2, -50 },
  { 7653, 35, 52, 41, 4, -51 },
  { 7881, 36, 50, 38, 2, -50 },
  { 8106, 34, 59, 41, 4, -51 },
  { 8357, 34, 50, 36, 2, -50 },
  { 8570, 33, 52, 35, 2, -51 },
  { 8785, 33, 50, 35, 6, -50 },
  { 8992, 36, 51, 38, 3, -50 },
  { 9222, 35, 50, 38, 6, -50 },
  { 9441, 48, 50, 52, 7, -50 },
  { 9741, 41, 50, 37, -1, -50 },
  { 9998, 34, 50, 36, 6, -50 },
  { 10211, 38, 50, 36, -1, -50 },
  { 10449, 21, 68, 17, 0, -57 },
  { 10628, 13, 54, 25, 7, -50 },
  { 10716, 22, 68, 17, -4, -57 },
  { 10903, 21, 25, 25, 3, -50 },
  { 10969, 27, 5, 27, -4, 0 },
  { 10986, 12, 10, 21, 7, -52 },
  { 11001, 27, 39, 33, 2, -38 },
  { 11133, 30, 54, 34, 1, -53 },
  { 11336, 28, 39, 31, 2, -38 },
  { 11473, 33, 54, 34, 2, -53 },
  { 11696, 27, 39, 32, 2, -38 },
  { 11828, 23, 54, 22, 3, -54 },
  { 11984, 32, 52, 34, 0, -38 },
  { 12192, 28, 53, 33, 1, -53 },
  { 12378, 15, 50, 16, 1, -50 },
  { 12472, 22, 64, 15, -7, -50 },
  { 12648, 31, 53, 31, 1, -53 },
  { 12854, 15, 53, 16, 1, -53 },
  { 12954, 46, 38, 51, 1, -38 },
  { 13173, 28, 38, 33, 1, -38 },
  { 13306, 29, 39, 34, 2, -38 },
  { 13448, 33, 52, 34, -2, -38 },
  { 13663, 30, 52, 34, 2, -38 },
  { 13858, 21, 38, 21, 1, -38 },
  { 13958, 28, 39, 31, 1, -38 },
  { 14095, 17, 47, 20, 3, -46 },
  { 14195, 28, 38, 33, 3, -37 },
  { 14328, 26, 37, 29, 4, -37 },
  { 14449, 40, 37, 44, 5, -37 },
  { 14634, 32, 37, 30, -2, -37 },
  { 14782, 33, 51, 28, -3, -37 },
  { 14993, 29, 37, 30, 0, -37 },
  { 15128, 22, 67, 21, 2, -55 },
  { 15313, 14, 59, 17, 1, -50 },
  { 15417, 22, 68, 21, -3, -55 },
  { 15604, 34, 14, 40, 3, -28 },
};

const GFXfont RobotoCondensed_Italic70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_ITALIC70PT7B_H_
