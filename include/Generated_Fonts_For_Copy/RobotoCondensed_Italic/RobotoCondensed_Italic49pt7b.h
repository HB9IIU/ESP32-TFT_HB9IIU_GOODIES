#ifndef _ROBOTOCONDENSED_ITALIC49PT7B_H_
#define _ROBOTOCONDENSED_ITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x00, 0x38, 0xEF, 0x1D, 0xE3, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C, 0x77,
  0x8E, 0xE1, 0xDC, 0x73, 0x8E, 0x71, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x38, 0x00,
  0x1C, 0x1C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x03, 0x83, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x1C, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x03, 0x83, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1E, 0x0F, 0x81,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xF0,
  0x0F, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0x78, 0x0F,
  0x87, 0xC1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1E, 0x38, 0x00, 0xF0, 0xE0,
  0x23, 0x81, 0xC0, 0xEE, 0x07, 0x07, 0x38, 0x1C, 0x3C, 0xE0, 0xF1, 0xE3,
  0x83, 0x87, 0x0E, 0x0E, 0x38, 0x38, 0x39, 0xE0, 0xE1, 0xC7, 0x01, 0xFF,
  0x38, 0x07, 0xF9, 0xE0, 0x07, 0x87, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0xF8, 0x01, 0xC7, 0xF0, 0x0F, 0x3F, 0xE0,
  0x39, 0xE3, 0x81, 0xC7, 0x07, 0x0F, 0x3C, 0x1C, 0x78, 0xE0, 0x71, 0xC3,
  0x81, 0xCE, 0x0E, 0x07, 0x78, 0x38, 0x1D, 0xC0, 0xE0, 0xE6, 0x03, 0x83,
  0x88, 0x0F, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1E, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0xF1, 0xF3, 0xE1,
  0xE7, 0xC3, 0xC3, 0x8F, 0x07, 0xCF, 0x3E, 0x07, 0x9E, 0x78, 0x0F, 0xBC,
  0xF0, 0x0F, 0xF1, 0xE0, 0x1F, 0xE3, 0xC0, 0x1F, 0x87, 0x80, 0x3E, 0x0F,
  0x00, 0x3C, 0x1F, 0x01, 0xFC, 0x1F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFC, 0xF0, 0x1F, 0xE1, 0xF0, 0x06, 0x00, 0x00, 0x39, 0xCE, 0xF7, 0xB9,
  0xCE, 0x77, 0xB8, 0x00, 0x04, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x10, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x1C, 0x38, 0x77, 0xE7, 0x3E, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x3F,
  0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x07, 0x9E, 0x01, 0xF1,
  0xC0, 0x7C, 0x3C, 0x1F, 0x07, 0x80, 0xC0, 0x70, 0x00, 0x08, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C,
  0x3C, 0x1C, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFE,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC1, 0xE0, 0xF8,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7,
  0xC0, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0x70, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80,
  0xF0, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xEE, 0x1E, 0x81, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0,
  0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x78,
  0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C,
  0x3C, 0x03, 0xC1, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x78, 0x78,
  0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3E,
  0x0F, 0x80, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC7, 0x00,
  0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x81,
  0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0xF8, 0x1E, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7E, 0x0F, 0xBF, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3E, 0x07, 0xC7, 0xC3, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xC1, 0xE0, 0xF8, 0x1F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x83, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0xF0, 0x3C,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x80, 0xF8,
  0x78, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x0F,
  0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x0F, 0xBE, 0x07, 0xE7, 0x83, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFB, 0xC0, 0xF8, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xE1, 0xF0, 0xF8,
  0x38, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x1F,
  0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06,
  0x07, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0xF8, 0x07,
  0x1E, 0x03, 0xFE, 0x03, 0x1C, 0x07, 0xFF, 0x03, 0x1C, 0x0F, 0x87, 0x03,
  0x38, 0x0F, 0x07, 0x03, 0x38, 0x1E, 0x0F, 0x03, 0x78, 0x1C, 0x0F, 0x03,
  0x70, 0x3C, 0x0E, 0x07, 0x70, 0x38, 0x0E, 0x07, 0x70, 0x78, 0x1E, 0x07,
  0xF0, 0x78, 0x1E, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07,
  0xE0, 0xF0, 0x3C, 0x06, 0xE0, 0xF0, 0x3C, 0x0E, 0xE0, 0xF0, 0x38, 0x0E,
  0xE0, 0xF0, 0x78, 0x0C, 0xE0, 0xF0, 0x78, 0x1C, 0xE0, 0xF0, 0xF8, 0x38,
  0xE0, 0xF1, 0xF8, 0x38, 0xE0, 0xFF, 0xBC, 0xF0, 0xE0, 0x7F, 0xBF, 0xE0,
  0xE0, 0x3E, 0x1F, 0xC0, 0xE0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x1F, 0x81, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x0F,
  0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x7C,
  0x0F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x78,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0x78, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E,
  0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x3E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78,
  0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x81, 0xE0, 0x1F,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x0F, 0xFC, 0xF8, 0x0F, 0xFC, 0xF0, 0x1F, 0xFC, 0xF0, 0x1F, 0xFC, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0xF0, 0x1F,
  0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x0F,
  0x80, 0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x07,
  0x80, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1F, 0x80, 0x00,
  0xF3, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFD, 0xE0, 0x00,
  0x1F, 0x9F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0xEF, 0x00, 0x0F, 0xF0, 0x3D, 0xE0, 0x03, 0xDE,
  0x07, 0xBC, 0x00, 0x7B, 0xC0, 0xF7, 0x80, 0x1E, 0x78, 0x1E, 0x70, 0x03,
  0xDE, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x1E, 0x3C,
  0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x7C, 0x0F,
  0x0E, 0x07, 0x8F, 0x01, 0xE1, 0xC1, 0xE1, 0xE0, 0x7C, 0x3C, 0x3C, 0x3C,
  0x0F, 0x87, 0x8F, 0x07, 0x81, 0xE0, 0xF1, 0xE1, 0xF0, 0x3C, 0x1E, 0x78,
  0x3E, 0x07, 0x83, 0xCF, 0x07, 0x80, 0xF0, 0x3B, 0xC0, 0xF0, 0x3E, 0x07,
  0x78, 0x1E, 0x07, 0xC0, 0xFE, 0x03, 0xC0, 0xF0, 0x1F, 0xC0, 0xF8, 0x1E,
  0x03, 0xF0, 0x1F, 0x03, 0xC0, 0x7E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x1F, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3F, 0x00, 0x1F,
  0x07, 0xF0, 0x01, 0xF0, 0x7F, 0x00, 0x1E, 0x07, 0xF8, 0x01, 0xE0, 0x7F,
  0x80, 0x1E, 0x07, 0xF8, 0x01, 0xE0, 0x7B, 0x80, 0x3E, 0x0F, 0xBC, 0x03,
  0xE0, 0xFB, 0xC0, 0x3C, 0x0F, 0x1C, 0x03, 0xC0, 0xF1, 0xE0, 0x3C, 0x0F,
  0x1E, 0x03, 0xC0, 0xF0, 0xE0, 0x7C, 0x1F, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x78, 0x1E, 0x07, 0x07, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x8F, 0x83,
  0xE0, 0x38, 0xF8, 0x3E, 0x03, 0xCF, 0x03, 0xC0, 0x3C, 0xF0, 0x3C, 0x01,
  0xCF, 0x03, 0xC0, 0x1E, 0xF0, 0x3C, 0x01, 0xFF, 0x07, 0xC0, 0x0F, 0xF0,
  0x7C, 0x00, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0x7E, 0x07, 0x80,
  0x07, 0xE0, 0x78, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E,
  0x1F, 0x00, 0x7E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xFC, 0x0F,
  0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3E, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3E,
  0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x3E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x87,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x01,
  0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00,
  0x3E, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF8,
  0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x07,
  0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC7, 0x80,
  0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0,
  0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0xF8, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0xF0, 0x03,
  0xDE, 0x00, 0xFC, 0x01, 0xEF, 0x00, 0x7E, 0x01, 0xF7, 0x80, 0x3F, 0x00,
  0xF3, 0xC0, 0x3F, 0x80, 0x79, 0xE0, 0x1F, 0xC0, 0x7C, 0xF0, 0x0E, 0xE0,
  0x3C, 0x78, 0x0F, 0x70, 0x1E, 0x3C, 0x07, 0x38, 0x1F, 0x1E, 0x07, 0x9C,
  0x0F, 0x0F, 0x03, 0xCE, 0x07, 0x87, 0x81, 0xC7, 0x07, 0xC3, 0xC1, 0xE3,
  0x83, 0xC1, 0xE0, 0xF1, 0xC1, 0xE0, 0xF0, 0x70, 0xE1, 0xF0, 0x38, 0x78,
  0x70, 0xF0, 0x1C, 0x38, 0x38, 0x78, 0x0E, 0x3C, 0x1C, 0x78, 0x07, 0x9E,
  0x0F, 0x3C, 0x03, 0xCE, 0x07, 0x9E, 0x01, 0xEF, 0x03, 0xDE, 0x00, 0xF7,
  0x01, 0xEF, 0x00, 0x7B, 0x80, 0x77, 0x80, 0x3F, 0xC0, 0x3B, 0x80, 0x1D,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0,
  0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x3C,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x78,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x1E,
  0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xE0, 0x3B, 0x81, 0xEE, 0x0F, 0x38, 0x3C, 0xE1, 0xE3, 0x87,
  0x8F, 0x3C, 0x3C, 0xF0, 0xF7, 0x81, 0xDE, 0x07, 0xF0, 0x1C, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1E, 0x0F, 0x07, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xF0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x07,
  0x8F, 0x80, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x1E,
  0x7C, 0x03, 0xCF, 0x80, 0xF8, 0xF8, 0x7F, 0x1F, 0xFF, 0xE1, 0xFF, 0xBC,
  0x3F, 0xE7, 0x81, 0xF0, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF1, 0xF0, 0x0F,
  0x7F, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x1F, 0x1F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00,
  0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0,
  0x7C, 0xFE, 0x0F, 0xCF, 0x7F, 0xF8, 0xF7, 0xFF, 0x0F, 0x3F, 0xE0, 0xF0,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xF0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x07, 0xCF, 0x00, 0xF0, 0xF0, 0x3E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x7E,
  0x3C, 0x07, 0xFC, 0xF0, 0x3F, 0xFB, 0xC1, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8,
  0x3E, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFB, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xF0, 0x7C, 0x7C, 0x07,
  0x8F, 0x00, 0xF3, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBC, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x60,
  0xF8, 0x1E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x1C, 0x07, 0xFC, 0xF0, 0x3F, 0xFB,
  0xC1, 0xFF, 0xFF, 0x0F, 0xC1, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3E,
  0x03, 0xE0, 0xF8, 0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFB,
  0xC0, 0x0F, 0xCF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x02, 0x00, 0xF8, 0x1C, 0x07, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x8F, 0x80,
  0xF7, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x1F, 0x1F, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x79, 0xF0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0xF8,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF8, 0x03,
  0x80, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xF0, 0xF0, 0x1F, 0x07,
  0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC1, 0xF0, 0x1E, 0x1F, 0x00, 0xF1, 0xF0,
  0x07, 0x9F, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x9E, 0x00,
  0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF8, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x1F, 0x0F,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x3F, 0x01, 0xF8, 0x0F, 0x7F, 0x87, 0xFC, 0x0F, 0xFF,
  0xCF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xFC, 0x1F, 0x1F, 0x01,
  0xF8, 0x0F, 0x1E, 0x01, 0xF0, 0x0F, 0x1E, 0x01, 0xF0, 0x0F, 0x1E, 0x01,
  0xF0, 0x0F, 0x3E, 0x01, 0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x0F, 0x3C, 0x01,
  0xE0, 0x1F, 0x3C, 0x01, 0xE0, 0x1F, 0x3C, 0x03, 0xE0, 0x1E, 0x3C, 0x03,
  0xC0, 0x1E, 0x7C, 0x03, 0xC0, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0x03,
  0xC0, 0x3E, 0x78, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0xC0, 0x3C, 0x78, 0x07,
  0x80, 0x3C, 0xF8, 0x07, 0x80, 0x3C, 0xF0, 0x07, 0x80, 0x3C, 0xF0, 0x07,
  0x80, 0x7C, 0xF0, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x1F,
  0x01, 0xEF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF8, 0x3E, 0x3E, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x79,
  0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0x03,
  0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xF7, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF,
  0x00, 0x7C, 0xF8, 0x07, 0x87, 0xC0, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xC7, 0xC0, 0x0F, 0x7F, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0,
  0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E,
  0x1E, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0x7F, 0xF0, 0x3C,
  0xFF, 0x80, 0xF1, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x7F,
  0xCF, 0x0F, 0xFE, 0xF1, 0xFF, 0xFF, 0x3F, 0x03, 0xF3, 0xE0, 0x1E, 0x7C,
  0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xEF,
  0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F,
  0x8F, 0x81, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xEF, 0x00, 0xFC,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x0F, 0x3C, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xC0, 0x7E,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x3C,
  0x3E, 0x07, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0xFE, 0x00, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x7C, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x0F, 0x8F, 0x00, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xEF, 0x01, 0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x3E, 0x70, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x38, 0x78,
  0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78,
  0x07, 0xBC, 0x03, 0xC0, 0x3D, 0xE0, 0x3E, 0x03, 0xCF, 0x01, 0xF0, 0x1E,
  0x38, 0x1F, 0x81, 0xF1, 0xC0, 0xFE, 0x0F, 0x0E, 0x0F, 0xF0, 0x78, 0x78,
  0x7F, 0x87, 0x83, 0xC3, 0xBC, 0x3C, 0x1E, 0x3D, 0xE1, 0xC0, 0xF1, 0xC7,
  0x1E, 0x07, 0x9E, 0x38, 0xF0, 0x3C, 0xF1, 0xCF, 0x01, 0xEF, 0x0E, 0x78,
  0x0F, 0x78, 0x73, 0x80, 0x7B, 0x83, 0xBC, 0x03, 0xFC, 0x1D, 0xE0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x7C,
  0x00, 0x79, 0xE0, 0x00, 0xEF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE3, 0xC0,
  0x0F, 0x0F, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x07, 0xC3, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x73, 0xC0,
  0x00, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x00, 0x02,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x00,
  0x01, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01,
  0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0x1F,
  0xF0, 0x0E, 0x3F, 0xF8, 0x0E, 0x3C, 0x7C, 0x1E, 0x78, 0x3E, 0x3C, 0x78,
  0x1F, 0xFC, 0x70, 0x0F, 0xF8, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 35, 12, 1, -35 },
  { 50, 11, 12, 15, 5, -37 },
  { 67, 25, 35, 26, 2, -35 },
  { 177, 20, 44, 23, 2, -40 },
  { 287, 22, 35, 30, 5, -35 },
  { 384, 23, 36, 26, 1, -35 },
  { 488, 5, 11, 8, 4, -37 },
  { 495, 14, 50, 15, 3, -39 },
  { 583, 14, 50, 15, -2, -39 },
  { 671, 19, 20, 20, 3, -35 },
  { 719, 20, 25, 24, 2, -29 },
  { 782, 9, 12, 9, -3, -5 },
  { 796, 10, 4, 12, 1, -17 },
  { 801, 6, 5, 13, 1, -5 },
  { 805, 22, 38, 18, -2, -35 },
  { 910, 20, 35, 23, 2, -35 },
  { 998, 12, 35, 23, 6, -35 },
  { 1051, 22, 35, 23, 0, -35 },
  { 1148, 21, 35, 23, 1, -35 },
  { 1240, 22, 35, 23, 0, -35 },
  { 1337, 21, 35, 23, 3, -35 },
  { 1429, 18, 35, 23, 3, -35 },
  { 1508, 22, 35, 23, 3, -35 },
  { 1605, 20, 35, 23, 2, -35 },
  { 1693, 18, 35, 23, 4, -35 },
  { 1772, 9, 26, 11, 1, -26 },
  { 1802, 12, 33, 10, -2, -26 },
  { 1852, 18, 21, 21, 2, -26 },
  { 1900, 18, 14, 23, 3, -23 },
  { 1932, 19, 21, 22, 1, -26 },
  { 1982, 16, 35, 20, 4, -35 },
  { 2052, 32, 45, 37, 2, -34 },
  { 2232, 26, 35, 27, -2, -35 },
  { 2346, 24, 35, 26, 1, -35 },
  { 2451, 24, 35, 27, 3, -35 },
  { 2556, 25, 35, 27, 1, -35 },
  { 2666, 24, 35, 24, 1, -35 },
  { 2771, 24, 35, 23, 1, -35 },
  { 2876, 24, 35, 28, 3, -35 },
  { 2981, 28, 35, 29, 1, -35 },
  { 3104, 11, 35, 12, 1, -35 },
  { 3153, 23, 35, 23, 0, -35 },
  { 3254, 28, 35, 26, 1, -35 },
  { 3377, 18, 35, 23, 1, -35 },
  { 3456, 35, 35, 36, 1, -35 },
  { 3610, 28, 35, 29, 1, -35 },
  { 3733, 24, 35, 29, 3, -35 },
  { 3838, 25, 35, 26, 1, -35 },
  { 3948, 25, 41, 29, 2, -35 },
  { 4077, 24, 35, 25, 1, -35 },
  { 4182, 24, 35, 25, 1, -35 },
  { 4287, 23, 35, 25, 4, -35 },
  { 4388, 25, 35, 27, 2, -35 },
  { 4498, 25, 35, 27, 4, -35 },
  { 4608, 33, 35, 36, 5, -35 },
  { 4753, 29, 35, 26, -1, -35 },
  { 4880, 24, 35, 25, 4, -35 },
  { 4985, 26, 35, 25, 0, -35 },
  { 5099, 15, 47, 12, 0, -40 },
  { 5188, 9, 38, 18, 5, -35 },
  { 5231, 15, 47, 12, -3, -40 },
  { 5320, 14, 17, 18, 2, -35 },
  { 5350, 19, 4, 19, -3, 0 },
  { 5360, 8, 7, 15, 5, -37 },
  { 5367, 19, 26, 23, 1, -26 },
  { 5429, 20, 37, 23, 1, -37 },
  { 5522, 19, 26, 22, 2, -26 },
  { 5584, 22, 37, 24, 2, -37 },
  { 5686, 19, 26, 22, 2, -26 },
  { 5748, 16, 38, 15, 2, -38 },
  { 5824, 22, 36, 23, 0, -26 },
  { 5923, 19, 37, 23, 1, -37 },
  { 6011, 10, 35, 11, 1, -35 },
  { 6055, 16, 45, 11, -5, -35 },
  { 6145, 21, 37, 21, 1, -37 },
  { 6243, 10, 37, 11, 1, -37 },
  { 6290, 32, 26, 36, 1, -26 },
  { 6394, 19, 26, 23, 1, -26 },
  { 6456, 20, 26, 24, 2, -26 },
  { 6521, 22, 36, 23, -1, -26 },
  { 6620, 20, 36, 24, 2, -26 },
  { 6710, 14, 26, 14, 1, -26 },
  { 6756, 19, 26, 22, 1, -26 },
  { 6818, 12, 32, 14, 2, -32 },
  { 6866, 20, 26, 23, 2, -26 },
  { 6931, 18, 26, 20, 3, -26 },
  { 6990, 29, 26, 31, 3, -26 },
  { 7085, 22, 26, 21, -1, -26 },
  { 7157, 23, 36, 20, -2, -26 },
  { 7261, 21, 26, 21, 0, -26 },
  { 7330, 16, 47, 15, 1, -38 },
  { 7424, 10, 41, 12, 1, -35 },
  { 7476, 15, 47, 15, -2, -38 },
  { 7565, 24, 10, 28, 2, -20 },
};

const GFXfont RobotoCondensed_Italic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_ITALIC49PT7B_H_
