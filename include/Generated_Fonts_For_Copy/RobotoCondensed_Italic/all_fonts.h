#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoCondensed_Italic
// Headers: 67

#include "RobotoCondensed_Italic6pt7b.h"
#include "RobotoCondensed_Italic7pt7b.h"
#include "RobotoCondensed_Italic8pt7b.h"
#include "RobotoCondensed_Italic9pt7b.h"
#include "RobotoCondensed_Italic10pt7b.h"
#include "RobotoCondensed_Italic11pt7b.h"
#include "RobotoCondensed_Italic12pt7b.h"
#include "RobotoCondensed_Italic13pt7b.h"
#include "RobotoCondensed_Italic14pt7b.h"
#include "RobotoCondensed_Italic15pt7b.h"
#include "RobotoCondensed_Italic16pt7b.h"
#include "RobotoCondensed_Italic17pt7b.h"
#include "RobotoCondensed_Italic18pt7b.h"
#include "RobotoCondensed_Italic19pt7b.h"
#include "RobotoCondensed_Italic20pt7b.h"
#include "RobotoCondensed_Italic21pt7b.h"
#include "RobotoCondensed_Italic22pt7b.h"
#include "RobotoCondensed_Italic23pt7b.h"
#include "RobotoCondensed_Italic24pt7b.h"
#include "RobotoCondensed_Italic25pt7b.h"
#include "RobotoCondensed_Italic26pt7b.h"
#include "RobotoCondensed_Italic27pt7b.h"
#include "RobotoCondensed_Italic28pt7b.h"
#include "RobotoCondensed_Italic29pt7b.h"
#include "RobotoCondensed_Italic30pt7b.h"
#include "RobotoCondensed_Italic31pt7b.h"
#include "RobotoCondensed_Italic32pt7b.h"
#include "RobotoCondensed_Italic33pt7b.h"
#include "RobotoCondensed_Italic34pt7b.h"
#include "RobotoCondensed_Italic35pt7b.h"
#include "RobotoCondensed_Italic36pt7b.h"
#include "RobotoCondensed_Italic37pt7b.h"
#include "RobotoCondensed_Italic38pt7b.h"
#include "RobotoCondensed_Italic39pt7b.h"
#include "RobotoCondensed_Italic40pt7b.h"
#include "RobotoCondensed_Italic41pt7b.h"
#include "RobotoCondensed_Italic42pt7b.h"
#include "RobotoCondensed_Italic43pt7b.h"
#include "RobotoCondensed_Italic44pt7b.h"
#include "RobotoCondensed_Italic45pt7b.h"
#include "RobotoCondensed_Italic46pt7b.h"
#include "RobotoCondensed_Italic47pt7b.h"
#include "RobotoCondensed_Italic48pt7b.h"
#include "RobotoCondensed_Italic49pt7b.h"
#include "RobotoCondensed_Italic50pt7b.h"
#include "RobotoCondensed_Italic51pt7b.h"
#include "RobotoCondensed_Italic52pt7b.h"
#include "RobotoCondensed_Italic53pt7b.h"
#include "RobotoCondensed_Italic54pt7b.h"
#include "RobotoCondensed_Italic55pt7b.h"
#include "RobotoCondensed_Italic56pt7b.h"
#include "RobotoCondensed_Italic57pt7b.h"
#include "RobotoCondensed_Italic58pt7b.h"
#include "RobotoCondensed_Italic59pt7b.h"
#include "RobotoCondensed_Italic60pt7b.h"
#include "RobotoCondensed_Italic61pt7b.h"
#include "RobotoCondensed_Italic62pt7b.h"
#include "RobotoCondensed_Italic63pt7b.h"
#include "RobotoCondensed_Italic64pt7b.h"
#include "RobotoCondensed_Italic65pt7b.h"
#include "RobotoCondensed_Italic66pt7b.h"
#include "RobotoCondensed_Italic67pt7b.h"
#include "RobotoCondensed_Italic68pt7b.h"
#include "RobotoCondensed_Italic69pt7b.h"
#include "RobotoCondensed_Italic70pt7b.h"
#include "RobotoCondensed_Italic71pt7b.h"
#include "RobotoCondensed_Italic72pt7b.h"
