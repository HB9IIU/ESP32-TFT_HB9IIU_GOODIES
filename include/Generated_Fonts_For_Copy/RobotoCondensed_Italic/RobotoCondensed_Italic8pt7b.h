#ifndef _ROBOTOCONDENSED_ITALIC8PT7B_H_
#define _ROBOTOCONDENSED_ITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xC0, 0x23, 0x56, 0x7A, 0x22, 0x54, 0x2A, 0x64, 0x9E,
  0xBE, 0xC0, 0x25, 0x65, 0xBF, 0x80, 0x29, 0x49, 0x22, 0x55, 0x58, 0x23,
  0x42, 0x22, 0xF4, 0xC0, 0xC0, 0x80, 0x05, 0x29, 0x00, 0x25, 0x99, 0xA6,
  0x75, 0xA0, 0x61, 0x12, 0x4E, 0x61, 0x26, 0xAE, 0x12, 0x6A, 0xE2, 0x74,
  0x61, 0x96, 0x29, 0xDA, 0xC0, 0x71, 0x22, 0x44, 0x25, 0x56, 0xA6, 0xD6,
  0xE5, 0x00, 0x02, 0x02, 0x80, 0x71, 0x80, 0x6C, 0x47, 0x00, 0xD6, 0x20,
  0x39, 0x15, 0x6D, 0xD6, 0xE8, 0x18, 0x22, 0x55, 0xF9, 0x65, 0x5B, 0x9E,
  0x35, 0x48, 0x96, 0x65, 0x59, 0x9E, 0x74, 0x4A, 0x8E, 0x74, 0x4A, 0x88,
  0x34, 0x4B, 0x97, 0x4A, 0x53, 0x69, 0x48, 0x56, 0xA0, 0x11, 0x12, 0xAE,
  0x4A, 0x98, 0xCA, 0x48, 0x49, 0x49, 0xC0, 0x45, 0x34, 0xAE, 0xBA, 0xA0,
  0x4A, 0x5B, 0x69, 0x48, 0x35, 0x59, 0x96, 0x75, 0x56, 0x88, 0x35, 0x99,
  0x96, 0x10, 0x65, 0x56, 0xA9, 0x25, 0x42, 0x96, 0xE9, 0x29, 0x00, 0x45,
  0x59, 0x96, 0x1A, 0xAC, 0xC8, 0x2D, 0x7B, 0xE9, 0x48, 0x42, 0x88, 0x46,
  0x48, 0x8A, 0xC4, 0x88, 0x71, 0x24, 0x4E, 0x55, 0xAA, 0x7C, 0x55, 0x6A,
  0x0A, 0x80, 0xE0, 0x80, 0x6E, 0xF0, 0x44, 0x79, 0xAE, 0x72, 0x30, 0x11,
  0x7A, 0xAE, 0x7E, 0x30, 0x69, 0x29, 0x00, 0x7A, 0xAE, 0x24, 0x49, 0xDB,
  0x40, 0x46, 0xA0, 0x20, 0xA4, 0x94, 0x44, 0x64, 0xAA, 0x56, 0xA0, 0x7D,
  0x6B, 0x50, 0x76, 0xD0, 0x79, 0x96, 0x76, 0xF9, 0x00, 0x7A, 0xAE, 0x22,
  0x52, 0x40, 0x68, 0xF0, 0x56, 0x40, 0x5A, 0xAE, 0xAD, 0x20, 0xDD, 0xAA,
  0x69, 0x50, 0xB5, 0x29, 0x00, 0x69, 0x70, 0x49, 0x45, 0x20, 0x56, 0xA8,
  0x55, 0xA8, 0x70,
};

const GFXglyph RobotoCondensed_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 3, 6, 5, 1, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 1, 1, -6 },
  { 18, 3, 8, 2, 0, -6 },
  { 21, 2, 8, 2, 0, -6 },
  { 23, 4, 4, 3, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 3, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 3, 6, 4, 1, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 3, 3, 0, -4 },
  { 67, 3, 2, 4, 0, -4 },
  { 68, 3, 3, 4, 0, -4 },
  { 70, 2, 6, 3, 1, -6 },
  { 72, 6, 8, 6, 0, -6 },
  { 78, 4, 6, 4, 0, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 2, 6, 2, 0, -6 },
  { 105, 4, 6, 4, 0, -6 },
  { 108, 5, 6, 4, 0, -6 },
  { 112, 3, 6, 4, 0, -6 },
  { 115, 6, 6, 6, 0, -6 },
  { 120, 5, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 0, -6 },
  { 127, 4, 6, 4, 0, -6 },
  { 130, 4, 7, 5, 0, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 3, 6, 4, 1, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 1, -6 },
  { 149, 5, 6, 6, 1, -6 },
  { 153, 5, 6, 4, 0, -6 },
  { 157, 4, 6, 4, 1, -6 },
  { 160, 4, 6, 4, 0, -6 },
  { 163, 2, 8, 2, 0, -7 },
  { 165, 1, 6, 3, 1, -6 },
  { 166, 2, 8, 2, 0, -7 },
  { 168, 3, 3, 3, 0, -6 },
  { 170, 3, 1, 3, 0, 0 },
  { 171, 1, 1, 2, 1, -6 },
  { 172, 3, 4, 4, 0, -4 },
  { 174, 4, 6, 4, 0, -6 },
  { 177, 3, 4, 4, 0, -4 },
  { 179, 4, 6, 4, 0, -6 },
  { 182, 3, 4, 4, 0, -4 },
  { 184, 3, 6, 2, 0, -6 },
  { 187, 4, 6, 4, 0, -4 },
  { 190, 3, 6, 4, 0, -6 },
  { 193, 2, 6, 2, 0, -6 },
  { 195, 3, 8, 2, -1, -6 },
  { 198, 4, 6, 4, 0, -6 },
  { 201, 2, 6, 2, 0, -6 },
  { 203, 5, 4, 6, 0, -4 },
  { 206, 3, 4, 4, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 3, 6, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 3, 4, 2, 0, -4 },
  { 218, 3, 4, 4, 0, -4 },
  { 220, 2, 5, 2, 0, -5 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 3, 4, 3, 0, -4 },
  { 226, 4, 4, 5, 1, -4 },
  { 228, 3, 4, 3, 0, -4 },
  { 230, 3, 6, 3, 0, -4 },
  { 233, 3, 4, 3, 0, -4 },
  { 235, 3, 7, 2, 0, -6 },
  { 238, 2, 7, 2, 0, -6 },
  { 240, 2, 7, 2, 0, -6 },
  { 242, 4, 1, 5, 0, -3 },
};

const GFXfont RobotoCondensed_Italic8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_ITALIC8PT7B_H_
