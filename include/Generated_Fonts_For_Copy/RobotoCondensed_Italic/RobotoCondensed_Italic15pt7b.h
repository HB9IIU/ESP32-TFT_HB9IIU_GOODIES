#ifndef _ROBOTOCONDENSED_ITALIC15PT7B_H_
#define _ROBOTOCONDENSED_ITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x22, 0x22, 0x64, 0x40, 0x04, 0x40, 0x55, 0x5A, 0x12, 0x24, 0x53,
  0xF2, 0x45, 0x0A, 0x7E, 0x50, 0xA2, 0x40, 0x10, 0x43, 0x9B, 0x45, 0x06,
  0x0C, 0x18, 0x28, 0xA6, 0xF1, 0x00, 0x70, 0xA6, 0x54, 0xA6, 0x82, 0x07,
  0x95, 0x4A, 0x94, 0x30, 0x1C, 0x68, 0x91, 0x23, 0x86, 0x1E, 0xA5, 0xCC,
  0x99, 0xF8, 0x5A, 0x13, 0x24, 0x4C, 0x88, 0x88, 0x88, 0x84, 0x40, 0x20,
  0x84, 0x30, 0x84, 0x63, 0x10, 0x84, 0x42, 0x22, 0x00, 0x10, 0x8F, 0xC8,
  0x52, 0x40, 0x10, 0xC3, 0x3F, 0x20, 0x86, 0x00, 0x69, 0x40, 0xE0, 0x70,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x18, 0x20, 0xC1, 0x02, 0x00, 0x39,
  0x34, 0x71, 0x8E, 0x38, 0xA2, 0x8A, 0x47, 0x00, 0x3E, 0x22, 0x26, 0x64,
  0x44, 0x40, 0x1C, 0x4D, 0x98, 0x30, 0x41, 0x86, 0x18, 0x20, 0x83, 0xF0,
  0x1C, 0x49, 0x98, 0x30, 0x43, 0x03, 0x02, 0xC4, 0x91, 0xE0, 0x06, 0x18,
  0x30, 0xA2, 0x4D, 0x93, 0x7F, 0x08, 0x10, 0x20, 0x3D, 0x84, 0x10, 0x79,
  0x20, 0x82, 0x8A, 0x67, 0x00, 0x19, 0x10, 0x8F, 0xE6, 0x31, 0x8E, 0xDC,
  0x7C, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x00, 0x1C, 0x6C,
  0x89, 0x32, 0x47, 0x11, 0x22, 0x44, 0x99, 0xE0, 0x39, 0x2C, 0xE3, 0x8F,
  0x27, 0x82, 0x10, 0xCE, 0x00, 0x2C, 0x00, 0x16, 0x13, 0x00, 0x00, 0x66,
  0x4C, 0x09, 0xD9, 0x0C, 0x18, 0x40, 0xF8, 0x00, 0x3E, 0x40, 0xC1, 0xC1,
  0x19, 0x88, 0x00, 0x72, 0x72, 0x11, 0x99, 0x88, 0x02, 0x10, 0x07, 0x83,
  0x08, 0x81, 0x13, 0x94, 0x92, 0x92, 0x54, 0x92, 0x92, 0x92, 0x4B, 0xF1,
  0x00, 0x20, 0x03, 0xC0, 0x0C, 0x18, 0x30, 0xA1, 0x44, 0xC8, 0xBF, 0x43,
  0x86, 0x08, 0x3E, 0x22, 0x23, 0x22, 0x66, 0x7C, 0x46, 0x42, 0x46, 0x44,
  0xF8, 0x3C, 0xCD, 0x0E, 0x1C, 0x10, 0x20, 0x42, 0x85, 0x99, 0xE0, 0x3C,
  0x22, 0x23, 0x23, 0x63, 0x63, 0x42, 0x42, 0x46, 0x4C, 0xF8, 0x3F, 0x20,
  0x20, 0x20, 0x60, 0x7C, 0x40, 0x40, 0x40, 0x40, 0xFC, 0x3F, 0x20, 0x20,
  0x20, 0x60, 0x7C, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x3C, 0xCD, 0x0E, 0x0C,
  0x10, 0x27, 0xC2, 0x85, 0x99, 0xE0, 0x20, 0x90, 0xC8, 0x64, 0x26, 0x13,
  0xF9, 0x04, 0x86, 0x43, 0x21, 0x30, 0x80, 0x22, 0x22, 0x66, 0x44, 0x44,
  0xC0, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x8D, 0x91, 0xC0, 0x21,
  0x11, 0x09, 0x85, 0x87, 0x83, 0xC1, 0xA0, 0x98, 0x44, 0x22, 0x31, 0x80,
  0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x0F, 0xC0, 0x30, 0x66, 0x0C,
  0xC3, 0x98, 0x67, 0x14, 0xF2, 0x92, 0x92, 0x56, 0x4C, 0xC9, 0x93, 0x32,
  0x00, 0x30, 0x98, 0xCC, 0x67, 0x26, 0x93, 0x49, 0x34, 0x8E, 0x47, 0x23,
  0x30, 0x80, 0x3C, 0xCD, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x85, 0x99, 0xE0,
  0x3E, 0x23, 0x21, 0x21, 0x63, 0x62, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x3C,
  0xCD, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x85, 0x99, 0xE0, 0x60, 0x40, 0x3E,
  0x22, 0x23, 0x23, 0x62, 0x66, 0x7C, 0x4C, 0x44, 0x44, 0xC6, 0x1C, 0x32,
  0x23, 0x20, 0x30, 0x1C, 0x04, 0x06, 0xC6, 0x44, 0x38, 0xFE, 0x20, 0x40,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x80, 0x42, 0x85, 0x0E, 0x3C, 0x70,
  0xA1, 0x42, 0x85, 0x11, 0xC0, 0xC3, 0x42, 0x46, 0x44, 0x44, 0x48, 0x48,
  0x78, 0x70, 0x30, 0x20, 0x44, 0x68, 0x89, 0x31, 0x26, 0x65, 0xC8, 0xA9,
  0x14, 0xC3, 0x18, 0x63, 0x0C, 0x41, 0x08, 0x00, 0x21, 0x11, 0x8D, 0x82,
  0x81, 0xC0, 0xC0, 0x60, 0x78, 0x64, 0x22, 0x31, 0x80, 0xC2, 0x46, 0x44,
  0x68, 0x78, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x3F, 0x02, 0x06, 0x04,
  0x08, 0x18, 0x30, 0x20, 0x40, 0xC0, 0xFC, 0x31, 0x08, 0x46, 0x31, 0x08,
  0x42, 0x11, 0x88, 0x60, 0x49, 0x24, 0x93, 0x24, 0x90, 0x38, 0xC4, 0x21,
  0x08, 0xC6, 0x21, 0x08, 0x42, 0x70, 0x22, 0x5D, 0x90, 0xFC, 0x90, 0x3D,
  0x90, 0x4F, 0x47, 0x3C, 0x9E, 0x20, 0x40, 0x81, 0x07, 0xCC, 0x91, 0xA3,
  0x44, 0x8B, 0x35, 0xC0, 0x3D, 0x94, 0x50, 0x41, 0x14, 0x9E, 0x02, 0x04,
  0x08, 0x13, 0xEC, 0xD1, 0x22, 0x44, 0x89, 0x33, 0xE0, 0x3D, 0x94, 0x5F,
  0x41, 0x04, 0x9E, 0x39, 0x18, 0x8F, 0x21, 0x18, 0xC4, 0x21, 0x00, 0x3A,
  0xCD, 0x12, 0x24, 0x48, 0x93, 0x3E, 0x09, 0x31, 0xC0, 0x20, 0x82, 0x08,
  0x7D, 0x94, 0x51, 0x45, 0x1C, 0xF2, 0x24, 0x16, 0x92, 0x4B, 0x00, 0x11,
  0x03, 0x32, 0x22, 0x26, 0x64, 0x4C, 0x20, 0x40, 0x81, 0x06, 0x4D, 0x16,
  0x38, 0x70, 0xB3, 0x26, 0x40, 0x22, 0x22, 0x26, 0x44, 0x44, 0x4C, 0x7D,
  0xD9, 0x94, 0x45, 0x11, 0x44, 0x51, 0x3C, 0xCF, 0x22, 0x7D, 0x94, 0x51,
  0x45, 0x1C, 0xF2, 0x3C, 0xC9, 0x1A, 0x34, 0x48, 0x93, 0x1C, 0x7C, 0xC9,
  0x1A, 0x24, 0x48, 0xB3, 0x7C, 0x81, 0x02, 0x00, 0x3A, 0xCD, 0x12, 0x24,
  0x48, 0x93, 0x3E, 0x08, 0x10, 0x20, 0x7B, 0x10, 0x84, 0x23, 0x18, 0x39,
  0x94, 0x0C, 0x1B, 0x3C, 0x9E, 0x4B, 0xA5, 0xA4, 0x98, 0xCF, 0x28, 0xA2,
  0x8A, 0x69, 0xBC, 0x8C, 0x65, 0x26, 0x31, 0x88, 0x89, 0xCC, 0xA6, 0xD5,
  0x4A, 0xA7, 0x63, 0x31, 0x98, 0x64, 0x58, 0xE1, 0x83, 0x0E, 0x16, 0x44,
  0x22, 0x4C, 0x91, 0x23, 0x83, 0x04, 0x08, 0x30, 0x43, 0x00, 0x7C, 0x30,
  0x84, 0x21, 0x8C, 0x3E, 0x08, 0x84, 0x62, 0x10, 0x98, 0x43, 0x18, 0x84,
  0x30, 0x80, 0x24, 0x92, 0x92, 0x49, 0x68, 0x20, 0x84, 0x21, 0x08, 0x41,
  0x31, 0x08, 0x42, 0x22, 0x00, 0x63, 0x2A, 0x70,
};

const GFXglyph RobotoCondensed_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 1, -11 },
  { 9, 7, 11, 8, 1, -11 },
  { 19, 6, 14, 7, 1, -13 },
  { 30, 7, 11, 9, 1, -11 },
  { 40, 7, 11, 8, 0, -11 },
  { 50, 2, 4, 3, 1, -11 },
  { 51, 4, 15, 5, 1, -12 },
  { 59, 5, 15, 5, -1, -12 },
  { 69, 6, 6, 6, 1, -11 },
  { 74, 6, 7, 7, 1, -8 },
  { 80, 3, 4, 3, -1, -2 },
  { 82, 3, 1, 4, 0, -5 },
  { 83, 2, 2, 4, 0, -2 },
  { 84, 7, 12, 5, -1, -11 },
  { 95, 6, 11, 7, 1, -11 },
  { 104, 4, 11, 7, 2, -11 },
  { 110, 7, 11, 7, 0, -11 },
  { 120, 7, 11, 7, 0, -11 },
  { 130, 7, 11, 7, 0, -11 },
  { 140, 6, 11, 7, 1, -11 },
  { 149, 5, 11, 7, 1, -11 },
  { 156, 7, 11, 7, 1, -11 },
  { 166, 7, 11, 7, 0, -11 },
  { 176, 6, 11, 7, 1, -11 },
  { 185, 3, 8, 3, 0, -8 },
  { 188, 4, 10, 3, -1, -8 },
  { 193, 5, 7, 6, 1, -8 },
  { 198, 6, 4, 7, 1, -7 },
  { 201, 6, 7, 7, 0, -8 },
  { 207, 5, 11, 6, 1, -11 },
  { 214, 11, 13, 11, 0, -10 },
  { 232, 7, 11, 8, 0, -11 },
  { 242, 8, 11, 8, 0, -11 },
  { 253, 7, 11, 8, 1, -11 },
  { 263, 8, 11, 8, 0, -11 },
  { 274, 8, 11, 7, 0, -11 },
  { 285, 8, 11, 7, 0, -11 },
  { 296, 7, 11, 9, 1, -11 },
  { 306, 9, 11, 9, 0, -11 },
  { 319, 4, 11, 4, 0, -11 },
  { 325, 7, 11, 7, 0, -11 },
  { 335, 9, 11, 8, 0, -11 },
  { 348, 6, 11, 7, 0, -11 },
  { 357, 11, 11, 11, 0, -11 },
  { 373, 9, 11, 9, 0, -11 },
  { 386, 7, 11, 9, 1, -11 },
  { 396, 8, 11, 8, 0, -11 },
  { 407, 7, 13, 9, 1, -11 },
  { 419, 8, 11, 8, 0, -11 },
  { 430, 8, 11, 8, 0, -11 },
  { 441, 7, 11, 8, 1, -11 },
  { 451, 7, 11, 8, 1, -11 },
  { 461, 8, 11, 8, 1, -11 },
  { 472, 11, 11, 11, 1, -11 },
  { 488, 9, 11, 8, 0, -11 },
  { 501, 8, 11, 8, 1, -11 },
  { 512, 8, 11, 8, 0, -11 },
  { 523, 5, 14, 4, 0, -12 },
  { 532, 3, 12, 5, 1, -11 },
  { 537, 5, 14, 4, -1, -12 },
  { 546, 4, 5, 5, 1, -11 },
  { 549, 6, 1, 6, -1, 0 },
  { 550, 2, 2, 5, 2, -11 },
  { 551, 6, 8, 7, 0, -8 },
  { 557, 7, 12, 7, 0, -12 },
  { 568, 6, 8, 7, 0, -8 },
  { 574, 7, 12, 7, 0, -12 },
  { 585, 6, 8, 7, 0, -8 },
  { 591, 5, 12, 5, 1, -12 },
  { 599, 7, 11, 7, 0, -8 },
  { 609, 6, 12, 7, 0, -12 },
  { 618, 3, 11, 3, 0, -11 },
  { 623, 4, 14, 3, -1, -11 },
  { 630, 7, 12, 7, 0, -12 },
  { 641, 4, 12, 3, 0, -12 },
  { 647, 10, 8, 11, 0, -8 },
  { 657, 6, 8, 7, 0, -8 },
  { 663, 7, 8, 7, 0, -8 },
  { 670, 7, 11, 7, 0, -8 },
  { 680, 7, 11, 7, 0, -8 },
  { 690, 5, 8, 4, 0, -8 },
  { 695, 6, 8, 7, 0, -8 },
  { 701, 3, 10, 4, 1, -10 },
  { 705, 6, 8, 7, 1, -8 },
  { 711, 5, 8, 6, 1, -8 },
  { 716, 9, 8, 9, 1, -8 },
  { 725, 7, 8, 6, 0, -8 },
  { 732, 7, 11, 6, -1, -8 },
  { 742, 6, 8, 6, 0, -8 },
  { 748, 5, 15, 4, 0, -12 },
  { 758, 3, 13, 4, 0, -11 },
  { 763, 5, 15, 4, -1, -12 },
  { 773, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_Italic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_ITALIC15PT7B_H_
