#ifndef _ROBOTOCONDENSED_ITALIC30PT7B_H_
#define _ROBOTOCONDENSED_ITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x31, 0xC7,
  0x18, 0x00, 0x00, 0x30, 0xE3, 0x00, 0x66, 0xCD, 0x9E, 0x6C, 0xD9, 0xB3,
  0x00, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x63,
  0x07, 0xFF, 0x8F, 0xFF, 0x07, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x00,
  0xC6, 0x01, 0x8C, 0x1F, 0xFE, 0x7F, 0xFC, 0x18, 0xC0, 0x33, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x30, 0x0C, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x07, 0x80, 0xFE, 0x0F, 0x38, 0x70, 0xC3, 0x07, 0x38, 0x39, 0xC1, 0xCE,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x38, 0x19, 0xC0, 0xCE, 0x0E, 0x30, 0x71, 0xEF, 0x07, 0xF0, 0x1F, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x00, 0x3C, 0x01, 0xF8, 0x0E, 0x61, 0x31, 0x86,
  0xC6, 0x33, 0x19, 0x8C, 0x66, 0x33, 0xB0, 0xFD, 0x81, 0xE6, 0x00, 0x30,
  0x01, 0x80, 0x06, 0xF0, 0x37, 0xE1, 0x99, 0x86, 0xC2, 0x33, 0x09, 0x8C,
  0x66, 0x31, 0x90, 0xC6, 0x01, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x3F, 0x80,
  0xE7, 0x07, 0x1C, 0x1C, 0x70, 0x61, 0xC1, 0xC6, 0x07, 0x38, 0x0F, 0xC0,
  0x3E, 0x00, 0xE0, 0x07, 0xC0, 0x3B, 0x1D, 0xCE, 0x6E, 0x19, 0xB8, 0x7E,
  0xE0, 0xF3, 0x83, 0xCE, 0x0E, 0x1C, 0x7C, 0x7F, 0xB0, 0x7C, 0xE0, 0x7F,
  0x6D, 0xA0, 0x01, 0x03, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x10, 0x08, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18,
  0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x06, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x18,
  0x43, 0x1F, 0x6F, 0xFF, 0xC7, 0xC0, 0xF0, 0x3F, 0x0E, 0x63, 0x8E, 0x20,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x81, 0xFF,
  0xEF, 0xFE, 0xFF, 0xF0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x18, 0xCE, 0x77, 0x31, 0x00, 0xFF, 0xF0, 0xFF, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0x03, 0xC0, 0x7F, 0x07, 0x9C, 0x30, 0x63, 0x83, 0x18,
  0x18, 0xC0, 0xE6, 0x06, 0x70, 0x33, 0x81, 0x9C, 0x0C, 0xC0, 0xE6, 0x07,
  0x30, 0x39, 0x81, 0x9C, 0x0C, 0x60, 0x63, 0x07, 0x18, 0x30, 0xE7, 0x83,
  0xF8, 0x0F, 0x00, 0x02, 0x3D, 0xFF, 0xFC, 0xE1, 0x83, 0x06, 0x1C, 0x38,
  0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x00, 0x03,
  0xE0, 0x1F, 0xC0, 0xE3, 0x87, 0x06, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0x80,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x07, 0xC0, 0xFE, 0x1C, 0x73, 0x87, 0x38, 0x33, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x1E, 0x0F, 0xC0, 0xFC, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0xC0, 0xEC, 0x0E, 0xE1, 0xC7, 0x3C, 0x7F, 0x81, 0xE0, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xD8, 0x0E, 0xC0, 0x66,
  0x06, 0x70, 0x73, 0x83, 0x1C, 0x38, 0xC3, 0x86, 0x18, 0x31, 0xC3, 0x9F,
  0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x37, 0x83, 0xFE, 0x1E, 0xF0, 0x41, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0xC0, 0xE6, 0x06, 0x30, 0x71, 0xC7, 0x07, 0xF0, 0x1F, 0x00, 0x01,
  0xC0, 0xF8, 0x3C, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x78, 0x7F, 0x9F,
  0x3B, 0x83, 0x70, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC0, 0xD8, 0x3B,
  0x86, 0x39, 0xC7, 0xF0, 0x7C, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x7F, 0x07, 0x9C, 0x38,
  0x61, 0x83, 0x9C, 0x1C, 0xE0, 0xC7, 0x06, 0x18, 0x70, 0xE7, 0x03, 0xF0,
  0x3F, 0x83, 0x8C, 0x38, 0x73, 0x81, 0x9C, 0x0C, 0xE0, 0x67, 0x07, 0x38,
  0x30, 0xE7, 0x87, 0xF8, 0x0F, 0x80, 0x0F, 0x83, 0xF8, 0xE7, 0x38, 0x77,
  0x06, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xB0, 0xF7, 0x3E,
  0xFF, 0x87, 0xB0, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x0F, 0x07, 0xC0, 0xE0,
  0x00, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x9C, 0x0E,
  0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0C,
  0x18, 0x70, 0xC3, 0x86, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xE3, 0xE1,
  0xF0, 0x38, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x08, 0x7F,
  0xEF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x20, 0x03,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x0F, 0xE7, 0x9D, 0xC3, 0x60,
  0xC0, 0x30, 0x0C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x03, 0xC1, 0xC0, 0x70, 0x06, 0x0E, 0x00, 0x60, 0xC0,
  0x03, 0x18, 0x3C, 0x33, 0x8F, 0xE3, 0x30, 0xC6, 0x33, 0x18, 0x63, 0x61,
  0x8E, 0x36, 0x30, 0xC3, 0x63, 0x0C, 0x3C, 0x30, 0xC3, 0xC7, 0x0C, 0x3C,
  0x61, 0x82, 0xC6, 0x18, 0x6C, 0x61, 0x84, 0xC7, 0x38, 0xCC, 0x3F, 0xF8,
  0xC3, 0xCF, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x81, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xD8, 0x01, 0xDC, 0x01, 0x9C,
  0x03, 0x9C, 0x03, 0x0C, 0x07, 0x0C, 0x07, 0x0C, 0x0E, 0x0C, 0x0E, 0x0C,
  0x0F, 0xFE, 0x1F, 0xFE, 0x18, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x70, 0x06,
  0x60, 0x06, 0xE0, 0x07, 0x1F, 0xE0, 0x7F, 0xE1, 0xC3, 0xC6, 0x07, 0x18,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xC1, 0xC3, 0xFE, 0x1F,
  0xF8, 0x70, 0x71, 0xC0, 0xE7, 0x03, 0x98, 0x0E, 0x60, 0x3B, 0x80, 0xCE,
  0x07, 0x38, 0x78, 0xFF, 0xE3, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xE3,
  0x8E, 0x07, 0x38, 0x1D, 0xC0, 0x37, 0x00, 0xD8, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0E, 0xC0,
  0x33, 0x81, 0xCE, 0x07, 0x1C, 0x78, 0x3F, 0xC0, 0x7C, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x71, 0xE0, 0xC0, 0xE1, 0x81, 0xC7, 0x01, 0x8E, 0x03, 0x1C,
  0x07, 0x38, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0x9C, 0x07, 0x30, 0x0C, 0x60, 0x39, 0xC0, 0xE3, 0x81, 0xC7, 0x0F, 0x0F,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0xFF, 0x1F,
  0xF8, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0xFE, 0x1F, 0xF8, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0xE1, 0xE3, 0x8E, 0x07, 0x30, 0x1D, 0xC0, 0x37, 0x00, 0xD8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x7E, 0xE1, 0xFB, 0x00, 0xEC, 0x03,
  0xB0, 0x0E, 0xC0, 0x3B, 0x80, 0xCE, 0x07, 0x1E, 0x7C, 0x3F, 0xE0, 0x7E,
  0x00, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x31,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x0F, 0xFF,
  0x8F, 0xFF, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x18, 0x60,
  0x0C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xC0,
  0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC7, 0x1C,
  0x61, 0x8E, 0x38, 0xE3, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xE0, 0x63, 0x83,
  0x86, 0x0E, 0x1C, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x1C, 0x07, 0x0E, 0x07,
  0x07, 0x07, 0x03, 0x07, 0x81, 0x87, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x73,
  0x80, 0x3B, 0x80, 0x1B, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xCE, 0x01, 0xC7, 0x00, 0xC1, 0x80, 0x60, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x03, 0x86, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x33,
  0x03, 0x71, 0x98, 0x3B, 0x0C, 0xC1, 0x98, 0xE6, 0x1D, 0xC7, 0x30, 0xCE,
  0x39, 0xCE, 0x71, 0xCE, 0x63, 0x8C, 0x37, 0x18, 0x61, 0xB0, 0xC7, 0x0F,
  0x8E, 0x38, 0x78, 0x71, 0xC3, 0xC3, 0x8E, 0x1C, 0x18, 0x60, 0xE0, 0xC0,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x61, 0xE0, 0x31, 0xF8,
  0x38, 0xEC, 0x1C, 0x76, 0x0E, 0x3B, 0x87, 0x18, 0xC3, 0x0C, 0x61, 0x8E,
  0x39, 0xC7, 0x0C, 0xE3, 0x86, 0x71, 0xC3, 0xB8, 0xC0, 0xD8, 0x60, 0x6C,
  0x70, 0x3E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xC6, 0x00, 0xC0, 0x03,
  0xE0, 0x1F, 0xF0, 0x79, 0xE1, 0xC0, 0xE3, 0x81, 0xCE, 0x01, 0x9C, 0x03,
  0x30, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xD8,
  0x03, 0xB0, 0x06, 0x60, 0x0C, 0xC0, 0x39, 0xC0, 0x63, 0x81, 0xC3, 0xCF,
  0x03, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x70, 0x70, 0xC0,
  0x71, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x38,
  0xC1, 0xF3, 0xFF, 0xC7, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0xC1, 0xE7, 0x8E, 0x07, 0x30, 0x1D, 0xC0, 0x37, 0x00, 0xD8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x6C,
  0x01, 0xB0, 0x0E, 0xC0, 0x3B, 0x81, 0xCE, 0x07, 0x1E, 0x78, 0x7F, 0xC0,
  0x7F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0x1F, 0xE0, 0x7F,
  0xE1, 0xC3, 0xC6, 0x07, 0x18, 0x0C, 0xE0, 0x33, 0x80, 0xCE, 0x07, 0x38,
  0x1C, 0xC0, 0xE3, 0x07, 0x9F, 0xFC, 0x7F, 0xC1, 0xC3, 0x07, 0x0E, 0x18,
  0x38, 0x60, 0xE3, 0x81, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x00, 0xC0,
  0x03, 0xE0, 0x3F, 0xC1, 0xE3, 0x87, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0xC0, 0x33, 0x01, 0xCE, 0x07, 0x1E, 0x78, 0x7F,
  0xC0, 0x7C, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x06,
  0x38, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0C,
  0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x18,
  0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0x70, 0x78, 0xF0, 0x3F, 0xE0,
  0x1F, 0x80, 0xC0, 0x0F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C,
  0x0E, 0x18, 0x1C, 0x30, 0x30, 0x60, 0xE0, 0xC1, 0xC1, 0xC7, 0x03, 0x8E,
  0x07, 0x18, 0x0E, 0x70, 0x0C, 0xC0, 0x1B, 0x80, 0x36, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x3E, 0x06,
  0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x06, 0xE1, 0xF0, 0xEE, 0x1B, 0x0E, 0xE1,
  0xB0, 0xCE, 0x3B, 0x1C, 0xE3, 0x31, 0xCE, 0x33, 0x18, 0xE6, 0x33, 0x8E,
  0x63, 0x38, 0xEE, 0x33, 0x0E, 0xC3, 0x70, 0x6C, 0x37, 0x07, 0xC3, 0x60,
  0x78, 0x36, 0x07, 0x83, 0xC0, 0x70, 0x3C, 0x07, 0x03, 0xC0, 0x70, 0x38,
  0x06, 0x01, 0x80, 0x1C, 0x03, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0,
  0x61, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x1C,
  0xC0, 0x1C, 0x70, 0x1E, 0x38, 0x0E, 0x0C, 0x0E, 0x07, 0x0F, 0x03, 0x87,
  0x00, 0xE0, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0x98, 0x1C, 0x60, 0xE1, 0xC3,
  0x87, 0x1C, 0x0C, 0x70, 0x33, 0x80, 0xEC, 0x03, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0x87, 0xC3, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1F, 0x0F, 0x80, 0xC6, 0x39,
  0xC6, 0x31, 0x8C, 0x63, 0x9C, 0x63, 0x18, 0xC6, 0x31, 0xCE, 0x31, 0x8C,
  0x63, 0x07, 0xC1, 0xE0, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x81, 0xE0,
  0xF8, 0x00, 0x06, 0x03, 0x83, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x67, 0x71,
  0xB0, 0xF8, 0x60, 0x7F, 0xF7, 0xFF, 0xE3, 0x8C, 0x30, 0x07, 0x83, 0xFC,
  0xF3, 0x98, 0x37, 0x06, 0x00, 0xC3, 0xF9, 0xFF, 0x70, 0xFC, 0x1F, 0x83,
  0x60, 0x6E, 0x1D, 0xEF, 0x9F, 0xF1, 0xEE, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBC, 0x1F, 0xF0, 0xF3, 0xCE,
  0x0E, 0x70, 0x33, 0x81, 0x9C, 0x1C, 0xC0, 0xE6, 0x07, 0x70, 0x3B, 0x81,
  0x9C, 0x0C, 0xE0, 0xE7, 0x8E, 0x37, 0xF3, 0x9E, 0x00, 0x0F, 0x81, 0xFC,
  0x38, 0xE7, 0x06, 0x70, 0x76, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x0E, 0xE0, 0xC7, 0x1C, 0x7F, 0x81, 0xE0, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x83, 0xCE, 0x1F,
  0xB0, 0xF3, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x06, 0x38,
  0x18, 0xE0, 0x63, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0x73, 0xC1, 0xFF, 0x03,
  0xEC, 0x00, 0x07, 0x81, 0xFC, 0x38, 0xE7, 0x06, 0x70, 0x66, 0x07, 0xE0,
  0x7F, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x87, 0x1C, 0x7F,
  0x81, 0xF0, 0x03, 0xC1, 0xF0, 0xF0, 0x38, 0x0C, 0x07, 0x01, 0xC1, 0xFC,
  0x7F, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x00, 0x07, 0x9C, 0x3F, 0x61, 0xE7,
  0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x31, 0xC0,
  0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x70, 0xE7, 0x83, 0xFE, 0x07, 0x98, 0x00,
  0xE0, 0x03, 0x84, 0x1C, 0x38, 0xF0, 0x7F, 0x80, 0xF8, 0x00, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBC, 0x1F,
  0xF0, 0xF3, 0x8F, 0x0C, 0x70, 0x63, 0x83, 0x1C, 0x18, 0xC0, 0xC6, 0x0E,
  0x70, 0x73, 0x83, 0x9C, 0x18, 0xE0, 0xC6, 0x06, 0x30, 0x73, 0x83, 0x80,
  0x1C, 0x71, 0x80, 0x00, 0x03, 0x8E, 0x30, 0xC3, 0x1C, 0x71, 0xC6, 0x18,
  0x63, 0x8E, 0x38, 0xC3, 0x00, 0x01, 0x80, 0x70, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x0F, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x0E, 0x18, 0x70, 0x63, 0x83, 0x9C, 0x0E,
  0xF0, 0x3B, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7B, 0x81, 0xCE, 0x07,
  0x18, 0x1C, 0x70, 0x61, 0xC1, 0x83, 0x8E, 0x0E, 0x00, 0x1C, 0x71, 0xC6,
  0x18, 0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x38,
  0xE3, 0x0C, 0x00, 0x19, 0xE3, 0xE1, 0xFF, 0x7F, 0x1E, 0x7E, 0x71, 0x83,
  0x83, 0x38, 0x38, 0x33, 0x83, 0x83, 0x38, 0x30, 0x33, 0x03, 0x07, 0x30,
  0x70, 0x77, 0x07, 0x07, 0x70, 0x70, 0x67, 0x06, 0x06, 0x70, 0x60, 0x66,
  0x06, 0x0E, 0x60, 0xE0, 0xEE, 0x0E, 0x0E, 0x19, 0xE0, 0xFF, 0x87, 0x9C,
  0x38, 0x63, 0x83, 0x1C, 0x18, 0xE0, 0xC6, 0x06, 0x30, 0x73, 0x83, 0x9C,
  0x1C, 0xE0, 0xC7, 0x06, 0x30, 0x31, 0x83, 0x9C, 0x1C, 0x07, 0x81, 0xFE,
  0x3C, 0xE3, 0x07, 0x70, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x06, 0xE0, 0xE7, 0x1C, 0x3F, 0x81, 0xF0, 0x0C, 0xF0, 0x3F,
  0xE0, 0xF3, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x31, 0xC1, 0xC6, 0x07, 0x18,
  0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xF1, 0xC3, 0x7E, 0x1C,
  0xF0, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x0F, 0x38, 0xFD, 0x8F, 0x3C, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x81, 0xDC,
  0x0C, 0xE0, 0x67, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x39, 0xE1, 0xFF,
  0x07, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x1B, 0x8F, 0xC7, 0xE3, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0x0F, 0x83, 0xF8, 0xE7, 0x98, 0x77,
  0x06, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x60, 0x6E, 0x1D,
  0xE7, 0x1F, 0xE1, 0xF0, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFE, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x70, 0x78, 0x38,
  0x38, 0x33, 0x03, 0x30, 0x77, 0x07, 0x70, 0x77, 0x06, 0x70, 0x66, 0x06,
  0x60, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xC7, 0x3C, 0x7F, 0xC3, 0xDC,
  0xC0, 0xF8, 0x1B, 0x87, 0x70, 0xCE, 0x38, 0xC6, 0x18, 0xC3, 0x38, 0x66,
  0x0D, 0xC1, 0xB0, 0x36, 0x07, 0x80, 0x70, 0x0E, 0x01, 0x80, 0xC1, 0xC1,
  0xE0, 0xE1, 0xF0, 0x70, 0xDC, 0x78, 0x6E, 0x3C, 0x77, 0x3E, 0x33, 0x9B,
  0x39, 0xDD, 0x98, 0xEC, 0xCC, 0x36, 0x6E, 0x1E, 0x3E, 0x0F, 0x0F, 0x07,
  0x87, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0x1C, 0x1C, 0x30, 0xE0,
  0xE7, 0x03, 0x9C, 0x06, 0xE0, 0x1B, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xFC, 0x07, 0x70, 0x1C, 0xC0, 0xE3, 0x87, 0x0E, 0x1C, 0x18,
  0x18, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x1C, 0x70, 0x71, 0x80, 0xCE,
  0x03, 0x30, 0x0D, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x87, 0x83, 0x80, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x06, 0x01,
  0x00, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0x08, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x70, 0x1C, 0x1E, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x38, 0x10, 0x00, 0x1E, 0x06, 0x7E, 0x19,
  0xDE, 0x33, 0x1E, 0xE6, 0x1F, 0x80, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 7, 7, 9, 3, -23 },
  { 25, 15, 22, 16, 1, -22 },
  { 67, 13, 28, 14, 1, -25 },
  { 113, 14, 22, 18, 3, -22 },
  { 152, 14, 22, 16, 1, -22 },
  { 191, 3, 7, 5, 3, -23 },
  { 194, 8, 31, 9, 2, -24 },
  { 225, 9, 31, 9, -1, -24 },
  { 260, 11, 12, 13, 2, -22 },
  { 277, 13, 16, 14, 1, -18 },
  { 303, 5, 7, 6, -2, -3 },
  { 308, 6, 2, 7, 1, -10 },
  { 310, 3, 3, 8, 1, -3 },
  { 312, 13, 24, 11, -1, -22 },
  { 351, 13, 22, 14, 1, -22 },
  { 387, 7, 22, 14, 4, -22 },
  { 407, 14, 22, 14, 0, -22 },
  { 446, 12, 22, 14, 1, -22 },
  { 479, 13, 22, 14, 0, -22 },
  { 515, 13, 22, 14, 2, -22 },
  { 551, 11, 22, 14, 2, -22 },
  { 582, 13, 22, 14, 2, -22 },
  { 618, 13, 22, 14, 1, -22 },
  { 654, 11, 22, 14, 2, -22 },
  { 685, 5, 16, 7, 1, -16 },
  { 695, 7, 20, 6, -1, -16 },
  { 713, 11, 13, 13, 1, -16 },
  { 731, 11, 8, 14, 2, -14 },
  { 742, 12, 13, 13, 1, -16 },
  { 762, 10, 22, 12, 2, -22 },
  { 790, 20, 28, 22, 1, -21 },
  { 860, 16, 22, 17, -1, -22 },
  { 904, 14, 22, 16, 1, -22 },
  { 943, 14, 22, 17, 2, -22 },
  { 982, 15, 22, 17, 1, -22 },
  { 1024, 14, 22, 14, 1, -22 },
  { 1063, 14, 22, 14, 1, -22 },
  { 1102, 14, 22, 17, 2, -22 },
  { 1141, 17, 22, 18, 1, -22 },
  { 1188, 6, 22, 7, 1, -22 },
  { 1205, 14, 22, 14, 0, -22 },
  { 1244, 17, 22, 16, 1, -22 },
  { 1291, 11, 22, 14, 1, -22 },
  { 1322, 21, 22, 22, 1, -22 },
  { 1380, 17, 22, 18, 1, -22 },
  { 1427, 15, 22, 17, 2, -22 },
  { 1469, 15, 22, 16, 1, -22 },
  { 1511, 14, 26, 17, 2, -22 },
  { 1557, 14, 22, 15, 1, -22 },
  { 1596, 14, 22, 15, 1, -22 },
  { 1635, 14, 22, 15, 3, -22 },
  { 1674, 16, 22, 16, 1, -22 },
  { 1718, 15, 22, 16, 3, -22 },
  { 1760, 20, 22, 22, 3, -22 },
  { 1815, 17, 22, 16, 0, -22 },
  { 1862, 14, 22, 15, 3, -22 },
  { 1901, 16, 22, 15, 0, -22 },
  { 1945, 9, 29, 7, 0, -24 },
  { 1978, 5, 24, 11, 3, -22 },
  { 1993, 10, 29, 7, -2, -24 },
  { 2030, 9, 11, 11, 1, -22 },
  { 2043, 12, 2, 12, -2, 0 },
  { 2046, 5, 4, 9, 3, -22 },
  { 2049, 11, 16, 14, 1, -16 },
  { 2071, 13, 23, 14, 0, -23 },
  { 2109, 12, 16, 13, 1, -16 },
  { 2133, 14, 23, 14, 1, -23 },
  { 2174, 12, 16, 14, 1, -16 },
  { 2198, 10, 23, 9, 1, -23 },
  { 2227, 14, 22, 14, 0, -16 },
  { 2266, 13, 23, 14, 0, -23 },
  { 2304, 6, 22, 7, 1, -22 },
  { 2321, 10, 28, 7, -3, -22 },
  { 2356, 14, 23, 13, 0, -23 },
  { 2397, 6, 23, 7, 1, -23 },
  { 2415, 20, 16, 22, 0, -16 },
  { 2455, 13, 16, 14, 0, -16 },
  { 2481, 12, 16, 15, 1, -16 },
  { 2505, 14, 22, 14, -1, -16 },
  { 2544, 13, 22, 15, 1, -16 },
  { 2580, 9, 16, 9, 0, -16 },
  { 2598, 11, 16, 13, 1, -16 },
  { 2620, 8, 20, 9, 1, -20 },
  { 2640, 12, 16, 14, 1, -16 },
  { 2664, 11, 16, 12, 2, -16 },
  { 2686, 17, 16, 19, 2, -16 },
  { 2720, 14, 16, 13, -1, -16 },
  { 2748, 14, 22, 12, -1, -16 },
  { 2787, 13, 16, 13, 0, -16 },
  { 2813, 9, 28, 9, 1, -23 },
  { 2845, 7, 26, 7, 0, -22 },
  { 2868, 9, 28, 9, -1, -23 },
  { 2900, 15, 6, 17, 1, -12 },
};

const GFXfont RobotoCondensed_Italic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_ITALIC30PT7B_H_
