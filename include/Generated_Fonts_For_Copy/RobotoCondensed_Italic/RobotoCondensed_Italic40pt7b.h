#ifndef _ROBOTOCONDENSED_ITALIC40PT7B_H_
#define _ROBOTOCONDENSED_ITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xF0, 0xF0, 0x60, 0x73, 0xB9, 0xDC, 0xEE, 0x76, 0x33, 0x1B,
  0x8D, 0xCE, 0xC7, 0x63, 0x00, 0x00, 0x38, 0x60, 0x03, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0C,
  0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x38, 0x70, 0x03,
  0x86, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x1C, 0x30, 0x01, 0xC7, 0x00,
  0x18, 0x70, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xC0,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x01,
  0xC3, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x38, 0x70, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07,
  0x8F, 0x03, 0xC7, 0xC7, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x07, 0x38, 0x03, 0x86, 0x04, 0xE1, 0xC3, 0xB0, 0x70, 0xCC, 0x1C, 0x73,
  0x06, 0x38, 0xC1, 0x8C, 0x38, 0xE7, 0x0E, 0x73, 0x81, 0xFD, 0xC0, 0x3C,
  0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x7C, 0x03, 0x3F, 0x81, 0xDE,
  0xE0, 0xE7, 0x1C, 0x33, 0x87, 0x1C, 0xE1, 0xCE, 0x38, 0x77, 0x0E, 0x1D,
  0x83, 0x87, 0x60, 0xE1, 0x80, 0x1D, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1E, 0x3C, 0x07, 0x07, 0x01, 0xC1,
  0xC0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x0E, 0x01, 0xCF, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x1C, 0x7B, 0x87, 0x3C,
  0xF1, 0xDE, 0x1C, 0x77, 0x07, 0xBB, 0xC0, 0xEE, 0xF0, 0x3F, 0xBC, 0x07,
  0xCF, 0x01, 0xE1, 0xC0, 0x78, 0x78, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0x78,
  0x3F, 0x0F, 0x39, 0x9C, 0xE7, 0x39, 0x8C, 0xE0, 0x00, 0x10, 0x07, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x02, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x61, 0xC6,
  0x7D, 0xDF, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xC0,
  0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0x70, 0x30, 0x70, 0x00, 0x20, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x1E, 0x38, 0xE0, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0x0E, 0x1E, 0x0F, 0x1C, 0x07,
  0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x78, 0x07, 0x70, 0x0F,
  0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x78,
  0x78, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0xC0, 0xF1, 0xFD,
  0xFE, 0xFF, 0xBC, 0xE8, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1E, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x1C, 0x78,
  0x07, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xE1, 0xE0, 0x70, 0xF0, 0x3C, 0x70,
  0x1E, 0x38, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x70, 0xE0,
  0x78, 0x78, 0x78, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xDE, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x0E,
  0x3C, 0x07, 0x8F, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x0E,
  0x1E, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x7C,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xF1, 0xE0, 0x60, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xF3,
  0xC0, 0x70, 0xE0, 0x78, 0x78, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE7, 0xC3, 0xFF, 0xC7,
  0xFF, 0xCF, 0xC7, 0x9E, 0x07, 0xBC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0x9C, 0x0F, 0x38, 0x1E, 0x78, 0x78,
  0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0xF0, 0xF0, 0xF0, 0x78, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1E,
  0x07, 0x8F, 0x03, 0xC3, 0x81, 0xC1, 0xE1, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7C, 0x78, 0x38, 0x1E, 0x3C, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0xCF, 0x00, 0xE7, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x78, 0x7C, 0x1F,
  0xFC, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xE1, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x3C, 0x7E,
  0x7F, 0xFC, 0x7F, 0xF0, 0x7C, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x1E,
  0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE3, 0xC7, 0x86, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x06, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x30,
  0x00, 0x20, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x10,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x39, 0xC0, 0xEF, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x78, 0x0C, 0x70, 0x3F, 0xC1, 0x8E,
  0x0F, 0xFC, 0x33, 0x83, 0xC3, 0x06, 0x70, 0x70, 0xE0, 0xCC, 0x1C, 0x1C,
  0x1B, 0x83, 0x83, 0x83, 0x70, 0xE0, 0x60, 0x6E, 0x1C, 0x1C, 0x1D, 0x83,
  0x83, 0x83, 0xB0, 0x70, 0x70, 0x6E, 0x1C, 0x0C, 0x0D, 0xC3, 0x83, 0x83,
  0xB8, 0x70, 0x70, 0x67, 0x0E, 0x1E, 0x0C, 0xE1, 0xE7, 0xC3, 0x1C, 0x1F,
  0xF9, 0xE3, 0x83, 0xF3, 0xF8, 0x30, 0x3C, 0x3C, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x20, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x38,
  0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1E,
  0x1C, 0x00, 0xE0, 0xE0, 0x0F, 0x07, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0,
  0x38, 0x07, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0x73, 0xC0, 0x03, 0xBC,
  0x00, 0x1D, 0xE0, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x0E, 0x03, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xE0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0x70,
  0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x0F, 0x1C, 0x01, 0xE3,
  0x80, 0x78, 0x70, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3C, 0x0F, 0x01,
  0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0F, 0x38, 0x00, 0xF3, 0x80,
  0x0F, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0x70, 0x07, 0x87, 0x80, 0xF0,
  0x3C, 0x1E, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0xE0,
  0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3,
  0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x78, 0x70, 0x07, 0x87, 0x00, 0xF0, 0x70, 0x3E,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F,
  0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF3,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x3F, 0xE7, 0x03, 0xFC, 0xF0, 0x3F, 0xCF, 0x00, 0x1C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0x70, 0x03, 0x87, 0x80,
  0x78, 0x3C, 0x1F, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0,
  0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00,
  0x38, 0x3C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0,
  0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x1C, 0x07, 0x83, 0x81,
  0xE0, 0x78, 0x7C, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x07,
  0x00, 0x7C, 0x1C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x38, 0x1E, 0x00, 0xE0, 0xF8, 0x03, 0x87, 0xC0, 0x1E, 0x3E, 0x00,
  0x78, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x3C, 0x00, 0x1D, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xDC, 0x00, 0x3E, 0x78, 0x00, 0xF0, 0xE0,
  0x03, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00,
  0xEE, 0x1F, 0xC0, 0x1F, 0xE1, 0xDE, 0x01, 0xDE, 0x1C, 0xE0, 0x1D, 0xC1,
  0xCE, 0x03, 0x9C, 0x1C, 0xE0, 0x39, 0xC3, 0xCE, 0x07, 0x3C, 0x3C, 0xE0,
  0x73, 0xC3, 0xCE, 0x0E, 0x3C, 0x38, 0x70, 0xE3, 0x83, 0x87, 0x1C, 0x38,
  0x38, 0x71, 0xC7, 0x87, 0x87, 0x38, 0x78, 0x78, 0x73, 0x87, 0x87, 0x87,
  0x70, 0x70, 0x70, 0x77, 0x07, 0x07, 0x03, 0xE0, 0x70, 0x70, 0x3E, 0x0F,
  0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F, 0x0F, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x70, 0x7C, 0x00, 0xE0, 0xFC,
  0x01, 0xC1, 0xF8, 0x07, 0x83, 0xF0, 0x0F, 0x07, 0x70, 0x1E, 0x1E, 0xE0,
  0x38, 0x3D, 0xC0, 0x70, 0x79, 0xC0, 0xE0, 0xE3, 0x83, 0xC1, 0xC7, 0x07,
  0x87, 0x87, 0x0F, 0x0F, 0x0E, 0x1C, 0x1E, 0x1C, 0x38, 0x38, 0x1C, 0x70,
  0x70, 0x39, 0xE0, 0xE0, 0x7B, 0xC3, 0xC0, 0x77, 0x87, 0x80, 0xEE, 0x0F,
  0x01, 0xFC, 0x1C, 0x01, 0xF8, 0x38, 0x03, 0xF0, 0x70, 0x07, 0xE1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C,
  0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x03,
  0xC7, 0x00, 0x38, 0x70, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x1F, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x38,
  0x01, 0xE1, 0xC0, 0x1E, 0x1E, 0x03, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFC, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C,
  0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x03,
  0xCF, 0x00, 0x38, 0x70, 0x07, 0x87, 0x80, 0xF0, 0x7C, 0x3F, 0x03, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xC0,
  0x1E, 0x1C, 0x03, 0xC3, 0xC0, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0x70,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x07, 0xE3, 0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07,
  0x1C, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC3,
  0xC0, 0x78, 0x7C, 0x3E, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x71, 0xE0, 0x07,
  0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x00,
  0xE3, 0xC0, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1C, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0xF0,
  0x03, 0x8F, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x8E,
  0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x3E, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9C, 0x00,
  0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x07,
  0x00, 0xF0, 0x38, 0x07, 0x81, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x78, 0x1C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C,
  0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x39, 0xE0, 0x01, 0xEE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x01, 0xFC, 0x01,
  0xC0, 0x3F, 0x80, 0x78, 0x07, 0x70, 0x0F, 0x01, 0xEF, 0x03, 0xE0, 0x3D,
  0xE0, 0x7C, 0x07, 0x3C, 0x0F, 0x81, 0xE7, 0x83, 0xB8, 0x3C, 0xF0, 0x77,
  0x07, 0x1E, 0x1C, 0xE1, 0xE3, 0xC3, 0x9C, 0x3C, 0x78, 0x73, 0x87, 0x0F,
  0x1C, 0x71, 0xE1, 0xE3, 0x8E, 0x38, 0x1C, 0x71, 0xC7, 0x03, 0x9C, 0x39,
  0xE0, 0x73, 0x87, 0x38, 0x0E, 0xE0, 0xE7, 0x01, 0xDC, 0x1D, 0xE0, 0x3B,
  0x81, 0xB8, 0x07, 0xE0, 0x37, 0x00, 0xFC, 0x06, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0,
  0x00, 0xE1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0x77, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0xC7, 0x00, 0x07, 0xC7, 0x80, 0x07, 0x87, 0x80,
  0x0F, 0x03, 0x80, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC1,
  0xE0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xF1, 0xC0, 0x0E, 0x78, 0x01, 0xDE,
  0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xFE, 0x0F, 0xC0,
  0xFC, 0x00, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E,
  0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0x80, 0x70, 0x0F, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xB0, 0xE6, 0x3C, 0xE7, 0x1D, 0xE3, 0xB8, 0x7F, 0x0F, 0xC1, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xE1, 0xE1, 0xC1, 0xC0,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x03, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1E,
  0x78, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xFC,
  0x7F, 0xFC, 0x3F, 0xBC, 0x1F, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x3E, 0x03, 0xBF, 0xC1, 0xFF, 0xE0, 0xF8, 0x78, 0xF0, 0x1C,
  0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x80,
  0x73, 0xC0, 0x39, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x78, 0x07, 0x3E,
  0x07, 0x9F, 0x87, 0x8E, 0xFF, 0x87, 0x7F, 0x83, 0x8F, 0x80, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x07, 0x78, 0x07,
  0x78, 0x07, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x7C, 0x70, 0x3F, 0xCE, 0x0F, 0xFF, 0xC1, 0xE1, 0xF8, 0x78,
  0x1E, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x78, 0x07, 0x0E, 0x01, 0xE1, 0xC0,
  0x3C, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80,
  0xF0, 0x70, 0x1E, 0x0E, 0x07, 0x81, 0xE1, 0xF0, 0x3F, 0xFE, 0x03, 0xFD,
  0xC0, 0x1F, 0x38, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E,
  0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x18, 0x78, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x81, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x01,
  0xF1, 0xC1, 0xFE, 0x70, 0xFF, 0xDC, 0x3C, 0x3F, 0x1E, 0x07, 0xC7, 0x00,
  0xE3, 0xC0, 0x38, 0xF0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0x70,
  0xE0, 0x1C, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0xF0, 0xE0, 0x3C, 0x38,
  0x1E, 0x0F, 0x0F, 0x83, 0xFF, 0xE0, 0x7F, 0xB8, 0x07, 0xDE, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x40, 0x3C, 0x1C, 0x1E, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x3E, 0x03, 0xBF, 0x81, 0xFF, 0xE0, 0xF8, 0xF0, 0xF8, 0x3C, 0x78,
  0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3,
  0xC0, 0x71, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x07,
  0x1C, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xE0, 0x07, 0x0F, 0x0F,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0xE0, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0x80, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x81, 0xF0, 0xE0, 0xF8, 0x38, 0x3C, 0x0E, 0x1E, 0x07, 0x8F, 0x01, 0xE7,
  0x80, 0x73, 0xC0, 0x1D, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0x38, 0x03, 0x8F, 0x00, 0xE1, 0xC0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x1C, 0x1C, 0x07, 0x80, 0x07,
  0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x0E, 0x7C, 0x1F, 0x01, 0xFF, 0xC7, 0xF8,
  0x3F, 0xFD, 0xFF, 0x07, 0x87, 0xF0, 0xF1, 0xE0, 0x7C, 0x1E, 0x3C, 0x0F,
  0x01, 0xC7, 0x01, 0xE0, 0x38, 0xE0, 0x3C, 0x07, 0x1C, 0x07, 0x01, 0xE7,
  0x80, 0xE0, 0x3C, 0xF0, 0x1C, 0x07, 0x1E, 0x03, 0x80, 0xE3, 0x80, 0xF0,
  0x1C, 0x70, 0x1E, 0x03, 0x8E, 0x03, 0x80, 0xF3, 0xC0, 0x70, 0x1E, 0x78,
  0x0E, 0x03, 0x8E, 0x03, 0xC0, 0x71, 0xC0, 0x78, 0x0E, 0x38, 0x0F, 0x01,
  0xC7, 0x01, 0xC0, 0x78, 0x0E, 0x7C, 0x07, 0x7F, 0x03, 0xFF, 0xC1, 0xF1,
  0xE1, 0xF0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x1E,
  0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x38,
  0xF0, 0x1C, 0x78, 0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xC7, 0x01,
  0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x71,
  0xE0, 0x39, 0xE0, 0x1E, 0xF0, 0x0F, 0x70, 0x07, 0xB8, 0x03, 0xDC, 0x01,
  0xFE, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x3C, 0xE0, 0x1C, 0x78,
  0x1E, 0x3C, 0x1E, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0x3E,
  0x01, 0xDF, 0xE0, 0x7F, 0xF8, 0x1F, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0x70,
  0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x1C, 0x78,
  0x07, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x83, 0xC3, 0xBF, 0xE0, 0xEF, 0xF8, 0x38, 0xF8, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0x87, 0xFD, 0xC7, 0xFE, 0xE3, 0xC3,
  0xF3, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x0F, 0x38,
  0x07, 0x9C, 0x03, 0x9E, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x3C, 0x70, 0x1C, 0x3C, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFB,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x78, 0x7F, 0x83, 0xFC, 0x1F,
  0xA1, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0xF0,
  0xF3, 0xC0, 0xE7, 0x81, 0xCE, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xF0,
  0x3D, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFB, 0xFE, 0x1C, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0E,
  0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C,
  0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x78, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3E, 0x70,
  0xF0, 0x1E, 0xE0, 0x3D, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0x8E, 0x0F, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C,
  0x07, 0x70, 0x0E, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x1F, 0xC0, 0xF0, 0x3B, 0x81, 0xE0,
  0x77, 0x07, 0xC1, 0xCE, 0x0F, 0x83, 0x9C, 0x3F, 0x0F, 0x38, 0x7E, 0x1C,
  0x70, 0xFC, 0x38, 0xE3, 0xB8, 0xE1, 0xC7, 0x71, 0xC3, 0x9C, 0x67, 0x87,
  0x38, 0xCE, 0x0E, 0xE1, 0xDC, 0x1D, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E,
  0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0x80,
  0xF0, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x70, 0x78,
  0x1C, 0x3C, 0x07, 0x8E, 0x00, 0xE7, 0x80, 0x3B, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x77, 0x80, 0x3C, 0xE0, 0x1E, 0x38, 0x0F, 0x0F, 0x03, 0xC1, 0xC1,
  0xE0, 0x78, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0xE0, 0x38, 0x1C, 0x0F,
  0x03, 0x81, 0xE0, 0x70, 0x78, 0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x78,
  0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00,
  0x10, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x01,
  0x00, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x02, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x20, 0x00,
  0x0F, 0x00, 0x07, 0xF0, 0x1D, 0xFF, 0x03, 0xBC, 0xF0, 0xE7, 0x0F, 0x3D,
  0xC0, 0xFF, 0x38, 0x0F, 0xE0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 28, 10, 1, -28 },
  { 29, 9, 10, 12, 4, -30 },
  { 41, 20, 28, 21, 2, -28 },
  { 111, 17, 36, 19, 1, -32 },
  { 188, 18, 28, 25, 4, -28 },
  { 251, 18, 28, 21, 1, -28 },
  { 314, 5, 9, 7, 3, -30 },
  { 320, 12, 41, 12, 2, -32 },
  { 382, 12, 41, 12, -2, -32 },
  { 444, 16, 17, 17, 2, -28 },
  { 478, 16, 20, 19, 2, -23 },
  { 518, 7, 10, 8, -2, -4 },
  { 527, 8, 3, 10, 1, -14 },
  { 530, 4, 4, 10, 1, -4 },
  { 532, 18, 30, 14, -2, -28 },
  { 600, 16, 28, 19, 2, -28 },
  { 656, 10, 28, 19, 5, -28 },
  { 691, 18, 28, 19, 0, -28 },
  { 754, 17, 28, 19, 1, -28 },
  { 814, 18, 28, 19, 0, -28 },
  { 877, 17, 28, 19, 2, -28 },
  { 937, 15, 28, 19, 2, -28 },
  { 990, 17, 28, 19, 3, -28 },
  { 1050, 17, 28, 19, 1, -28 },
  { 1110, 15, 28, 19, 3, -28 },
  { 1163, 7, 21, 9, 1, -21 },
  { 1182, 10, 27, 8, -2, -21 },
  { 1216, 15, 18, 17, 1, -22 },
  { 1250, 15, 11, 19, 2, -19 },
  { 1271, 16, 17, 18, 1, -21 },
  { 1305, 14, 28, 16, 3, -28 },
  { 1354, 27, 37, 30, 1, -28 },
  { 1479, 21, 28, 22, -1, -28 },
  { 1553, 19, 28, 21, 1, -28 },
  { 1620, 20, 28, 22, 2, -28 },
  { 1690, 20, 28, 22, 1, -28 },
  { 1760, 20, 28, 19, 1, -28 },
  { 1830, 19, 28, 19, 1, -28 },
  { 1897, 20, 28, 23, 2, -28 },
  { 1967, 23, 28, 24, 1, -28 },
  { 2048, 9, 28, 10, 1, -28 },
  { 2080, 19, 28, 19, 0, -28 },
  { 2147, 22, 28, 21, 1, -28 },
  { 2224, 15, 28, 18, 1, -28 },
  { 2277, 28, 28, 29, 1, -28 },
  { 2375, 23, 28, 24, 1, -28 },
  { 2456, 20, 28, 23, 2, -28 },
  { 2526, 21, 28, 22, 1, -28 },
  { 2600, 20, 33, 23, 2, -28 },
  { 2683, 20, 28, 21, 1, -28 },
  { 2753, 19, 28, 20, 1, -28 },
  { 2820, 19, 28, 20, 3, -28 },
  { 2887, 20, 28, 22, 2, -28 },
  { 2957, 21, 28, 22, 3, -28 },
  { 3031, 27, 28, 30, 4, -28 },
  { 3126, 24, 28, 21, -1, -28 },
  { 3210, 19, 28, 20, 4, -28 },
  { 3277, 21, 28, 20, 0, -28 },
  { 3351, 12, 39, 10, 0, -33 },
  { 3410, 7, 30, 14, 4, -28 },
  { 3437, 12, 39, 10, -2, -33 },
  { 3496, 11, 14, 14, 2, -28 },
  { 3516, 15, 3, 16, -2, 0 },
  { 3522, 7, 6, 12, 4, -30 },
  { 3528, 16, 21, 19, 1, -21 },
  { 3570, 17, 30, 19, 0, -30 },
  { 3634, 16, 21, 18, 1, -21 },
  { 3676, 19, 30, 19, 1, -30 },
  { 3748, 16, 21, 18, 1, -21 },
  { 3790, 13, 30, 12, 2, -30 },
  { 3839, 18, 29, 19, 0, -21 },
  { 3905, 17, 30, 19, 0, -30 },
  { 3969, 8, 29, 9, 1, -29 },
  { 3998, 13, 37, 9, -4, -29 },
  { 4059, 18, 30, 17, 0, -30 },
  { 4127, 8, 30, 9, 1, -30 },
  { 4157, 27, 21, 29, 0, -21 },
  { 4228, 17, 21, 19, 0, -21 },
  { 4273, 17, 21, 19, 1, -21 },
  { 4318, 18, 29, 19, -1, -21 },
  { 4384, 17, 29, 19, 1, -21 },
  { 4446, 13, 21, 12, 0, -21 },
  { 4481, 15, 21, 18, 1, -21 },
  { 4521, 10, 26, 11, 2, -26 },
  { 4554, 16, 21, 19, 2, -21 },
  { 4596, 15, 21, 17, 2, -21 },
  { 4636, 23, 21, 25, 3, -21 },
  { 4697, 18, 21, 17, -1, -21 },
  { 4745, 19, 29, 16, -2, -21 },
  { 4814, 17, 21, 17, 0, -21 },
  { 4859, 13, 38, 12, 1, -31 },
  { 4921, 8, 33, 9, 1, -28 },
  { 4954, 13, 38, 12, -2, -31 },
  { 5016, 19, 8, 23, 2, -16 },
};

const GFXfont RobotoCondensed_Italic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_ITALIC40PT7B_H_
