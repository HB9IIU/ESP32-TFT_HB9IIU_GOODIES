#ifndef _ROBOTOCONDENSED_ITALIC60PT7B_H_
#define _ROBOTOCONDENSED_ITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x02, 0x00, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7,
  0xCF, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70, 0xF1, 0xC3,
  0xCF, 0x0F, 0x3C, 0x38, 0xE0, 0xE3, 0x83, 0x80, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0xE7, 0x80, 0xE0, 0x1E,
  0xF0, 0x1C, 0x07, 0x9E, 0x03, 0x81, 0xE3, 0xC0, 0x70, 0x7C, 0x70, 0x1E,
  0x0F, 0x0E, 0x03, 0xC3, 0xC1, 0xC0, 0x78, 0xF8, 0x3C, 0x0F, 0x1E, 0x07,
  0x83, 0xC7, 0x80, 0xF8, 0xF9, 0xE0, 0x0F, 0xFE, 0x3C, 0x00, 0xFF, 0x8F,
  0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x20, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x0F,
  0xE0, 0x01, 0xE7, 0xFE, 0x00, 0x78, 0xFF, 0xE0, 0x1E, 0x3E, 0x3C, 0x03,
  0xCF, 0x83, 0xC0, 0xF1, 0xE0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x8F, 0x01,
  0xE1, 0xE1, 0xE0, 0x3C, 0x78, 0x3C, 0x07, 0x9F, 0x07, 0x80, 0xF3, 0xC0,
  0xF0, 0x1E, 0xF0, 0x1E, 0x03, 0xBC, 0x03, 0xC0, 0xF1, 0x80, 0x38, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8,
  0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF3, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x01, 0xE3, 0xF3, 0xF0, 0x7C, 0xFC, 0x3E, 0x0F,
  0x9F, 0x87, 0xE1, 0xF7, 0xE0, 0x7C, 0x3C, 0xF8, 0x0F, 0xCF, 0xBF, 0x00,
  0xF9, 0xF7, 0xC0, 0x1F, 0xBC, 0xF8, 0x01, 0xFF, 0x9F, 0x00, 0x3F, 0xE3,
  0xE0, 0x03, 0xFC, 0x7C, 0x00, 0x7F, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x83, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFB, 0xF0, 0x3F, 0xFE, 0x3E, 0x03, 0xFF, 0x07, 0xE0, 0x06, 0x00,
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F,
  0x1E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x30, 0x1E, 0x02, 0x7C, 0x1C, 0x1E, 0x7F, 0x3C, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xCF, 0x00,
  0x0F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x18, 0x03, 0x80, 0x08, 0x01, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3,
  0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1,
  0xF0, 0xF8, 0x1C, 0x02, 0x00, 0x7F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0,
  0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x1E, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFC, 0x7F, 0x7C, 0xFC, 0x7C, 0xE0, 0x7C, 0x80, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3,
  0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0x81,
  0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC1, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x3E, 0x7F, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xC3, 0xF8, 0x0F, 0x8F,
  0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7C, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7E, 0x3F, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x1F, 0x9F, 0x00, 0x7F, 0x3F, 0x00, 0xFC, 0x3F, 0x07, 0xF8, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xF7, 0x80, 0xFF, 0xDF, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F,
  0x83, 0xE0, 0x10, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF8, 0xFE, 0x7E, 0x03, 0xE7, 0xC0, 0x3E,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x07, 0x80, 0x1F, 0xF0, 0x0F,
  0x07, 0x80, 0x7F, 0xFC, 0x07, 0x0F, 0x00, 0xFF, 0xFC, 0x07, 0x0F, 0x00,
  0xF8, 0x3C, 0x07, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x3C, 0x0F, 0x80, 0x78, 0x07, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x78, 0x1F, 0x00, 0xF0, 0x0F,
  0x78, 0x1F, 0x00, 0xF0, 0x0E, 0xF0, 0x1E, 0x01, 0xE0, 0x0E, 0xF0, 0x1E,
  0x01, 0xE0, 0x0E, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0xF0, 0x3E, 0x01, 0xE0,
  0x1C, 0xF0, 0x3E, 0x03, 0xE0, 0x1C, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0xF0,
  0x3E, 0x03, 0xC0, 0x38, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0xF0, 0x3E, 0x0F,
  0xC0, 0x70, 0xF0, 0x1F, 0x1F, 0xC0, 0xF0, 0xF0, 0x1F, 0xFD, 0xE1, 0xE0,
  0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0xF0, 0x0F, 0xF1, 0xFF, 0x80, 0xF0, 0x07,
  0xE0, 0xFF, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7F,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80,
  0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E,
  0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x1F, 0x00,
  0x7F, 0xFC, 0x7C, 0x01, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x3F,
  0xFE, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xF0,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x87, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xC0,
  0x03, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0xF8, 0x07, 0xF0, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x0F, 0x81, 0xFC, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x01, 0xF3, 0xF8,
  0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x01,
  0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3D, 0xF0, 0x00,
  0x3E, 0xF8, 0x0F, 0x9E, 0x00, 0x07, 0xDF, 0x01, 0xF3, 0xC0, 0x01, 0xF7,
  0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0x0F, 0x9F, 0x80, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x00,
  0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x01, 0xF0,
  0x3C, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0x87, 0xC0, 0xF8, 0x07, 0xC0, 0xF9,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xEF, 0x80,
  0xF8, 0x07, 0xC0, 0x3D, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x7F,
  0x80, 0x01, 0xF0, 0x0F, 0xF0, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x0F, 0x80,
  0x7F, 0xE0, 0x01, 0xF0, 0x0F, 0xBC, 0x00, 0x3E, 0x01, 0xF7, 0xC0, 0x07,
  0xC0, 0x3E, 0xF8, 0x00, 0xF8, 0x0F, 0xCF, 0x00, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0xF0, 0x1F, 0x80,
  0xFC, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3C, 0x0F,
  0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xF0, 0x0F,
  0x0F, 0xC0, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x3E, 0x3E, 0x01, 0xF0,
  0x03, 0xC7, 0xC0, 0x3E, 0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x0F, 0xBF, 0x01,
  0xF8, 0x00, 0xF7, 0xC0, 0x3F, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xFF,
  0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00,
  0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x01, 0xFC, 0x03, 0xE0,
  0x00, 0x3F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x19, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xC0, 0x07,
  0xEF, 0x80, 0x07, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xFE,
  0x00, 0x7C, 0x7C, 0x00, 0xFF, 0x00, 0x7E, 0x3E, 0x00, 0xFF, 0x80, 0x3E,
  0x1F, 0x00, 0x7B, 0xC0, 0x1F, 0x0F, 0x80, 0x3D, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x78, 0x07, 0xC0, 0xF0, 0x1F, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x87, 0x81, 0xF0,
  0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x07, 0xC3,
  0xE0, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x78, 0x7C, 0x01, 0xF0, 0xF0, 0x3C,
  0x3E, 0x00, 0xF8, 0xF8, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x0F, 0x1F, 0x00,
  0x3E, 0x3C, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x0F, 0x9E,
  0x01, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x03, 0xEF, 0x00, 0x79,
  0xF0, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0x7C, 0x00, 0x3F, 0xE0, 0x03, 0xBC, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0,
  0x3C, 0xF0, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x7C,
  0x1E, 0x1F, 0x07, 0x8F, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x0F, 0x7C, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x03, 0xE3, 0xF8, 0x07, 0xC7, 0xE0,
  0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xE1, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7C, 0x1F, 0xFC, 0xF8, 0x1F, 0xF1, 0xF0,
  0x02, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x7F, 0xC0, 0x1F,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0x83,
  0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFE, 0x01, 0xF8, 0xFB, 0xC3, 0xF8, 0x7D,
  0xFF, 0xFC, 0x3E, 0x7F, 0xFC, 0x1F, 0x3F, 0xFC, 0x0F, 0x87, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0x80, 0x7E,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x08, 0x0F, 0xC0, 0x0F, 0xF8, 0xF8, 0x03, 0xFF,
  0xCF, 0x80, 0x7F, 0xFE, 0xF8, 0x07, 0xFF, 0xEF, 0x80, 0xFE, 0x0F, 0xF8,
  0x1F, 0x80, 0x7F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0xF0, 0x01, 0xFF, 0xDF, 0x00, 0x0F, 0xF9, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0x83, 0xF0, 0x07, 0x87, 0xF0,
  0x3F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xFC, 0x3C, 0x03, 0xFF, 0xCF, 0x80, 0xFF, 0xFD,
  0xF0, 0x1F, 0xFF, 0xBE, 0x07, 0xF0, 0x7F, 0xC1, 0xF8, 0x07, 0xF8, 0x3E,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xE0, 0x03,
  0xFE, 0x7C, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x40, 0x03, 0xF0, 0x0C, 0x00, 0xFC, 0x03, 0xC0,
  0x3F, 0x80, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x80, 0x07, 0xCF,
  0xF8, 0x07, 0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8,
  0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x00, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x07, 0xF0, 0x7C, 0x03, 0xF8, 0x1F, 0x01, 0xFC, 0x07,
  0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x0F, 0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFE, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x01, 0x00, 0x07, 0xCF, 0xF8, 0x1F, 0xF0, 0x07, 0xDF,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0xFE, 0xFF,
  0xFE, 0x0F, 0xF0, 0x7F, 0xF0, 0x7E, 0x0F, 0xC0, 0x3F, 0xE0, 0x3E, 0x0F,
  0xC0, 0x3F, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xCF, 0xF8, 0x07, 0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xF8, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0xC0, 0x07, 0xDF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x1F,
  0x80, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xE0, 0x1F, 0x83, 0xFE, 0x0F,
  0xE0, 0x7D, 0xFF, 0xFC, 0x0F, 0xBF, 0xFF, 0x01, 0xF3, 0xFF, 0xC0, 0x3E,
  0x1F, 0xE0, 0x07, 0xC0, 0x60, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F,
  0xC3, 0xC0, 0xFF, 0xF3, 0xE0, 0xFF, 0xFD, 0xF0, 0xFF, 0xFE, 0xF8, 0x7F,
  0x07, 0xFC, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xF0,
  0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xF9, 0xF0, 0x00, 0x60, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xF1, 0xF0, 0x07,
  0xE3, 0xF0, 0x0F, 0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0x80,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC,
  0x0F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF7,
  0xC0, 0x1F, 0xF3, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xC1,
  0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0,
  0x0F, 0x1E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0xFB, 0xE0, 0x0F, 0x80,
  0x1F, 0x7C, 0x01, 0xF8, 0x07, 0xCF, 0x80, 0x7F, 0x00, 0xF9, 0xF0, 0x0F,
  0xE0, 0x1F, 0x3E, 0x03, 0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0x80, 0xF8, 0xF8,
  0x0F, 0xF0, 0x1E, 0x0F, 0x03, 0xFE, 0x07, 0xC1, 0xE0, 0x7B, 0xC0, 0xF8,
  0x3C, 0x1F, 0x78, 0x3E, 0x07, 0x83, 0xCF, 0x07, 0xC0, 0xF0, 0xF9, 0xE0,
  0xF0, 0x1E, 0x1E, 0x3C, 0x3E, 0x03, 0xC3, 0xC7, 0xC7, 0xC0, 0x7C, 0xF8,
  0xF8, 0xF0, 0x0F, 0x9E, 0x0F, 0x3E, 0x01, 0xF7, 0xC1, 0xE7, 0x80, 0x3E,
  0xF0, 0x3D, 0xF0, 0x07, 0xFE, 0x07, 0xBE, 0x00, 0xFF, 0xC0, 0xF7, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x03,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x3F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0x1F, 0xFC, 0x00, 0xF1, 0xFF, 0xE0, 0x0F, 0x3F,
  0xFF, 0x01, 0xF7, 0xE1, 0xF8, 0x1E, 0x7C, 0x0F, 0xC3, 0xE7, 0x80, 0xFF,
  0xFC, 0xF8, 0x07, 0xFF, 0xCF, 0x80, 0x3F, 0xF8, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 44, 14, 2, -43 },
  { 67, 14, 14, 19, 6, -45 },
  { 92, 30, 43, 32, 3, -43 },
  { 254, 25, 56, 29, 2, -50 },
  { 429, 27, 45, 37, 6, -44 },
  { 581, 27, 45, 32, 2, -44 },
  { 733, 7, 14, 10, 5, -45 },
  { 746, 18, 62, 18, 3, -48 },
  { 886, 18, 62, 19, -3, -48 },
  { 1026, 24, 25, 25, 3, -43 },
  { 1101, 25, 31, 29, 2, -35 },
  { 1198, 10, 15, 11, -3, -6 },
  { 1217, 13, 4, 14, 1, -20 },
  { 1224, 6, 7, 15, 2, -6 },
  { 1230, 27, 47, 22, -3, -43 },
  { 1389, 24, 45, 29, 3, -44 },
  { 1524, 16, 43, 29, 7, -43 },
  { 1610, 26, 44, 29, 1, -44 },
  { 1753, 25, 45, 29, 2, -44 },
  { 1894, 27, 43, 29, 0, -43 },
  { 2040, 26, 44, 29, 3, -43 },
  { 2183, 23, 44, 29, 3, -43 },
  { 2310, 26, 43, 29, 4, -43 },
  { 2450, 25, 45, 29, 2, -44 },
  { 2591, 23, 44, 29, 4, -44 },
  { 2718, 11, 33, 14, 1, -32 },
  { 2764, 15, 41, 12, -3, -32 },
  { 2841, 22, 26, 26, 2, -32 },
  { 2913, 23, 18, 28, 3, -29 },
  { 2965, 23, 26, 27, 2, -32 },
  { 3040, 20, 45, 25, 5, -44 },
  { 3153, 40, 55, 45, 2, -42 },
  { 3428, 31, 43, 34, -2, -43 },
  { 3595, 29, 43, 32, 1, -43 },
  { 3751, 30, 45, 33, 3, -44 },
  { 3920, 30, 43, 33, 1, -43 },
  { 4082, 30, 43, 29, 1, -43 },
  { 4244, 29, 43, 28, 1, -43 },
  { 4400, 30, 45, 34, 3, -44 },
  { 4569, 35, 43, 36, 1, -43 },
  { 4758, 12, 43, 15, 2, -43 },
  { 4823, 28, 44, 28, 0, -43 },
  { 4977, 34, 43, 32, 1, -43 },
  { 5160, 23, 43, 28, 1, -43 },
  { 5284, 43, 43, 44, 1, -43 },
  { 5516, 35, 43, 36, 1, -43 },
  { 5705, 30, 45, 35, 3, -44 },
  { 5874, 31, 43, 32, 1, -43 },
  { 6041, 30, 51, 35, 3, -44 },
  { 6233, 30, 43, 31, 1, -43 },
  { 6395, 29, 45, 30, 1, -44 },
  { 6559, 28, 43, 30, 5, -43 },
  { 6710, 31, 44, 33, 3, -43 },
  { 6881, 31, 43, 33, 5, -43 },
  { 7048, 41, 43, 44, 6, -43 },
  { 7269, 35, 43, 32, -1, -43 },
  { 7458, 29, 43, 31, 5, -43 },
  { 7614, 32, 43, 30, 0, -43 },
  { 7786, 18, 58, 15, 0, -49 },
  { 7917, 11, 47, 22, 6, -43 },
  { 7982, 18, 58, 15, -3, -49 },
  { 8113, 18, 21, 22, 2, -43 },
  { 8161, 23, 4, 24, -3, 0 },
  { 8173, 10, 9, 18, 6, -45 },
  { 8185, 23, 34, 28, 2, -33 },
  { 8283, 25, 46, 29, 1, -45 },
  { 8427, 24, 34, 27, 2, -33 },
  { 8529, 28, 46, 29, 2, -45 },
  { 8690, 23, 34, 27, 2, -33 },
  { 8788, 20, 46, 18, 3, -46 },
  { 8903, 27, 45, 29, 0, -33 },
  { 9055, 24, 45, 28, 1, -45 },
  { 9190, 13, 43, 13, 1, -43 },
  { 9260, 19, 55, 13, -6, -43 },
  { 9391, 26, 45, 26, 1, -45 },
  { 9538, 13, 45, 13, 1, -45 },
  { 9612, 40, 33, 44, 1, -33 },
  { 9777, 24, 33, 28, 1, -33 },
  { 9876, 25, 34, 29, 2, -33 },
  { 9983, 27, 45, 29, -1, -33 },
  { 10135, 25, 45, 29, 2, -33 },
  { 10276, 18, 33, 18, 1, -33 },
  { 10351, 23, 34, 27, 1, -33 },
  { 10449, 15, 40, 17, 2, -39 },
  { 10524, 25, 33, 28, 2, -32 },
  { 10628, 22, 32, 25, 4, -32 },
  { 10716, 35, 32, 38, 4, -32 },
  { 10856, 27, 32, 26, -1, -32 },
  { 10964, 29, 44, 24, -3, -32 },
  { 11124, 25, 32, 26, 0, -32 },
  { 11224, 19, 58, 18, 2, -47 },
  { 11362, 12, 51, 14, 1, -43 },
  { 11439, 19, 58, 18, -3, -47 },
  { 11577, 28, 12, 34, 3, -24 },
};

const GFXfont RobotoCondensed_Italic60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_ITALIC60PT7B_H_
