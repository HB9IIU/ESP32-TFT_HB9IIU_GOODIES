#ifndef _ROBOTOCONDENSED_ITALIC65PT7B_H_
#define _ROBOTOCONDENSED_ITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E,
  0x3E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x78, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0x78, 0x70, 0x78,
  0xF0, 0x70, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x01, 0xFE, 0x03, 0xFE, 0x7F,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x07, 0x80, 0xF0, 0x06, 0x1E, 0x03, 0xC0, 0x3C, 0x78, 0x0F,
  0x01, 0xF3, 0xC0, 0x3C, 0x07, 0x8F, 0x00, 0xF0, 0x3C, 0x3C, 0x03, 0xC1,
  0xF0, 0xF0, 0x0F, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x0F, 0x01, 0xF1, 0xF0,
  0x3C, 0x07, 0x87, 0x80, 0xF8, 0x3E, 0x3C, 0x01, 0xE0, 0xF1, 0xF0, 0x07,
  0xFF, 0xCF, 0x80, 0x0F, 0xFE, 0x3C, 0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x3F,
  0x8F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x0F, 0x8F,
  0xF8, 0x00, 0x3C, 0x7F, 0xF0, 0x01, 0xE3, 0xFF, 0xE0, 0x0F, 0x9F, 0x07,
  0x80, 0x3C, 0x78, 0x1E, 0x01, 0xE1, 0xE0, 0x7C, 0x0F, 0x8F, 0x00, 0xF0,
  0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0xF0, 0x0F, 0x0F, 0x83, 0xC0, 0x3C, 0x7C,
  0x0F, 0x01, 0xF1, 0xE0, 0x3C, 0x07, 0x8F, 0x80, 0xF0, 0x1E, 0x7C, 0x03,
  0xC0, 0x79, 0xE0, 0x0F, 0x03, 0xE1, 0x80, 0x3C, 0x0F, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x03,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE7, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x07, 0xC7, 0xF3, 0xF8,
  0x3E, 0x1F, 0x87, 0xE0, 0xF8, 0xFC, 0x1F, 0xC3, 0xE7, 0xF0, 0x3F, 0x0F,
  0x9F, 0x80, 0x7E, 0x7C, 0x7C, 0x01, 0xF9, 0xF3, 0xF0, 0x03, 0xF7, 0xCF,
  0xC0, 0x0F, 0xFE, 0x3F, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x7F, 0xC3, 0xF0,
  0x00, 0xFF, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x81, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x8F, 0xC0, 0x3F, 0xF8, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x38, 0x0F, 0x03, 0x8F, 0xC3, 0xC3, 0xE7, 0xFD, 0xF7, 0xFD, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x78,
  0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xE0, 0xF8, 0x03, 0xF8,
  0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0x00, 0x38, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0x8C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x00,
  0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F,
  0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0,
  0x7C, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF,
  0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFE, 0x3E, 0xF8, 0x7E, 0xE0, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xFE,
  0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0xFF, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0x70, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0x9F, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0xFF, 0x00, 0xFC, 0x7F, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80,
  0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0x7C,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x0F, 0xE1, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0x7C,
  0x01, 0xFE, 0x7E, 0x03, 0xFC, 0x7F, 0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0xF8, 0x03, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x38,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0x9F, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x3E, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0xFF,
  0xC0, 0x0E, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0xE0, 0x78, 0x03, 0xFF, 0xF8,
  0x0E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xF0, 0xF0, 0x07, 0xC0, 0xF8, 0x0F,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF1, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF3, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF3, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x3C, 0x07, 0xC0,
  0x1E, 0x00, 0xE7, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE7, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x78, 0x0F, 0x80, 0x3C, 0x01,
  0xE7, 0x80, 0xF8, 0x07, 0xC0, 0x1C, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xCF,
  0x80, 0xF0, 0x07, 0x80, 0x3C, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0xCF, 0x01,
  0xF0, 0x0F, 0x80, 0x38, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x8F, 0x01, 0xF0,
  0x1F, 0x80, 0x70, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0x3F,
  0x81, 0xE0, 0xF0, 0x0F, 0x87, 0xF8, 0x1E, 0x0F, 0x00, 0xFF, 0xF7, 0x87,
  0xC0, 0xF0, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0x80, 0x7F, 0xC7, 0xFF, 0x00,
  0x78, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3E, 0x00,
  0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0x83, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3E, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x07, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0x80, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x7E, 0x00, 0xFF, 0xFC,
  0x7E, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFC,
  0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0x80, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00, 0x3E, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xBF, 0x00, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0x80,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0x7E, 0x00, 0x03, 0xEF,
  0x80, 0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF8,
  0x07, 0xCF, 0x80, 0x03, 0xF7, 0xE0, 0x3F, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0xFC, 0xF8, 0x00, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x0F, 0xCF, 0xC0, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0xF8,
  0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87,
  0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C,
  0x07, 0xE1, 0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x1F, 0x03, 0xE0,
  0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x1F,
  0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xE3, 0xF0,
  0x3F, 0x00, 0xF8, 0x07, 0x8F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x7D, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0x7C, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xC0, 0x7F, 0xE0, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x1F,
  0xF8, 0x00, 0x1F, 0x00, 0xFB, 0xE0, 0x01, 0xF8, 0x07, 0xDF, 0x00, 0x0F,
  0xC0, 0x7E, 0xF8, 0x00, 0x7E, 0x03, 0xF3, 0xE0, 0x03, 0xF0, 0x1F, 0x9F,
  0x00, 0x1F, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0xC0,
  0x7E, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x1F, 0x83, 0xE0,
  0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0x3E,
  0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0xFC, 0x00, 0xF8, 0xFC, 0x07, 0xE0, 0x07, 0xE7, 0xC0, 0x3F, 0x00, 0x1F,
  0x3E, 0x01, 0xF0, 0x00, 0xFB, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0xFC,
  0x00, 0x1F, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xFE,
  0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0xFC, 0x00,
  0x07, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x9F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0xC3,
  0xE0, 0x03, 0xFE, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xFB, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xDF, 0x00, 0xFC, 0x0F, 0x80, 0x7C,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE3, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x1E,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x87, 0x81,
  0xF8, 0x07, 0xC0, 0xF8, 0x3C, 0x0F, 0xC0, 0x3E, 0x07, 0xC1, 0xE0, 0x7C,
  0x01, 0xF8, 0x3C, 0x0F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x78, 0x3E, 0x00,
  0x7E, 0x1F, 0x03, 0xC1, 0xF0, 0x03, 0xF0, 0xF0, 0x1E, 0x1F, 0x80, 0x1F,
  0x8F, 0x80, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x07, 0xC7, 0xC0, 0x03, 0xE7,
  0xC0, 0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0,
  0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x01,
  0xEF, 0x80, 0x01, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x7B,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0,
  0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x3E, 0x1F, 0x07, 0xC7,
  0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x01, 0xE7, 0xC0, 0x3D, 0xF8, 0x07, 0xFE,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F,
  0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0x87, 0xF0, 0x07, 0xC7, 0xF0, 0x03,
  0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x1F, 0xC7, 0xE0, 0x1F, 0xE3, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0xFC, 0x1F, 0xFE, 0x7E, 0x03, 0xFE, 0x3F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x3F, 0xF0, 0x07, 0xEF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xFE, 0x1F, 0xE1, 0xFB, 0xFF, 0xFC, 0x3E,
  0x7F, 0xFF, 0x07, 0xC7, 0xFF, 0xC0, 0xF8, 0x7F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0xF0, 0xF8, 0x01, 0xFF,
  0xF3, 0xE0, 0x0F, 0xFF, 0xCF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFE, 0x1F,
  0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0,
  0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x87, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0x00, 0x07, 0xFC,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x83,
  0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80,
  0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x07, 0xE0, 0x03,
  0x83, 0xF8, 0x03, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0x84, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x07, 0xFF, 0xCF, 0x80, 0x3F,
  0xFF, 0x3E, 0x01, 0xFF, 0xFE, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0x80,
  0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x7C, 0x00, 0x1F, 0xFB, 0xF0, 0x00, 0x0F,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0xF0,
  0x07, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x9F, 0xF8, 0x07, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xF0, 0xFE, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0x7C, 0x07, 0xF0, 0x07, 0xC0, 0xFE, 0x00, 0x7C, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00,
  0xF8, 0xFE, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0x80, 0x03, 0xF8,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x3F, 0x81, 0xFC,
  0x07, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F,
  0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x7E, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0,
  0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xF3, 0xFF, 0x00, 0x0F, 0xDF, 0xFE, 0x00, 0x3E, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x80, 0x7E,
  0x7F, 0xFC, 0x01, 0xF0, 0xFF, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFE, 0x3F, 0x01, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xFB,
  0xE0, 0xFF, 0x07, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFC, 0x00, 0x0F, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x7D, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xFE, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x0F,
  0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x3F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x20, 0x7F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xF8, 0x3F, 0xC7, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xF0, 0x07, 0xFE, 0x7C, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1E,
  0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0xFF, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xBF, 0x00,
  0x7F, 0x00, 0x7E, 0x7C, 0x01, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3F, 0xC0, 0x3E, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x7C, 0x07,
  0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0xF0, 0x1F, 0x07, 0xC0, 0xFF, 0xC0, 0x7C,
  0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x7C, 0x1F, 0x3C, 0x0F, 0x81, 0xF0, 0x7C,
  0xF0, 0x7E, 0x07, 0xC3, 0xE3, 0xC1, 0xF0, 0x1F, 0x0F, 0x8F, 0x87, 0xC0,
  0x7C, 0x3C, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0xF8, 0xF8, 0x07, 0xC7, 0xC3,
  0xE7, 0xC0, 0x0F, 0x3E, 0x0F, 0x9F, 0x00, 0x3C, 0xF8, 0x3E, 0x7C, 0x00,
  0xF7, 0xC0, 0xFB, 0xE0, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x07,
  0xBC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x80, 0x3E, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3C, 0x3F, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0x01, 0xF1, 0xFF, 0xF8,
  0x03, 0xC7, 0xE3, 0xF8, 0x0F, 0x8F, 0x83, 0xF8, 0x1F, 0x3E, 0x03, 0xF8,
  0xFC, 0x7C, 0x03, 0xFF, 0xF8, 0xF0, 0x03, 0xFF, 0xE3, 0xE0, 0x03, 0xFF,
  0x87, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 47, 16, 2, -46 },
  { 78, 16, 16, 20, 6, -49 },
  { 110, 32, 46, 35, 3, -46 },
  { 294, 28, 61, 31, 2, -54 },
  { 508, 30, 48, 40, 6, -47 },
  { 688, 30, 48, 34, 2, -47 },
  { 868, 8, 15, 11, 5, -49 },
  { 883, 20, 67, 20, 3, -52 },
  { 1051, 19, 67, 20, -3, -52 },
  { 1211, 26, 27, 27, 3, -46 },
  { 1299, 27, 34, 31, 3, -38 },
  { 1414, 11, 16, 12, -4, -7 },
  { 1436, 14, 5, 16, 1, -22 },
  { 1445, 7, 7, 17, 2, -6 },
  { 1452, 29, 50, 23, -3, -46 },
  { 1634, 26, 48, 31, 3, -47 },
  { 1790, 16, 46, 31, 8, -46 },
  { 1882, 29, 47, 31, 1, -47 },
  { 2053, 27, 48, 31, 2, -47 },
  { 2215, 29, 46, 31, 0, -46 },
  { 2382, 29, 47, 31, 3, -46 },
  { 2553, 25, 47, 31, 3, -46 },
  { 2700, 29, 46, 31, 4, -46 },
  { 2867, 28, 48, 31, 2, -47 },
  { 3035, 24, 47, 31, 5, -47 },
  { 3176, 12, 35, 15, 1, -34 },
  { 3229, 16, 43, 13, -3, -34 },
  { 3315, 24, 29, 28, 2, -35 },
  { 3402, 25, 18, 30, 3, -31 },
  { 3459, 25, 29, 29, 2, -35 },
  { 3550, 22, 48, 27, 5, -47 },
  { 3682, 44, 59, 49, 2, -45 },
  { 4007, 34, 46, 36, -2, -46 },
  { 4203, 31, 46, 34, 2, -46 },
  { 4382, 32, 48, 36, 3, -47 },
  { 4574, 32, 46, 36, 2, -46 },
  { 4758, 31, 46, 31, 2, -46 },
  { 4937, 31, 46, 30, 2, -46 },
  { 5116, 32, 48, 37, 3, -47 },
  { 5308, 37, 46, 39, 2, -46 },
  { 5521, 13, 46, 16, 2, -46 },
  { 5596, 31, 47, 30, 0, -46 },
  { 5779, 36, 46, 34, 2, -46 },
  { 5986, 24, 46, 30, 2, -46 },
  { 6124, 46, 46, 48, 2, -46 },
  { 6389, 37, 46, 39, 2, -46 },
  { 6602, 32, 48, 38, 4, -47 },
  { 6794, 33, 46, 35, 2, -46 },
  { 6984, 33, 55, 38, 3, -47 },
  { 7211, 31, 46, 33, 2, -46 },
  { 7390, 32, 48, 33, 1, -47 },
  { 7582, 30, 46, 33, 6, -46 },
  { 7755, 33, 47, 35, 3, -46 },
  { 7949, 32, 46, 35, 6, -46 },
  { 8133, 45, 46, 48, 6, -46 },
  { 8392, 38, 46, 35, -1, -46 },
  { 8611, 31, 46, 33, 6, -46 },
  { 8790, 35, 46, 33, -1, -46 },
  { 8992, 20, 63, 16, 0, -53 },
  { 9150, 12, 50, 23, 6, -46 },
  { 9225, 21, 63, 16, -4, -53 },
  { 9391, 19, 23, 23, 3, -46 },
  { 9446, 25, 5, 26, -3, 0 },
  { 9462, 11, 9, 19, 7, -48 },
  { 9475, 25, 36, 30, 2, -35 },
  { 9588, 27, 50, 31, 1, -49 },
  { 9757, 26, 36, 29, 2, -35 },
  { 9874, 30, 50, 31, 2, -49 },
  { 10062, 25, 36, 30, 2, -35 },
  { 10175, 21, 50, 20, 3, -50 },
  { 10307, 30, 48, 31, 0, -35 },
  { 10487, 26, 49, 30, 1, -49 },
  { 10647, 14, 47, 14, 1, -47 },
  { 10730, 20, 60, 14, -6, -47 },
  { 10880, 28, 49, 28, 1, -49 },
  { 11052, 14, 49, 14, 1, -49 },
  { 11138, 43, 35, 47, 1, -35 },
  { 11327, 26, 35, 31, 1, -35 },
  { 11441, 27, 36, 32, 2, -35 },
  { 11563, 30, 48, 31, -2, -35 },
  { 11743, 28, 48, 32, 2, -35 },
  { 11911, 19, 35, 19, 1, -35 },
  { 11995, 26, 36, 29, 1, -35 },
  { 12112, 16, 44, 19, 3, -43 },
  { 12200, 26, 35, 30, 3, -34 },
  { 12314, 24, 34, 27, 4, -34 },
  { 12416, 38, 34, 41, 4, -34 },
  { 12578, 30, 34, 28, -2, -34 },
  { 12706, 31, 47, 26, -3, -34 },
  { 12889, 27, 34, 28, 0, -34 },
  { 13004, 20, 63, 19, 2, -51 },
  { 13162, 13, 55, 15, 1, -46 },
  { 13252, 20, 63, 19, -3, -51 },
  { 13410, 31, 13, 37, 3, -26 },
};

const GFXfont RobotoCondensed_Italic65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_ITALIC65PT7B_H_
