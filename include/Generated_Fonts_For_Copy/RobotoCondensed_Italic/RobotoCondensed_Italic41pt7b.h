#ifndef _ROBOTOCONDENSED_ITALIC41PT7B_H_
#define _ROBOTOCONDENSED_ITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x1E, 0x06, 0x00, 0x71, 0xDC,
  0x67, 0x39, 0xCE, 0x73, 0x98, 0xE6, 0x33, 0x8C, 0xE7, 0x31, 0xC0, 0x00,
  0x38, 0x70, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0,
  0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x60, 0x03, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x61, 0xC0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x81, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0x87, 0x00, 0x38,
  0x70, 0x03, 0x86, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0x3E, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0xE0,
  0x3C, 0x38, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x00,
  0xF1, 0xC0, 0x38, 0x78, 0x1E, 0x1F, 0x1F, 0x03, 0xFF, 0xC0, 0x7F, 0xC0,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x19,
  0xC3, 0x87, 0x38, 0x70, 0xC6, 0x0E, 0x38, 0xC1, 0xCE, 0x18, 0x33, 0x83,
  0x8E, 0x70, 0x7B, 0xDC, 0x07, 0xF7, 0x00, 0x7C, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x78, 0x03, 0x9F, 0x80, 0x77, 0x38, 0x1D, 0xC3, 0x07, 0x38, 0x60,
  0xC6, 0x0E, 0x38, 0xC1, 0x8E, 0x38, 0x33, 0x87, 0x06, 0x70, 0x61, 0xCC,
  0x0C, 0x38, 0x01, 0xCE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xE3, 0x80, 0x78, 0x78, 0x0E, 0x0F, 0x01,
  0xC1, 0xE0, 0x78, 0x38, 0x0F, 0x0F, 0x00, 0xE3, 0xC0, 0x1E, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x07, 0x3E,
  0xF0, 0xE7, 0x8E, 0x39, 0xE1, 0xE7, 0x38, 0x1C, 0xEF, 0x03, 0xF9, 0xE0,
  0x3F, 0x3C, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x1F, 0x0F, 0x87, 0xE0, 0xFF,
  0xFE, 0x0F, 0xF9, 0xE0, 0xFC, 0x3C, 0x39, 0xCC, 0xE7, 0x39, 0xCC, 0x63,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x61, 0xC3, 0x7D, 0xDF, 0xFF, 0xFF, 0x1F,
  0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0x70, 0x78,
  0x70, 0x30, 0x30, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x1E, 0x38, 0xE0, 0x80, 0xFF,
  0xFF, 0xFF, 0x07, 0xBF, 0xE7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0x81, 0xE1, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x9E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x03, 0x9C, 0x01,
  0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xE0, 0x78, 0xF0, 0x38, 0x3C,
  0x7C, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x40, 0xF0, 0xFD,
  0xFF, 0xFF, 0xFC, 0xEC, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xE1, 0xE0, 0x70, 0x3C, 0x1E, 0x03, 0x83,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xF1, 0xE0, 0xE0, 0x78, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x3C, 0x70, 0x3C, 0x3C,
  0x3E, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xB8,
  0x01, 0xEE, 0x00, 0x77, 0x80, 0x39, 0xE0, 0x1E, 0x70, 0x0F, 0x1C, 0x03,
  0x87, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x03,
  0x87, 0x80, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xDF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0x8F, 0x81, 0xC1, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x38, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x70, 0x3C, 0x1E, 0x1E,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0x80, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE7, 0xC1, 0xFF, 0xC7, 0xFF, 0xCF, 0xC7, 0xDF, 0x07,
  0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xB8, 0x0E, 0x78, 0x3C, 0xF0, 0xF0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x1E, 0x1E, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0xE0,
  0x3C, 0x38, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0xE0, 0xE0, 0x78, 0x38, 0x1C,
  0x0F, 0x0F, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1E, 0x1E, 0x0F,
  0x03, 0x87, 0x80, 0xE1, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x00,
  0xE1, 0xC0, 0x78, 0x78, 0x1E, 0x1E, 0x1F, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0x81,
  0xCF, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x0F, 0x3C, 0x7E, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7C, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x78, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x8F, 0x1E, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x60, 0x00, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F,
  0x1E, 0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x3E, 0x06, 0x0C, 0x0F, 0xF0, 0x71,
  0xC1, 0xFF, 0x87, 0x18, 0x1C, 0x38, 0x73, 0x83, 0x83, 0x87, 0x38, 0x38,
  0x30, 0x73, 0x07, 0x07, 0x07, 0x70, 0x70, 0x70, 0x77, 0x0E, 0x07, 0x07,
  0x70, 0xE0, 0x60, 0x66, 0x0E, 0x0E, 0x06, 0x60, 0xE0, 0xE0, 0x6E, 0x0E,
  0x0E, 0x0E, 0xE1, 0xC0, 0xC0, 0xCE, 0x1C, 0x1C, 0x0C, 0xE1, 0xC1, 0xC1,
  0x8E, 0x0E, 0x3C, 0x38, 0xE0, 0xFE, 0xE7, 0x0E, 0x0F, 0xCF, 0xE0, 0x60,
  0x78, 0x7C, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0xCE,
  0x00, 0x1C, 0x70, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0x70, 0x07,
  0x03, 0x80, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC7, 0x80,
  0x0E, 0x3C, 0x00, 0x73, 0xC0, 0x03, 0x9E, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xF0,
  0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E,
  0x00, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x7C, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0x83, 0xC0, 0x3C,
  0x38, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0x87, 0x80, 0x78, 0x70, 0x0F, 0x87, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7C, 0x3E, 0x0F, 0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x70,
  0x03, 0x87, 0x00, 0x78, 0x78, 0x0F, 0x03, 0xC1, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0xF0, 0x7E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x1C,
  0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3,
  0xC0, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x78, 0x70, 0x0F, 0x07, 0x03, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF3, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x03, 0xFE,
  0x70, 0x3F, 0xEF, 0x03, 0xFE, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x01,
  0xCF, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC3, 0xE1,
  0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x38,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0x83, 0x80, 0xF0, 0x78, 0x3C, 0x0F, 0x8F, 0x80, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x3E, 0x0E, 0x00, 0xF8,
  0x1C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x03,
  0x81, 0xE0, 0x07, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x79,
  0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xDF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x78, 0x00, 0x7C, 0x70, 0x00, 0xF0, 0xF0,
  0x01, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xF7, 0x00,
  0x77, 0x07, 0xB8, 0x07, 0xB8, 0x39, 0xC0, 0x39, 0xC1, 0xCE, 0x03, 0xDE,
  0x0E, 0x70, 0x1C, 0xF0, 0xF3, 0xC1, 0xE7, 0x07, 0x8E, 0x0E, 0x38, 0x3C,
  0x70, 0xF1, 0xC1, 0xE3, 0x87, 0x1E, 0x0E, 0x1C, 0x78, 0xF0, 0x70, 0xE3,
  0x87, 0x87, 0x87, 0x3C, 0x38, 0x3C, 0x3D, 0xC1, 0xC1, 0xE0, 0xFE, 0x1E,
  0x0F, 0x07, 0xE0, 0xF0, 0x70, 0x3F, 0x07, 0x83, 0x81, 0xF0, 0x3C, 0x3C,
  0x0F, 0x81, 0xC1, 0xE0, 0x78, 0x0E, 0x0F, 0x01, 0xC0, 0xF0, 0x00, 0x07,
  0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x0F, 0xC0, 0x1E, 0x0F,
  0xC0, 0x1E, 0x0F, 0xC0, 0x1E, 0x0F, 0xE0, 0x1C, 0x0E, 0xE0, 0x1C, 0x0E,
  0xE0, 0x3C, 0x1E, 0xF0, 0x3C, 0x1E, 0x70, 0x3C, 0x1E, 0x70, 0x3C, 0x1C,
  0x78, 0x38, 0x1C, 0x38, 0x38, 0x3C, 0x38, 0x78, 0x3C, 0x3C, 0x78, 0x3C,
  0x1C, 0x78, 0x3C, 0x1C, 0x70, 0x38, 0x1E, 0x70, 0x38, 0x0E, 0x70, 0x78,
  0x0E, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xE0, 0x70,
  0x07, 0xE0, 0x70, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x87,
  0xC0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xC7, 0x80, 0x0E, 0x3C,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x07,
  0x3C, 0x00, 0x79, 0xC0, 0x03, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xF7, 0x80,
  0x07, 0x3C, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE1,
  0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x38,
  0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0xF8, 0xF0, 0x0F, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x01,
  0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0x80,
  0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00, 0x78,
  0x78, 0x0F, 0x83, 0xE3, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x20, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x3E, 0x0F,
  0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xE0, 0x1E, 0x1C, 0x03, 0xE1, 0xC0, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xC1, 0xC0, 0x38, 0x1E,
  0x03, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0x70, 0x07, 0x07, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3C,
  0x0F, 0x01, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x00, 0x78, 0x78, 0x0F, 0x07, 0xC3, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x1E,
  0x1E, 0x00, 0xE0, 0xF0, 0x0F, 0x03, 0xE1, 0xF0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x70, 0x07, 0x87, 0x00,
  0x78, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x78, 0x0E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x03, 0x83, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03,
  0x87, 0x00, 0x3C, 0xF0, 0x03, 0xCE, 0x00, 0x1D, 0xE0, 0x01, 0xDC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0E, 0xF0, 0x0F, 0x01, 0xEF, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x01, 0xCF,
  0x03, 0xF0, 0x3C, 0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x38, 0xF0, 0x77,
  0x07, 0x8F, 0x07, 0x70, 0x78, 0xF0, 0x77, 0x07, 0x07, 0x0E, 0x70, 0x70,
  0x70, 0xE7, 0x0F, 0x07, 0x1C, 0x30, 0xE0, 0x71, 0xC3, 0x0E, 0x07, 0x1C,
  0x31, 0xE0, 0x73, 0x83, 0x9C, 0x07, 0x38, 0x39, 0xC0, 0x77, 0x83, 0xBC,
  0x07, 0x70, 0x3B, 0x80, 0x77, 0x03, 0xB8, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x01, 0xC0, 0x3C,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x00, 0xE0, 0xF0, 0x00, 0xF1, 0xE0,
  0x00, 0xF3, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xE7, 0x00,
  0x03, 0xC7, 0x80, 0x07, 0xC7, 0x80, 0x07, 0x83, 0x80, 0x0F, 0x03, 0xC0,
  0x1F, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0x78, 0x01, 0xF0, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x38, 0x03,
  0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x3C,
  0x07, 0x87, 0x00, 0xF1, 0xE0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0xE0, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xEC, 0x0E,
  0xC1, 0xCE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x8E, 0x70, 0xEF, 0x07, 0xE0,
  0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x78, 0xF0, 0xE0, 0xE1, 0xC1,
  0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x3C,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x03, 0xFE, 0x0F, 0xFE, 0x3F,
  0xFE, 0x7C, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F, 0xBC, 0x1F, 0x3C, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0x80, 0xEF, 0xF0, 0x3F, 0xFE,
  0x0F, 0x87, 0x87, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xC7,
  0x00, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x0E, 0x38, 0x07, 0x9E, 0x01, 0xC7, 0xC0, 0xF1, 0xF8, 0x78,
  0x77, 0xFE, 0x1C, 0xFF, 0x07, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x78, 0x7C, 0x3F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x7C, 0x78, 0x1F, 0xEE, 0x07, 0xFD, 0xC1, 0xF1, 0xF8, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0x70,
  0xF0, 0x0E, 0x0E, 0x03, 0xC1, 0xE0, 0x78, 0x3E, 0x3F, 0x03, 0xFF, 0xC0,
  0x7F, 0xB8, 0x03, 0xE7, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0x1E, 0x1C, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x78, 0x07, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x08, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0x81, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x7F, 0xBC, 0x1F, 0xF7, 0x07,
  0xC7, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1C, 0x3C,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x38, 0x0F, 0x07, 0x81, 0xE0, 0xF8,
  0xFC, 0x0F, 0xFF, 0x01, 0xFE, 0xE0, 0x0F, 0x9C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x08, 0x07, 0x81, 0xC1, 0xE0, 0x7F, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x9F, 0x03, 0xBF, 0xC1, 0xFF, 0xE0, 0xF8, 0x78, 0xF8, 0x3C, 0x78, 0x0E,
  0x3C, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x71, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x78, 0x07, 0x0F,
  0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70,
  0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x07, 0x80, 0xE1,
  0xE0, 0x1C, 0x78, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x1C, 0xF0, 0x03, 0xBC,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7D, 0xC0, 0x0F, 0x3C,
  0x01, 0xC3, 0x80, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x01, 0xC0, 0xE0, 0x3C, 0x1C, 0x07, 0x80, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x80, 0x0E, 0x7C, 0x0F, 0x80, 0xEF,
  0xF3, 0xFC, 0x0F, 0xFF, 0x7F, 0xE0, 0xF8, 0xFF, 0x1E, 0x1E, 0x07, 0xE0,
  0xF1, 0xE0, 0x7C, 0x0F, 0x1E, 0x03, 0x80, 0xF1, 0xC0, 0x38, 0x0F, 0x1C,
  0x07, 0x80, 0xF1, 0xC0, 0x78, 0x0E, 0x3C, 0x07, 0x80, 0xE3, 0xC0, 0x70,
  0x0E, 0x3C, 0x07, 0x01, 0xE3, 0x80, 0x70, 0x1E, 0x38, 0x0F, 0x01, 0xE3,
  0x80, 0xF0, 0x1C, 0x78, 0x0F, 0x01, 0xC7, 0x80, 0xE0, 0x1C, 0x78, 0x0E,
  0x03, 0xC7, 0x00, 0xE0, 0x3C, 0x70, 0x1E, 0x03, 0xC7, 0x01, 0xE0, 0x38,
  0x0E, 0x3E, 0x07, 0x7F, 0x83, 0xFF, 0xC1, 0xF0, 0xF1, 0xF0, 0x78, 0xF0,
  0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0x70, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF0, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xE1, 0xE1, 0xE0, 0x79, 0xE0, 0x3C,
  0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x0E, 0x3C,
  0x0F, 0x1F, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x3F,
  0x00, 0xEF, 0xF0, 0x1F, 0xFF, 0x03, 0xE1, 0xE0, 0xF8, 0x1E, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x1E,
  0x3C, 0x03, 0x87, 0x80, 0xF0, 0xFC, 0x3C, 0x1D, 0xFF, 0x83, 0xBF, 0xE0,
  0x71, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF3,
  0xC1, 0xFE, 0xE0, 0xFF, 0xF8, 0x7C, 0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0x80, 0x79, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x38, 0x70, 0x1E,
  0x1C, 0x07, 0x87, 0x87, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xEF, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x78, 0x77, 0xC3, 0xFE, 0x1F,
  0xF1, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0x1E, 0x1C, 0x0E, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0xE0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xC0, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x7E, 0x1F, 0x03, 0xC0,
  0x3C, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0E,
  0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C,
  0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xF0, 0x78,
  0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0x78, 0x70, 0x0E, 0x70, 0x1E,
  0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x78, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x39, 0xC0,
  0x3B, 0x80, 0x1B, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x38, 0x0E, 0xE0, 0x78, 0x1E, 0xE0, 0x78,
  0x1E, 0xE0, 0x78, 0x1C, 0xE0, 0xF8, 0x3C, 0xE0, 0xF8, 0x38, 0xE1, 0xD8,
  0x38, 0xE1, 0xDC, 0x78, 0xE3, 0xDC, 0x70, 0xE3, 0x9C, 0x70, 0xE3, 0x9C,
  0xE0, 0xE7, 0x1C, 0xE0, 0xF7, 0x1D, 0xE0, 0x7E, 0x1D, 0xC0, 0x7E, 0x1D,
  0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x03,
  0xE1, 0xE0, 0x78, 0x1C, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x07, 0x3C,
  0x00, 0xE7, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x79, 0xC0,
  0x0F, 0x38, 0x03, 0xC7, 0x80, 0xF0, 0x70, 0x1E, 0x0E, 0x07, 0x81, 0xE1,
  0xF0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x07, 0x03, 0x80, 0x70, 0x78, 0x07, 0x87, 0x80, 0x78, 0x70, 0x07,
  0x8F, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xBC, 0x00,
  0x3B, 0x80, 0x03, 0xB8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x07, 0x07, 0x07,
  0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0xF8, 0x0C, 0xFF, 0x83, 0xBC, 0xF0, 0x77, 0x0F, 0x9D, 0xC0,
  0xFF, 0xB8, 0x0F, 0xE0, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 29, 10, 1, -29 },
  { 34, 10, 10, 13, 4, -31 },
  { 47, 20, 29, 22, 2, -29 },
  { 120, 18, 37, 20, 1, -33 },
  { 204, 19, 29, 25, 4, -29 },
  { 273, 19, 29, 22, 1, -29 },
  { 342, 5, 10, 7, 3, -31 },
  { 349, 12, 42, 13, 2, -33 },
  { 412, 12, 42, 13, -2, -33 },
  { 475, 16, 17, 17, 2, -29 },
  { 509, 17, 21, 20, 2, -24 },
  { 554, 7, 10, 8, -2, -4 },
  { 563, 8, 3, 10, 1, -14 },
  { 566, 5, 5, 10, 1, -5 },
  { 570, 18, 32, 15, -2, -29 },
  { 642, 17, 29, 20, 2, -29 },
  { 704, 10, 29, 20, 5, -29 },
  { 741, 19, 29, 20, 0, -29 },
  { 810, 17, 29, 20, 1, -29 },
  { 872, 18, 29, 20, 0, -29 },
  { 938, 18, 29, 20, 2, -29 },
  { 1004, 15, 29, 20, 2, -29 },
  { 1059, 18, 29, 20, 3, -29 },
  { 1125, 18, 29, 20, 1, -29 },
  { 1191, 15, 29, 20, 3, -29 },
  { 1246, 7, 23, 9, 1, -23 },
  { 1267, 10, 29, 8, -2, -23 },
  { 1304, 16, 18, 18, 1, -22 },
  { 1340, 16, 11, 19, 2, -19 },
  { 1362, 16, 18, 18, 1, -22 },
  { 1398, 14, 29, 17, 3, -29 },
  { 1449, 28, 38, 31, 1, -29 },
  { 1582, 21, 29, 23, -1, -29 },
  { 1659, 20, 29, 22, 1, -29 },
  { 1732, 20, 29, 23, 2, -29 },
  { 1805, 20, 29, 23, 1, -29 },
  { 1878, 20, 29, 20, 1, -29 },
  { 1951, 20, 29, 19, 1, -29 },
  { 2024, 20, 29, 24, 2, -29 },
  { 2097, 24, 29, 25, 1, -29 },
  { 2184, 9, 29, 10, 1, -29 },
  { 2217, 19, 29, 19, 0, -29 },
  { 2286, 23, 29, 22, 1, -29 },
  { 2370, 15, 29, 19, 1, -29 },
  { 2425, 29, 29, 30, 1, -29 },
  { 2531, 24, 29, 25, 1, -29 },
  { 2618, 21, 29, 24, 2, -29 },
  { 2695, 21, 29, 22, 1, -29 },
  { 2772, 20, 34, 24, 2, -29 },
  { 2857, 20, 29, 21, 1, -29 },
  { 2930, 20, 29, 21, 1, -29 },
  { 3003, 19, 29, 21, 4, -29 },
  { 3072, 21, 29, 22, 2, -29 },
  { 3149, 20, 29, 22, 4, -29 },
  { 3222, 28, 29, 30, 4, -29 },
  { 3324, 24, 29, 22, -1, -29 },
  { 3411, 19, 29, 21, 4, -29 },
  { 3480, 22, 29, 21, 0, -29 },
  { 3560, 12, 39, 10, 0, -33 },
  { 3619, 8, 32, 15, 4, -29 },
  { 3651, 12, 39, 10, -2, -33 },
  { 3710, 12, 15, 15, 2, -29 },
  { 3733, 16, 3, 16, -2, 0 },
  { 3739, 7, 6, 12, 4, -31 },
  { 3745, 16, 22, 19, 1, -22 },
  { 3789, 18, 31, 20, 0, -31 },
  { 3859, 16, 22, 18, 1, -22 },
  { 3903, 19, 31, 20, 1, -31 },
  { 3977, 16, 22, 19, 1, -22 },
  { 4021, 13, 31, 13, 2, -31 },
  { 4072, 19, 30, 20, 0, -22 },
  { 4144, 17, 31, 19, 0, -31 },
  { 4210, 8, 30, 9, 1, -30 },
  { 4240, 13, 38, 9, -4, -30 },
  { 4302, 19, 31, 18, 0, -31 },
  { 4376, 9, 31, 9, 1, -31 },
  { 4411, 28, 22, 30, 0, -22 },
  { 4488, 17, 22, 19, 0, -22 },
  { 4535, 17, 22, 20, 1, -22 },
  { 4582, 19, 30, 20, -1, -22 },
  { 4654, 18, 30, 20, 1, -22 },
  { 4722, 13, 22, 12, 0, -22 },
  { 4758, 16, 22, 18, 1, -22 },
  { 4802, 10, 27, 12, 2, -27 },
  { 4836, 16, 22, 19, 2, -22 },
  { 4880, 16, 22, 17, 2, -22 },
  { 4924, 24, 22, 26, 3, -22 },
  { 4990, 19, 22, 17, -1, -22 },
  { 5043, 20, 30, 17, -2, -22 },
  { 5118, 17, 22, 17, 0, -22 },
  { 5165, 13, 39, 12, 1, -32 },
  { 5229, 8, 34, 10, 1, -29 },
  { 5263, 13, 39, 12, -2, -32 },
  { 5327, 19, 8, 23, 2, -16 },
};

const GFXfont RobotoCondensed_Italic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_ITALIC41PT7B_H_
