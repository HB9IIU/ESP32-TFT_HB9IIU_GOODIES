#ifndef _ROBOTOCONDENSED_ITALIC66PT7B_H_
#define _ROBOTOCONDENSED_ITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0C,
  0x00, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E, 0x3E,
  0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x78, 0x78, 0x78, 0x70, 0x78, 0x70, 0x78, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0,
  0xF0, 0x06, 0x1E, 0x03, 0xC0, 0x1C, 0x78, 0x0F, 0x00, 0xF3, 0xE0, 0x3C,
  0x07, 0xCF, 0x80, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0xF0, 0xF0, 0x0F, 0x07,
  0xC3, 0xC0, 0x3C, 0x3E, 0x0F, 0x00, 0xF0, 0xF0, 0x3C, 0x07, 0xC7, 0xC0,
  0x78, 0x1E, 0x3E, 0x01, 0xE0, 0xF8, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x0F,
  0xFE, 0x3E, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x3F,
  0xF0, 0x00, 0xF1, 0xFF, 0xE0, 0x07, 0x8F, 0xFF, 0x80, 0x3E, 0x3E, 0x1F,
  0x00, 0xF1, 0xF0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x3E, 0x1E, 0x03, 0xC0,
  0xF0, 0xF8, 0x0F, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x0F, 0x00, 0xF1, 0xF0,
  0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x0F, 0x3E, 0x03, 0xC0, 0x3D, 0xF0, 0x0F,
  0x01, 0xF3, 0x80, 0x3C, 0x07, 0x86, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8,
  0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xE3, 0xF8, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0xC3, 0xFB, 0xF8,
  0x1F, 0x1F, 0xC7, 0xE0, 0x7C, 0xFE, 0x1F, 0xC3, 0xF3, 0xF0, 0x3F, 0x0F,
  0x9F, 0x80, 0xFE, 0x3E, 0x7E, 0x01, 0xF8, 0xFB, 0xF0, 0x07, 0xF7, 0xCF,
  0xC0, 0x0F, 0xDF, 0x3F, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x7F, 0xE3, 0xF0,
  0x01, 0xFF, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xC0, 0xFF, 0xFE, 0x3F,
  0x00, 0xFF, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0xF3, 0xE7,
  0xCF, 0x9E, 0x3C, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x38, 0x0F, 0x01, 0xCF, 0xC3, 0xC3, 0xF7, 0xFC,
  0xF7, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xC3, 0xE0, 0x07, 0xE0,
  0xF8, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC0, 0x38, 0x01, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC3,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0,
  0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0x3E, 0x7E, 0x1F, 0x38, 0x0F, 0x90, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xC1, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3E, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x3F, 0x7F, 0xF0,
  0x3E, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xE0, 0xFE,
  0x7F, 0x80, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8,
  0x3F, 0x87, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xFE, 0x7F, 0x07, 0xFE, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0x7C, 0x0F, 0xFE, 0xFC, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x0F,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x80, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x9F, 0xE3, 0xF8,
  0x1F, 0x8F, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F,
  0xDF, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x7F, 0xE0,
  0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0xF0, 0x7C, 0x01, 0xFF, 0xFC, 0x07,
  0x07, 0x80, 0x3F, 0x0F, 0x80, 0x70, 0xF8, 0x07, 0xC0, 0x78, 0x07, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x71, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x71, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x3E, 0x03, 0xE0,
  0x0F, 0x00, 0xF3, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x1F,
  0x00, 0xF3, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x7C, 0x07, 0xC0, 0x1E, 0x00,
  0xF7, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x78, 0x0F, 0x80, 0x3E, 0x00, 0xF7,
  0x80, 0xF8, 0x03, 0xC0, 0x0E, 0x78, 0x0F, 0x80, 0x3C, 0x01, 0xEF, 0x80,
  0xF8, 0x07, 0xC0, 0x1E, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xEF, 0x80, 0xF0,
  0x07, 0x80, 0x3C, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xCF, 0x00, 0xF0, 0x0F,
  0x80, 0x3C, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x8F, 0x00, 0xF8, 0x1F, 0x80,
  0x78, 0xF0, 0x0F, 0x83, 0xF8, 0x0F, 0x0F, 0x00, 0xF8, 0x7F, 0x81, 0xE0,
  0xF0, 0x0F, 0xFF, 0x7C, 0x3E, 0x0F, 0x80, 0xFF, 0xE7, 0xFF, 0xC0, 0xF8,
  0x07, 0xFE, 0x3F, 0xF8, 0x07, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0x78, 0x00,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xF8,
  0x01, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0x80, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0x8F, 0xC0,
  0x0F, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xFC,
  0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x3F, 0x80, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFC, 0x00, 0x00,
  0x3F, 0xE3, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x1F, 0xBE, 0x00,
  0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x00, 0x0F, 0xBF, 0x01, 0xF3, 0xE0, 0x00,
  0x7E, 0xFC, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0xFC, 0xFC, 0x00, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x01, 0xF9,
  0xF8, 0x0F, 0xC7, 0xC0, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0x3F, 0x1F,
  0x80, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xE1, 0xF0,
  0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x3F, 0x01,
  0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x03, 0xF0,
  0x3E, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xE0, 0x3F, 0x01,
  0xE1, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC7, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF7,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xFF, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x1F,
  0x80, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xE0,
  0x00, 0x7E, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0x80,
  0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x3E, 0xF8, 0x00,
  0x3E, 0x03, 0xF3, 0xE0, 0x03, 0xF0, 0x1F, 0x9F, 0x00, 0x1F, 0x80, 0xFC,
  0xF8, 0x00, 0xFC, 0x07, 0xE3, 0xE0, 0x07, 0xE0, 0x3E, 0x1F, 0x00, 0x3E,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x80, 0xFC, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0xFC, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x03, 0xE1, 0xF8, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0xFC,
  0x07, 0xE0, 0x03, 0xE7, 0xE0, 0x3F, 0x00, 0x1F, 0x3F, 0x01, 0xF8, 0x00,
  0xF9, 0xF8, 0x0F, 0xC0, 0x03, 0xEF, 0xC0, 0x7C, 0x00, 0x1F, 0x7C, 0x07,
  0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xFF, 0x01, 0xF8, 0x00, 0x1F,
  0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F,
  0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xF0,
  0x01, 0xF8, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xFC, 0x00,
  0xFC, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xEF, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0x78, 0x03, 0xF0, 0x7E, 0x00, 0xF3, 0xC0, 0x1F, 0x83,
  0xF0, 0x0F, 0x9E, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0xF0, 0x0F, 0xC0, 0xFC,
  0x07, 0xC7, 0x80, 0x7E, 0x07, 0xE0, 0x3E, 0x3C, 0x03, 0xE0, 0x3F, 0x01,
  0xF1, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8,
  0x7C, 0x0F, 0x80, 0x7E, 0x07, 0x83, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x1F,
  0x07, 0xE0, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x07, 0xC1,
  0xF0, 0x03, 0xE1, 0xF0, 0x1E, 0x1F, 0x80, 0x1F, 0x0F, 0x00, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x3C, 0x7E, 0x00,
  0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0x0F,
  0x9F, 0x00, 0x79, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80, 0x03, 0xEF,
  0x80, 0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0xC0,
  0x07, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80,
  0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3E, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x7C, 0x78, 0x0F, 0x8F,
  0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x78, 0xF8, 0x0F,
  0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0xE3, 0xFC, 0x03, 0xF3, 0xF8, 0x01, 0xF1,
  0xF8, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xE3, 0xF8, 0x0F, 0xF1, 0xFF, 0x3F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x3F, 0xE0, 0x03, 0xEF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F,
  0x07, 0xFF, 0x1F, 0xF0, 0xFD, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xC0, 0xF8,
  0xFF, 0xF8, 0x0F, 0x87, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07,
  0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0xF1,
  0xF8, 0x01, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xEF,
  0x80, 0x3F, 0xC3, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80,
  0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x7C, 0x00, 0x0F, 0xFC, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x1F,
  0xC0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xC0,
  0x03, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x08, 0x1F, 0x80, 0x0E, 0x07, 0xF0, 0x07, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x20, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x07,
  0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0xBF, 0x01, 0xFF, 0xFE, 0xFC, 0x07, 0xF8,
  0x7F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x03,
  0xFC, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFD, 0xF0, 0x00, 0x7F, 0xE7, 0xC0, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0xC0, 0x03, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x3F,
  0xF0, 0x03, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x03, 0xE0, 0x7F,
  0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFB,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0x9F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xEF,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x9F, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF, 0xF1, 0xFE, 0x07, 0xF0, 0x0F, 0xFC,
  0x07, 0xE0, 0x7E, 0x00, 0xFF, 0x80, 0x7E, 0x07, 0xC0, 0x07, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0xFF, 0xC0,
  0x0F, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFC,
  0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF9, 0xFF, 0x80, 0x01, 0xF7, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x0F, 0xFC, 0x1F, 0xE0, 0x1F, 0xBF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0x00,
  0x7E, 0x7F, 0xFC, 0x00, 0xF8, 0x7F, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xFE, 0x1F, 0x01, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF, 0xBF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x7C,
  0x00, 0x7F, 0xEF, 0xC0, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x7F, 0x03, 0xEF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0x20, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x1F, 0xC7, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xE7, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xF0, 0x03,
  0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0xC0, 0x1F,
  0x8F, 0x80, 0x3F, 0x80, 0x3F, 0x1F, 0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x01,
  0xFE, 0x01, 0xF8, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xF8, 0x07,
  0xC1, 0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0xE0, 0x7D, 0xF0, 0x3E, 0x07, 0xC0,
  0xFB, 0xE0, 0xFC, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x1F, 0x07, 0xCF, 0x83,
  0xE0, 0x3E, 0x1F, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x78, 0xF8, 0x01, 0xF3, 0xE0, 0xF1,
  0xF0, 0x03, 0xEF, 0x81, 0xE7, 0xC0, 0x07, 0xDF, 0x03, 0xCF, 0x80, 0x0F,
  0xFC, 0x07, 0x9F, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFE,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3C,
  0x3F, 0xFC, 0x00, 0x78, 0xFF, 0xFC, 0x00, 0xF1, 0xFF, 0xFC, 0x03, 0xE7,
  0xE3, 0xF8, 0x07, 0x8F, 0x83, 0xF8, 0x1F, 0x3E, 0x03, 0xFC, 0x7E, 0x7C,
  0x03, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0xC7, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 14, 48, 16, 2, -47 },
  { 85, 16, 16, 21, 6, -50 },
  { 117, 33, 47, 35, 3, -47 },
  { 311, 28, 62, 32, 2, -55 },
  { 528, 30, 49, 41, 6, -48 },
  { 712, 30, 49, 35, 2, -48 },
  { 896, 7, 15, 11, 6, -50 },
  { 910, 20, 68, 20, 3, -53 },
  { 1080, 20, 68, 20, -3, -53 },
  { 1250, 26, 27, 28, 3, -47 },
  { 1338, 27, 35, 32, 3, -40 },
  { 1457, 12, 16, 13, -4, -7 },
  { 1481, 14, 5, 16, 1, -23 },
  { 1490, 7, 8, 17, 2, -7 },
  { 1497, 30, 51, 24, -3, -47 },
  { 1689, 27, 49, 32, 3, -48 },
  { 1855, 17, 47, 32, 8, -47 },
  { 1955, 29, 48, 32, 1, -48 },
  { 2129, 28, 49, 32, 2, -48 },
  { 2301, 29, 47, 32, 0, -47 },
  { 2472, 29, 48, 32, 3, -47 },
  { 2646, 24, 48, 32, 4, -47 },
  { 2790, 29, 47, 32, 4, -47 },
  { 2961, 28, 49, 32, 2, -48 },
  { 3133, 24, 48, 32, 5, -48 },
  { 3277, 13, 36, 15, 1, -35 },
  { 3336, 16, 44, 13, -3, -35 },
  { 3424, 25, 30, 29, 2, -36 },
  { 3518, 25, 18, 31, 4, -31 },
  { 3575, 25, 29, 29, 2, -35 },
  { 3666, 22, 49, 27, 5, -48 },
  { 3801, 44, 61, 49, 2, -46 },
  { 4137, 34, 47, 37, -2, -47 },
  { 4337, 31, 47, 35, 2, -47 },
  { 4520, 32, 49, 36, 4, -48 },
  { 4716, 32, 47, 37, 2, -47 },
  { 4904, 32, 47, 32, 2, -47 },
  { 5092, 31, 47, 31, 2, -47 },
  { 5275, 33, 49, 38, 3, -48 },
  { 5478, 38, 47, 40, 2, -47 },
  { 5702, 14, 47, 16, 2, -47 },
  { 5785, 31, 48, 31, 0, -47 },
  { 5971, 37, 47, 35, 2, -47 },
  { 6189, 24, 47, 30, 2, -47 },
  { 6330, 46, 47, 48, 2, -47 },
  { 6601, 37, 47, 40, 2, -47 },
  { 6819, 32, 49, 38, 4, -48 },
  { 7015, 34, 47, 35, 2, -47 },
  { 7215, 33, 56, 38, 3, -48 },
  { 7446, 32, 47, 34, 2, -47 },
  { 7634, 32, 49, 33, 1, -48 },
  { 7830, 30, 47, 33, 6, -47 },
  { 8007, 34, 48, 36, 3, -47 },
  { 8211, 33, 47, 36, 6, -47 },
  { 8405, 45, 47, 49, 7, -47 },
  { 8670, 38, 47, 35, -1, -47 },
  { 8894, 32, 47, 34, 6, -47 },
  { 9082, 36, 47, 33, -1, -47 },
  { 9294, 20, 64, 16, 0, -54 },
  { 9454, 12, 51, 24, 7, -47 },
  { 9531, 21, 64, 16, -4, -54 },
  { 9699, 19, 23, 24, 3, -47 },
  { 9754, 25, 5, 26, -3, 0 },
  { 9770, 11, 9, 20, 7, -49 },
  { 9783, 25, 37, 31, 2, -36 },
  { 9899, 28, 51, 32, 1, -50 },
  { 10078, 26, 37, 30, 2, -36 },
  { 10199, 31, 51, 32, 2, -50 },
  { 10397, 26, 37, 30, 2, -36 },
  { 10518, 22, 51, 20, 3, -51 },
  { 10659, 30, 49, 32, 0, -36 },
  { 10843, 27, 50, 31, 1, -50 },
  { 11012, 14, 48, 15, 1, -48 },
  { 11096, 20, 61, 14, -6, -48 },
  { 11249, 29, 50, 29, 1, -50 },
  { 11431, 14, 50, 15, 1, -50 },
  { 11519, 44, 36, 48, 1, -36 },
  { 11717, 27, 36, 31, 1, -36 },
  { 11839, 27, 37, 32, 2, -36 },
  { 11964, 31, 49, 32, -2, -36 },
  { 12154, 28, 49, 32, 2, -36 },
  { 12326, 20, 36, 20, 1, -36 },
  { 12416, 26, 37, 29, 1, -36 },
  { 12537, 16, 44, 19, 3, -43 },
  { 12625, 27, 36, 31, 3, -35 },
  { 12747, 24, 35, 27, 4, -35 },
  { 12852, 39, 35, 42, 4, -35 },
  { 13023, 31, 35, 28, -2, -35 },
  { 13159, 31, 48, 27, -3, -35 },
  { 13345, 28, 35, 28, 0, -35 },
  { 13468, 21, 64, 20, 2, -52 },
  { 13636, 14, 56, 16, 1, -47 },
  { 13734, 21, 63, 20, -3, -51 },
  { 13900, 31, 13, 38, 3, -26 },
};

const GFXfont RobotoCondensed_Italic66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_ITALIC66PT7B_H_
