#ifndef _ROBOTOCONDENSED_ITALIC54PT7B_H_
#define _ROBOTOCONDENSED_ITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x79, 0xE3, 0xCF, 0x1E,
  0x70, 0xE3, 0x87, 0x3C, 0x79, 0xE3, 0xCF, 0x1C, 0x70, 0xE3, 0x87, 0x1C,
  0x38, 0xE3, 0x8E, 0x1C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E,
  0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x1E,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x0F, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xC0, 0x21,
  0xC0, 0xE0, 0x39, 0xE0, 0x70, 0x3C, 0xF0, 0x38, 0x1C, 0x78, 0x1C, 0x1E,
  0x38, 0x0E, 0x1E, 0x1C, 0x07, 0x1E, 0x0F, 0x07, 0x8E, 0x07, 0x83, 0x8F,
  0x01, 0xC3, 0xCF, 0x00, 0xFF, 0xC7, 0x00, 0x3F, 0xE7, 0x80, 0x0F, 0xC7,
  0x80, 0x01, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE7, 0xF0, 0x01, 0xE7, 0xFC, 0x01, 0xE7, 0xFF, 0x00,
  0xE3, 0xC3, 0x80, 0xF3, 0xC1, 0xC0, 0xF1, 0xC0, 0xF0, 0x70, 0xE0, 0x78,
  0x78, 0x70, 0x3C, 0x78, 0x78, 0x1E, 0x38, 0x3C, 0x0F, 0x3C, 0x1E, 0x07,
  0x3C, 0x0F, 0x03, 0x9C, 0x03, 0x83, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0xC0,
  0x78, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF0, 0x07, 0xC1,
  0xF0, 0x03, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x0F, 0x1F, 0x3E, 0x0F, 0x3E, 0x3E, 0x0F, 0x7E, 0x1F,
  0x1F, 0x7C, 0x1F, 0x1E, 0xF8, 0x0F, 0x9E, 0xF8, 0x0F, 0xBE, 0xF8, 0x07,
  0xFC, 0xF0, 0x07, 0xFC, 0xF0, 0x03, 0xF8, 0xF0, 0x03, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xF8, 0x7C, 0x07, 0xF8, 0x7F, 0xBF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFE, 0x3E, 0x0F, 0xFC, 0x3E, 0x00, 0x80, 0x00, 0x7B, 0xDE,
  0xF7, 0xB9, 0xDE, 0xF7, 0xB9, 0xCE, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x01, 0x81, 0xE0,
  0x4F, 0x0F, 0x1F, 0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80,
  0x1F, 0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0x80,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x3E,
  0x3E, 0x0E, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF,
  0xFF, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0x7F, 0x07, 0xE0, 0x78, 0x3E, 0x03, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78,
  0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xDE,
  0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x03,
  0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8,
  0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x1F, 0x07, 0xE0, 0xFE, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xE7, 0xF7, 0x9F, 0x1E, 0x60,
  0xFA, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0x81, 0xF8, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x83,
  0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x0F, 0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8,
  0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x07,
  0xBF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFC,
  0x0F, 0x80, 0x20, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE7, 0xE0, 0x3D,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF8, 0x7E, 0x7F, 0x03, 0xE7,
  0xE0, 0x1E, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7C,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0xF8, 0x0F,
  0x80, 0xF8, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x0F, 0x81, 0xF0, 0x3F,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C,
  0x01, 0xE7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E,
  0xF8, 0x03, 0xE7, 0x80, 0x7E, 0x7C, 0x0F, 0xE7, 0xE1, 0xFE, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xF3, 0xC0, 0x7E, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC3, 0xF7, 0xE0, 0x7D, 0xF0,
  0x1F, 0x78, 0x03, 0xDE, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x3F, 0x00, 0x60,
  0xF0, 0x0F, 0xF8, 0x07, 0x0E, 0x01, 0xFF, 0xE0, 0x71, 0xE0, 0x3F, 0x3E,
  0x07, 0x1E, 0x07, 0xC1, 0xE0, 0x73, 0xC0, 0x78, 0x1E, 0x07, 0x3C, 0x0F,
  0x01, 0xC0, 0x73, 0x80, 0xF0, 0x3C, 0x07, 0x78, 0x1E, 0x03, 0xC0, 0x77,
  0x81, 0xE0, 0x3C, 0x07, 0x78, 0x1E, 0x03, 0x80, 0x77, 0x03, 0xC0, 0x78,
  0x0F, 0xF0, 0x3C, 0x07, 0x80, 0xEF, 0x03, 0xC0, 0x78, 0x0E, 0xF0, 0x3C,
  0x07, 0x00, 0xEF, 0x07, 0x80, 0xF0, 0x0E, 0xE0, 0x78, 0x0F, 0x01, 0xCE,
  0x07, 0x80, 0xF0, 0x1C, 0xE0, 0x78, 0x0F, 0x01, 0xCE, 0x07, 0x81, 0xE0,
  0x38, 0xE0, 0x78, 0x1E, 0x03, 0x8E, 0x07, 0x83, 0xE0, 0x70, 0xE0, 0x7C,
  0x7F, 0x0F, 0x0E, 0x03, 0xFE, 0xFF, 0xE0, 0xE0, 0x3F, 0xC7, 0xFC, 0x0F,
  0x01, 0xF8, 0x3F, 0x80, 0xF0, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0x80, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x3E, 0x01, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3E, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0xF8,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xFF, 0x9E, 0x01, 0xFF, 0xEF, 0x80,
  0x7F, 0xFB, 0xE0, 0x1F, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x07,
  0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0x80,
  0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFD, 0xF0, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0,
  0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7B, 0xC0, 0x01, 0xFF,
  0x81, 0xEF, 0x00, 0x07, 0xBC, 0x07, 0xBE, 0x00, 0x3E, 0xF0, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0xF9, 0xE0, 0x07, 0xDF, 0x03, 0xE7, 0x80, 0x1E, 0x7C,
  0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x1F, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x0F, 0x03, 0xE3, 0xE0,
  0x7C, 0x3C, 0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xC1,
  0xE0, 0xF0, 0x1E, 0x0F, 0x0F, 0x87, 0xC0, 0xF8, 0x3C, 0x3C, 0x1F, 0x03,
  0xE0, 0x79, 0xF0, 0x7C, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0x3E, 0x07, 0xBE,
  0x07, 0x80, 0xF0, 0x1E, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xC0, 0xF8, 0x1F,
  0x01, 0xFE, 0x03, 0xE0, 0x7C, 0x07, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x78,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0xC0, 0x01,
  0xF0, 0x3F, 0x80, 0x03, 0xE0, 0x7F, 0x00, 0x07, 0x80, 0xFF, 0x00, 0x1F,
  0x01, 0xFE, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x7C, 0x0F, 0xBC, 0x00, 0xF8,
  0x1F, 0x78, 0x01, 0xE0, 0x3E, 0xF0, 0x03, 0xC0, 0x7C, 0xF0, 0x0F, 0x80,
  0xF1, 0xE0, 0x1F, 0x03, 0xE3, 0xC0, 0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x0F,
  0x87, 0x80, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x07, 0xC0, 0xF8,
  0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x1F, 0x03, 0xE0, 0x3C, 0x3E, 0x07, 0xC0,
  0x78, 0x78, 0x0F, 0x80, 0xF1, 0xF0, 0x1E, 0x00, 0xF3, 0xE0, 0x7C, 0x01,
  0xE7, 0xC0, 0xF8, 0x03, 0xCF, 0x81, 0xF0, 0x03, 0xDF, 0x03, 0xE0, 0x07,
  0xBC, 0x07, 0xC0, 0x0F, 0xF8, 0x0F, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x1F,
  0xE0, 0x7C, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E,
  0x03, 0xC0, 0x00, 0xFC, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x7C,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x79, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0x8F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xE0, 0x0F, 0xE0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x00, 0x3F, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3C,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00,
  0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x01,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x07, 0xE0, 0x3C, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0,
  0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0xF0,
  0x03, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x80, 0x1F, 0x3C, 0x00, 0xFC, 0x01,
  0xF1, 0xE0, 0x0F, 0xE0, 0x0F, 0x8F, 0x00, 0x7F, 0x00, 0x7C, 0x78, 0x03,
  0xB8, 0x07, 0xC3, 0xC0, 0x3D, 0xC0, 0x3E, 0x1E, 0x01, 0xEE, 0x01, 0xE0,
  0xF0, 0x1E, 0x70, 0x1F, 0x07, 0x80, 0xF3, 0x80, 0xF8, 0x3C, 0x07, 0x9E,
  0x07, 0x81, 0xE0, 0x78, 0xF0, 0x7C, 0x0F, 0x03, 0xC7, 0x83, 0xE0, 0x78,
  0x3C, 0x3C, 0x1E, 0x03, 0xC1, 0xE1, 0xE1, 0xF0, 0x1E, 0x0F, 0x0F, 0x0F,
  0x80, 0xF0, 0xF0, 0x78, 0x78, 0x07, 0x87, 0x83, 0xC7, 0xC0, 0x3C, 0x3C,
  0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x0F, 0x1E, 0x03, 0x9F, 0x00,
  0x7D, 0xE0, 0x1C, 0xF8, 0x03, 0xEF, 0x00, 0xE7, 0x80, 0x1F, 0x78, 0x07,
  0x3C, 0x00, 0xFF, 0x80, 0x3B, 0xC0, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0x3D,
  0xC0, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xC0,
  0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xDC, 0x03, 0xDC, 0x07, 0x9E, 0x07, 0x9E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x0E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xE0, 0x7C,
  0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0x1E, 0x3F, 0x81, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x7C,
  0x07, 0xE3, 0xE0, 0x7F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xBE,
  0x07, 0xF1, 0xF0, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0xFE, 0x01, 0xF7, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x7C, 0x00,
  0xF0, 0xF8, 0x01, 0xE1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F,
  0x8F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF1,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xF0,
  0x0F, 0x8F, 0xF0, 0x3E, 0x1F, 0xFF, 0xFC, 0x3C, 0xFF, 0xF0, 0x79, 0xFF,
  0xC0, 0xF0, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0x7F, 0x0F, 0xC0, 0xF8, 0x7C,
  0x03, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07,
  0xC3, 0xE0, 0x7E, 0x1F, 0xEF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x02, 0x07, 0xC0, 0x1F, 0xE3, 0xE0, 0x3F, 0xF9,
  0xE0, 0x3F, 0xFE, 0xF0, 0x1F, 0xFF, 0x78, 0x1F, 0x81, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x3F, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0,
  0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xF7, 0x80, 0x0F, 0xF3,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFE, 0xFE, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xC7,
  0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01,
  0xF7, 0x80, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x01, 0x83, 0xE0,
  0x3E, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC7, 0xC0, 0x7F, 0xF3, 0xC0, 0x7F, 0xFD, 0xE0, 0x3F, 0xFE,
  0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x3E, 0x01, 0xF8, 0x0F, 0x81, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0x80, 0x01, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x08, 0x00, 0xF8, 0x0E, 0x00,
  0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x40, 0x07, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x3E, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0,
  0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC0, 0x00,
  0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xE1, 0xF0, 0x1F, 0x83,
  0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x3C,
  0x3F, 0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xF0, 0x03, 0xEF, 0xC0, 0x07, 0x9F,
  0x00, 0x0F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x80,
  0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x79, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xF0, 0x3E, 0x0F, 0x80,
  0xFE, 0x03, 0xE1, 0xF0, 0x07, 0xE0, 0x1E, 0x1F, 0x00, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0x03, 0xE3,
  0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x78, 0x01,
  0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x07, 0x8F,
  0x80, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x00,
  0xF8, 0xF0, 0x03, 0xE0, 0x0F, 0x8F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x7F, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C,
  0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x7E,
  0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x03, 0xFB, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF3, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1F, 0x00,
  0x1E, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0xC0, 0x7C, 0x0F, 0xFD, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xCF, 0xFE, 0x01, 0xE3, 0xFE, 0x00, 0xF0, 0x10, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x7C, 0x1F, 0xFC, 0xF0, 0x7F, 0xFD, 0xE0, 0xFF, 0xFB, 0xC3, 0xF0,
  0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x1F, 0x81, 0xFE,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xF8, 0x00, 0x41,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xE0, 0xF8, 0x3E, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x78, 0x03, 0xC3,
  0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x07, 0xFF, 0xDF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x01, 0x80, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0x7C, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xE7, 0x80, 0x0C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78,
  0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87,
  0x80, 0xF8, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xE0,
  0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x01, 0xCF, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE0,
  0x0F, 0x00, 0x7B, 0xC0, 0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x03, 0xEF, 0x01,
  0xF8, 0x07, 0x9E, 0x03, 0xF0, 0x1F, 0x3C, 0x07, 0xE0, 0x3C, 0x78, 0x1F,
  0xE0, 0x78, 0xF0, 0x3F, 0xC1, 0xF1, 0xE0, 0xF7, 0x83, 0xC3, 0xC1, 0xEF,
  0x0F, 0x87, 0x87, 0x9E, 0x1E, 0x0F, 0x0F, 0x3C, 0x3C, 0x1E, 0x1E, 0x78,
  0xF8, 0x3E, 0x78, 0xF1, 0xE0, 0x3C, 0xF1, 0xE3, 0xC0, 0x7B, 0xC1, 0xCF,
  0x00, 0xF7, 0x83, 0x9E, 0x01, 0xFE, 0x07, 0x7C, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xE7,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7D, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0x3C, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0xC0,
  0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xF8, 0x01, 0xCF, 0xFE, 0x01, 0xE7, 0xFF, 0x80, 0xF7, 0xCF, 0xC0, 0x73,
  0xC1, 0xF0, 0x7B, 0xC0, 0x7C, 0x7D, 0xE0, 0x3F, 0xFC, 0xF0, 0x0F, 0xFC,
  0x78, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 39, 13, 2, -38 },
  { 55, 13, 13, 17, 5, -41 },
  { 77, 27, 38, 29, 2, -38 },
  { 206, 23, 51, 26, 2, -45 },
  { 353, 25, 40, 33, 5, -39 },
  { 478, 24, 40, 29, 2, -39 },
  { 598, 5, 13, 9, 5, -41 },
  { 607, 16, 55, 16, 3, -43 },
  { 717, 17, 55, 17, -3, -43 },
  { 834, 21, 22, 23, 3, -38 },
  { 892, 23, 28, 26, 2, -32 },
  { 973, 9, 13, 10, -3, -6 },
  { 988, 11, 4, 13, 1, -18 },
  { 994, 6, 6, 14, 1, -5 },
  { 999, 25, 41, 19, -3, -38 },
  { 1128, 21, 40, 26, 3, -39 },
  { 1233, 14, 38, 26, 6, -38 },
  { 1300, 25, 39, 26, 0, -39 },
  { 1422, 23, 40, 26, 1, -39 },
  { 1537, 24, 38, 26, 0, -38 },
  { 1651, 23, 39, 26, 3, -38 },
  { 1764, 20, 39, 26, 3, -38 },
  { 1862, 24, 38, 26, 3, -38 },
  { 1976, 23, 40, 26, 2, -39 },
  { 2091, 20, 39, 26, 4, -39 },
  { 2189, 10, 29, 13, 1, -28 },
  { 2226, 14, 35, 11, -3, -28 },
  { 2288, 20, 24, 23, 2, -29 },
  { 2348, 20, 14, 25, 3, -25 },
  { 2383, 20, 24, 24, 2, -29 },
  { 2443, 18, 40, 22, 4, -39 },
  { 2533, 36, 50, 40, 2, -38 },
  { 2758, 28, 38, 30, -2, -38 },
  { 2891, 26, 38, 29, 1, -38 },
  { 3015, 26, 40, 30, 3, -39 },
  { 3145, 27, 38, 30, 1, -38 },
  { 3274, 27, 38, 26, 1, -38 },
  { 3403, 26, 38, 25, 1, -38 },
  { 3527, 26, 40, 31, 3, -39 },
  { 3657, 31, 38, 32, 1, -38 },
  { 3805, 12, 38, 13, 1, -38 },
  { 3862, 26, 39, 25, 0, -38 },
  { 3989, 31, 38, 29, 1, -38 },
  { 4137, 20, 38, 25, 1, -38 },
  { 4232, 38, 38, 40, 1, -38 },
  { 4413, 31, 38, 32, 1, -38 },
  { 4561, 27, 40, 31, 3, -39 },
  { 4696, 28, 38, 29, 1, -38 },
  { 4829, 27, 45, 31, 3, -39 },
  { 4981, 27, 38, 28, 1, -38 },
  { 5110, 26, 40, 27, 1, -39 },
  { 5240, 25, 38, 27, 5, -38 },
  { 5359, 28, 39, 29, 2, -38 },
  { 5496, 27, 38, 29, 5, -38 },
  { 5625, 37, 38, 40, 5, -38 },
  { 5801, 32, 38, 29, -1, -38 },
  { 5953, 26, 38, 28, 5, -38 },
  { 6077, 28, 38, 27, 0, -38 },
  { 6210, 16, 52, 13, 0, -44 },
  { 6314, 10, 41, 19, 5, -38 },
  { 6366, 17, 52, 13, -3, -44 },
  { 6477, 16, 19, 19, 2, -38 },
  { 6515, 21, 4, 21, -3, 0 },
  { 6526, 10, 8, 16, 5, -41 },
  { 6536, 21, 31, 25, 1, -30 },
  { 6618, 23, 42, 26, 1, -41 },
  { 6739, 21, 31, 24, 2, -30 },
  { 6821, 25, 42, 26, 2, -41 },
  { 6953, 21, 31, 25, 2, -30 },
  { 7035, 17, 42, 17, 3, -42 },
  { 7125, 25, 41, 26, 0, -30 },
  { 7254, 22, 41, 25, 1, -41 },
  { 7367, 11, 40, 12, 1, -40 },
  { 7422, 17, 51, 12, -5, -40 },
  { 7531, 23, 41, 24, 1, -41 },
  { 7649, 12, 41, 12, 1, -41 },
  { 7711, 36, 30, 39, 1, -30 },
  { 7846, 22, 30, 25, 1, -30 },
  { 7929, 22, 31, 26, 2, -30 },
  { 8015, 25, 41, 26, -1, -30 },
  { 8144, 23, 41, 26, 2, -30 },
  { 8262, 16, 30, 16, 1, -30 },
  { 8322, 21, 31, 24, 1, -30 },
  { 8404, 14, 36, 16, 2, -35 },
  { 8467, 22, 30, 25, 2, -29 },
  { 8550, 20, 29, 22, 3, -29 },
  { 8623, 31, 29, 34, 4, -29 },
  { 8736, 25, 29, 23, -1, -29 },
  { 8827, 25, 40, 22, -2, -29 },
  { 8952, 23, 29, 23, 0, -29 },
  { 9036, 17, 52, 16, 2, -42 },
  { 9147, 11, 45, 13, 1, -38 },
  { 9209, 17, 52, 16, -3, -42 },
  { 9320, 25, 11, 31, 3, -22 },
};

const GFXfont RobotoCondensed_Italic54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_ITALIC54PT7B_H_
