#ifndef _ROBOTOCONDENSED_ITALIC63PT7B_H_
#define _ROBOTOCONDENSED_ITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0x80, 0x10, 0x00, 0x3E, 0x1E, 0x7C, 0x7C, 0xF0, 0xF9, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1,
  0xE3, 0x83, 0x87, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xEF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x03, 0x0F, 0x03, 0xC0, 0x3C, 0xF0, 0x1E, 0x03, 0xE7,
  0x80, 0xF0, 0x1E, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x1F, 0x0F, 0x01,
  0xE0, 0xF0, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0x78, 0xF8, 0x1E, 0x07, 0x87,
  0x80, 0xF8, 0x3C, 0x78, 0x03, 0xE7, 0xC7, 0xC0, 0x1F, 0xFE, 0x3C, 0x00,
  0x7F, 0xE3, 0xC0, 0x01, 0xFE, 0x3E, 0x00, 0x01, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF8, 0xFF, 0x80, 0x07, 0x8F, 0xFE,
  0x00, 0x78, 0xF8, 0xF8, 0x07, 0xCF, 0x83, 0xC0, 0x3C, 0x78, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x3E, 0x3E, 0x03, 0xC1, 0xE1, 0xE0, 0x1E, 0x1E, 0x0F,
  0x00, 0xF1, 0xF0, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x03,
  0xCF, 0x80, 0xF0, 0x1E, 0x78, 0x07, 0x81, 0xF1, 0x80, 0x1E, 0x0F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0,
  0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x07, 0xC3, 0xF3, 0xF0, 0x3C, 0x3F, 0x1F, 0x83, 0xE3,
  0xF0, 0x7E, 0x1F, 0x3F, 0x83, 0xF0, 0xF9, 0xF8, 0x0F, 0xC7, 0xCF, 0x80,
  0x7E, 0x7C, 0xFC, 0x01, 0xFB, 0xE7, 0xE0, 0x0F, 0xFE, 0x3F, 0x00, 0x3F,
  0xF1, 0xF0, 0x01, 0xFF, 0x0F, 0x80, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0x83, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x7E, 0x03, 0xFF, 0x83, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0xF9,
  0xF3, 0xC7, 0x8F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3E, 0x02, 0x3C, 0x1E,
  0x07, 0x3F, 0x8F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x01, 0xF8, 0xF8, 0x01,
  0xF8, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x0C, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3E, 0x07, 0x00, 0x80, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7D, 0xFB, 0xF7, 0xEF,
  0xDF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x07, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFC, 0x7E, 0x3E, 0x3C, 0x1F, 0x18, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x30,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x87,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0x7F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC0, 0xFC, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0x3E, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80,
  0x3F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0x07,
  0xE0, 0x3E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0xFE, 0x7C, 0x03, 0xFC, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0x81, 0xFF, 0xBE, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x3C,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0x78, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x04,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xF7, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x3F, 0x00, 0x3C, 0x1F, 0x00,
  0x3F, 0xF0, 0x0F, 0x07, 0x80, 0x3F, 0xFE, 0x01, 0xC3, 0xE0, 0x1F, 0xFF,
  0xC0, 0x70, 0xF0, 0x07, 0xC1, 0xF0, 0x1C, 0x3C, 0x03, 0xE0, 0x7C, 0x07,
  0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xC7, 0x80, 0x78, 0x07, 0x80, 0x73, 0xE0,
  0x3E, 0x01, 0xE0, 0x1C, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x3C, 0x07, 0xC0,
  0x3C, 0x03, 0xCF, 0x01, 0xE0, 0x0F, 0x00, 0xF7, 0xC0, 0x78, 0x03, 0xC0,
  0x3D, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x78, 0x0F, 0x80, 0x78, 0x03, 0xDE,
  0x03, 0xC0, 0x1E, 0x00, 0xE7, 0x80, 0xF0, 0x07, 0x80, 0x3B, 0xE0, 0x7C,
  0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0xBC, 0x07, 0xC0, 0x3C,
  0x01, 0xCF, 0x01, 0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0x7C, 0x07, 0xC0, 0x3C,
  0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x3C, 0x07, 0xC0, 0xFC, 0x07, 0x8F, 0x01,
  0xF0, 0x7F, 0x03, 0xC3, 0xC0, 0x7C, 0x1F, 0xC0, 0xF0, 0xF0, 0x1F, 0xFE,
  0xF0, 0xF8, 0x3C, 0x03, 0xFF, 0x3F, 0xFC, 0x0F, 0x00, 0xFF, 0xC7, 0xFE,
  0x01, 0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x03, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0x7E,
  0x00, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xE3, 0xE0,
  0x0F, 0xFF, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xF0, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0xFE, 0x00,
  0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0x07,
  0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xBF,
  0x00, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x07, 0xDF, 0x00,
  0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x00,
  0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x00, 0x7E,
  0xF8, 0x07, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x00, 0x3F, 0x3E,
  0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x1F, 0x9F, 0x80,
  0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x83,
  0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0x0F, 0xC0, 0xF0, 0x7C, 0x1F, 0x80, 0x7C, 0x07, 0x87, 0xC0,
  0xFC, 0x03, 0xE0, 0x3E, 0x3E, 0x07, 0xE0, 0x1F, 0x01, 0xF3, 0xE0, 0x3E,
  0x01, 0xF8, 0x0F, 0x9F, 0x01, 0xF0, 0x0F, 0xC0, 0x7D, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xEF, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x0F, 0xC0,
  0x1F, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01,
  0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0x7C, 0x01, 0xFF,
  0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x01, 0xF8,
  0x07, 0xEF, 0x00, 0x0F, 0xC0, 0x3F, 0x7C, 0x00, 0x7E, 0x01, 0xF3, 0xE0,
  0x03, 0xE0, 0x0F, 0x8F, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x07,
  0xE3, 0xE0, 0x0F, 0xC0, 0x3F, 0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x7C, 0x03,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x03, 0xF0,
  0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0x03, 0xE3, 0xF0, 0x0F,
  0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x03, 0xE7,
  0xC0, 0x1F, 0x00, 0x1F, 0x3E, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0xC0,
  0x1F, 0x00, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x07,
  0xE0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F,
  0xE0, 0x3E, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0xF8, 0x01, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC3, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xFF, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xFE, 0x00, 0xFC,
  0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xDF, 0x00, 0xF8, 0x1F, 0x00, 0xF9, 0xE0, 0x1F, 0x03, 0xE0, 0x1E,
  0x3C, 0x07, 0xE0, 0x7C, 0x07, 0xC7, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x1E, 0x07, 0xE0, 0x3E, 0x07, 0xC3, 0xC0, 0xF8,
  0x07, 0xC0, 0xF0, 0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x0F, 0x07, 0xE0, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x03, 0xE0, 0xF0, 0x3C, 0x1F, 0x00, 0x7C, 0x3E,
  0x07, 0x87, 0xE0, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x07, 0xC7, 0x80, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0xF3, 0xE0, 0x03,
  0xE7, 0x80, 0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xDF, 0x00, 0x07, 0xBC,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0,
  0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0x78, 0x7C,
  0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xE0, 0x7E, 0x3F, 0x80, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0xFF, 0x3F,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x0F, 0xF0,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF9, 0xFF, 0x00, 0x3F, 0x7F, 0xF0, 0x07, 0xDF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0,
  0x1F, 0xC1, 0xFF, 0x8F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0x81,
  0xF1, 0xFF, 0xE0, 0x3E, 0x1F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80,
  0x1F, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0x1F, 0x80, 0x3F, 0xFC, 0xF8, 0x03, 0xFF,
  0xF7, 0xC0, 0x3F, 0xFF, 0xBE, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0x80, 0x7F,
  0x81, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x7C, 0x00, 0x1F,
  0xF3, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x7E, 0x00, 0xF8, 0x3F, 0x83, 0xFC,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x87, 0xC0, 0x1F, 0xFE, 0x3E, 0x01, 0xFF, 0xFB, 0xE0,
  0x1F, 0xFF, 0xDF, 0x01, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC,
  0x00, 0xFE, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBE, 0x00, 0x0F, 0xF9, 0xF0,
  0x00, 0x0C, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x04, 0x00, 0x1F, 0x80, 0x30, 0x01,
  0xF8, 0x03, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x9F, 0xF0, 0x0F,
  0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xE0,
  0xFE, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03,
  0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xF0, 0x00, 0x20, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x1F,
  0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x03, 0xE1, 0xFC, 0x00, 0x7C, 0x7F, 0x00, 0x0F, 0x9F, 0xC0, 0x01, 0xF7,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xDF,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xF1, 0xFF, 0x01, 0xFF, 0x00, 0x7D,
  0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0x1F, 0xE0, 0x7E, 0x01, 0xFF, 0x01,
  0xF8, 0x3F, 0x00, 0x7F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE3, 0xFE, 0x01, 0xF3, 0xFF, 0x80, 0xFB, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xE3, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0,
  0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFB,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xF0, 0x01,
  0xF7, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xF7, 0xFF, 0xE0, 0x3E, 0x3F, 0xFC, 0x03,
  0xE1, 0xFF, 0x00, 0x3E, 0x01, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x7C, 0x07, 0xFF, 0x9F, 0x01,
  0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0x7C, 0x1F, 0xE0, 0xFF, 0x83, 0xF0, 0x0F,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFE, 0xF8, 0x00, 0xFF, 0x9F, 0x00, 0x03, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x80, 0xFD, 0xFC, 0x1F, 0x7F, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xFC, 0x7F, 0xC0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0xA0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x01, 0x00, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x07,
  0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80,
  0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0,
  0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x0F, 0xF3, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xE0, 0x1F, 0xF3, 0xE0, 0x00, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x07, 0xEF, 0x80, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x01,
  0xE7, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1E,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xBE, 0x00,
  0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x80, 0x3E,
  0x7C, 0x01, 0xFC, 0x03, 0xF1, 0xF0, 0x1F, 0xE0, 0x1F, 0x0F, 0x80, 0xFF,
  0x00, 0xF8, 0x7C, 0x0F, 0xF8, 0x0F, 0x83, 0xE0, 0x7F, 0xC0, 0x7C, 0x1F,
  0x03, 0xDE, 0x07, 0xC0, 0xF8, 0x3E, 0xF0, 0x3E, 0x07, 0xC1, 0xE7, 0x81,
  0xF0, 0x3E, 0x1F, 0x3E, 0x1F, 0x01, 0xF0, 0xF9, 0xF0, 0xF8, 0x0F, 0x8F,
  0x8F, 0x8F, 0x80, 0x7C, 0x7C, 0x7C, 0x7C, 0x03, 0xE3, 0xC3, 0xE3, 0xE0,
  0x1F, 0x3E, 0x0F, 0x3E, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x07, 0xDF, 0x03,
  0xCF, 0x00, 0x1E, 0xF8, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0xF7, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0xFC,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7D, 0xF8,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0xFF, 0xE0,
  0x07, 0xC7, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF, 0x80, 0x78, 0xF8, 0x7F, 0x03,
  0xE7, 0xC0, 0xFE, 0x1F, 0x1F, 0x01, 0xFF, 0xFC, 0x78, 0x03, 0xFF, 0xE3,
  0xE0, 0x07, 0xFF, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 46, 15, 2, -45 },
  { 76, 15, 15, 20, 6, -47 },
  { 105, 31, 45, 33, 3, -45 },
  { 280, 27, 60, 30, 2, -53 },
  { 483, 29, 47, 39, 6, -46 },
  { 654, 29, 47, 33, 2, -46 },
  { 825, 7, 15, 11, 5, -47 },
  { 839, 19, 65, 19, 3, -51 },
  { 994, 19, 65, 19, -3, -51 },
  { 1149, 25, 26, 26, 3, -45 },
  { 1231, 26, 32, 30, 3, -37 },
  { 1335, 10, 16, 12, -3, -7 },
  { 1355, 13, 5, 15, 1, -22 },
  { 1364, 7, 7, 16, 2, -6 },
  { 1371, 28, 49, 23, -3, -45 },
  { 1543, 25, 47, 30, 3, -46 },
  { 1690, 17, 45, 30, 7, -45 },
  { 1786, 28, 46, 30, 1, -46 },
  { 1947, 26, 47, 30, 2, -46 },
  { 2100, 28, 45, 30, 0, -45 },
  { 2258, 28, 46, 30, 3, -45 },
  { 2419, 24, 46, 30, 3, -45 },
  { 2557, 28, 45, 30, 4, -45 },
  { 2715, 27, 47, 30, 2, -46 },
  { 2874, 23, 46, 30, 5, -46 },
  { 3007, 12, 34, 15, 1, -33 },
  { 3058, 15, 42, 13, -3, -33 },
  { 3137, 24, 28, 27, 2, -34 },
  { 3221, 24, 18, 29, 3, -30 },
  { 3275, 24, 28, 28, 2, -34 },
  { 3359, 21, 47, 26, 5, -46 },
  { 3483, 42, 58, 47, 2, -44 },
  { 3788, 33, 45, 35, -2, -45 },
  { 3974, 31, 45, 33, 1, -45 },
  { 4149, 31, 47, 35, 3, -46 },
  { 4332, 32, 45, 35, 1, -45 },
  { 4512, 31, 45, 30, 1, -45 },
  { 4687, 31, 45, 29, 1, -45 },
  { 4862, 31, 47, 36, 3, -46 },
  { 5045, 37, 45, 38, 1, -45 },
  { 5254, 13, 45, 15, 2, -45 },
  { 5328, 30, 46, 30, 0, -45 },
  { 5501, 36, 45, 33, 1, -45 },
  { 5704, 24, 45, 29, 1, -45 },
  { 5839, 45, 45, 46, 1, -45 },
  { 6093, 37, 45, 38, 1, -45 },
  { 6302, 32, 47, 37, 3, -46 },
  { 6490, 33, 45, 34, 1, -45 },
  { 6676, 31, 54, 37, 3, -46 },
  { 6886, 31, 45, 32, 1, -45 },
  { 7061, 31, 47, 32, 1, -46 },
  { 7244, 30, 45, 32, 5, -45 },
  { 7413, 32, 46, 34, 3, -45 },
  { 7597, 32, 45, 34, 5, -45 },
  { 7777, 43, 45, 47, 6, -45 },
  { 8019, 37, 45, 34, -1, -45 },
  { 8228, 30, 45, 32, 6, -45 },
  { 8397, 34, 45, 32, -1, -45 },
  { 8589, 19, 61, 15, 0, -51 },
  { 8734, 12, 49, 23, 6, -45 },
  { 8808, 19, 61, 15, -3, -51 },
  { 8953, 18, 22, 23, 3, -45 },
  { 9003, 24, 5, 25, -3, 0 },
  { 9018, 11, 9, 19, 6, -47 },
  { 9031, 24, 35, 29, 2, -34 },
  { 9136, 27, 48, 30, 1, -47 },
  { 9298, 25, 35, 28, 2, -34 },
  { 9408, 29, 48, 30, 2, -47 },
  { 9582, 24, 35, 29, 2, -34 },
  { 9687, 21, 48, 19, 3, -48 },
  { 9813, 29, 47, 30, 0, -34 },
  { 9984, 25, 47, 30, 1, -47 },
  { 10131, 13, 46, 14, 1, -46 },
  { 10206, 20, 59, 14, -6, -46 },
  { 10354, 27, 47, 28, 1, -47 },
  { 10513, 14, 47, 14, 1, -47 },
  { 10596, 42, 34, 46, 1, -34 },
  { 10775, 25, 34, 30, 1, -34 },
  { 10882, 26, 35, 31, 2, -34 },
  { 10996, 28, 47, 30, -1, -34 },
  { 11161, 27, 47, 31, 2, -34 },
  { 11320, 19, 34, 19, 1, -34 },
  { 11401, 25, 35, 28, 1, -34 },
  { 11511, 16, 42, 18, 2, -41 },
  { 11595, 25, 34, 30, 3, -33 },
  { 11702, 23, 33, 26, 4, -33 },
  { 11797, 37, 33, 40, 4, -33 },
  { 11950, 28, 33, 27, -1, -33 },
  { 12066, 30, 46, 25, -3, -33 },
  { 12239, 26, 33, 27, 0, -33 },
  { 12347, 20, 60, 19, 2, -49 },
  { 12497, 13, 53, 15, 1, -45 },
  { 12584, 20, 60, 19, -3, -49 },
  { 12734, 30, 12, 36, 3, -24 },
};

const GFXfont RobotoCondensed_Italic63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_ITALIC63PT7B_H_
