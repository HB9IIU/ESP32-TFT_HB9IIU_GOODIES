#ifndef _ROBOTOCONDENSED_ITALIC7PT7B_H_
#define _ROBOTOCONDENSED_ITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0x00, 0x17, 0x6E, 0x00, 0x2D, 0x23, 0x50, 0x99, 0x76,
  0x6D, 0x5E, 0x00, 0x16, 0xA8, 0x15, 0x58, 0x0E, 0x00, 0x5D, 0x20, 0xC0,
  0x00, 0x80, 0x29, 0x48, 0x76, 0xDE, 0xDA, 0x80, 0x64, 0xAE, 0x65, 0x1E,
  0x2D, 0xF2, 0x68, 0x9E, 0x6A, 0xDE, 0x62, 0x24, 0x40, 0x6D, 0x5E, 0xFD,
  0x80, 0x10, 0x18, 0x39, 0x00, 0x7C, 0x0F, 0x00, 0xDA, 0x00, 0x32, 0x6F,
  0xBF, 0xC1, 0x00, 0x2D, 0xBA, 0x65, 0x6A, 0xE0, 0x79, 0x88, 0x60, 0x65,
  0x99, 0xE0, 0x74, 0x68, 0xE0, 0x64, 0x68, 0x80, 0x78, 0x89, 0x60, 0x55,
  0x79, 0x90, 0x5A, 0x80, 0x04, 0x9C, 0x56, 0x4A, 0xA0, 0x4A, 0x4E, 0x4A,
  0x77, 0x5A, 0x80, 0x55, 0xBB, 0xA0, 0x79, 0x99, 0x60, 0x75, 0xE8, 0x80,
  0x79, 0x99, 0x60, 0x65, 0x6A, 0xA0, 0x68, 0x62, 0xE0, 0xEA, 0x48, 0x19,
  0x99, 0xE0, 0x37, 0x68, 0x0D, 0xBA, 0xA0, 0x56, 0x46, 0xA0, 0x3A, 0x48,
  0x72, 0x44, 0xE0, 0x5A, 0xA8, 0x78, 0x56, 0xA8, 0x58, 0xC0, 0x80, 0x66,
  0xF0, 0x4E, 0xDE, 0x76, 0x70, 0x2E, 0xDE, 0x77, 0x70, 0x59, 0x48, 0x56,
  0xD4, 0x4E, 0xDA, 0x4A, 0x80, 0x01, 0x24, 0x80, 0x55, 0x6A, 0x5A, 0x80,
  0x7D, 0x6B, 0x50, 0x76, 0xD0, 0x76, 0xF0, 0x76, 0xF8, 0x56, 0xD2, 0x6A,
  0x71, 0xE0, 0x76, 0x80, 0x16, 0xF0, 0xB7, 0x20, 0xA5, 0x9C, 0x00, 0x29,
  0x60, 0xB5, 0x28, 0x00, 0x69, 0x60, 0x56, 0xA0, 0x1A, 0xA0, 0x56, 0xA0,
  0x5A,
};

const GFXglyph RobotoCondensed_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 1, 1, 2, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 7, 3, 0, -6 },
  { 10, 3, 5, 4, 1, -5 },
  { 12, 3, 5, 4, 0, -5 },
  { 14, 1, 1, 1, 0, -5 },
  { 15, 2, 8, 2, 0, -6 },
  { 17, 2, 8, 2, 0, -6 },
  { 19, 3, 3, 3, 0, -5 },
  { 21, 3, 4, 3, 0, -4 },
  { 23, 1, 2, 1, 0, -1 },
  { 24, 2, 1, 2, 0, -3 },
  { 25, 1, 1, 2, 0, -1 },
  { 26, 3, 5, 3, 0, -5 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 2, 5, 3, 1, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 4, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 2, 5, 3, 1, -5 },
  { 49, 1, 4, 2, 0, -4 },
  { 50, 1, 5, 1, 0, -4 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 3, 2, 3, 0, -3 },
  { 54, 3, 3, 3, 0, -4 },
  { 56, 2, 5, 3, 1, -5 },
  { 58, 5, 7, 5, 0, -5 },
  { 63, 3, 5, 4, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 3, 0, -5 },
  { 77, 4, 5, 3, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 2, 5, 2, 0, -5 },
  { 88, 3, 5, 3, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 3, 5, 3, 0, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 6, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 3, 5, 4, 1, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 3, 5, 4, 1, -5 },
  { 124, 4, 5, 5, 1, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 3, 5, 4, 1, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 2, 7, 2, 0, -6 },
  { 137, 1, 5, 3, 1, -5 },
  { 138, 2, 7, 2, 0, -6 },
  { 140, 2, 3, 3, 0, -5 },
  { 141, 2, 1, 3, 0, 0 },
  { 142, 1, 1, 2, 1, -5 },
  { 143, 3, 4, 3, 0, -4 },
  { 145, 3, 5, 3, 0, -5 },
  { 147, 3, 4, 3, 0, -4 },
  { 149, 3, 5, 3, 0, -5 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 3, 5, 2, 0, -5 },
  { 155, 3, 5, 3, 0, -4 },
  { 157, 3, 5, 3, 0, -5 },
  { 159, 2, 5, 2, 0, -5 },
  { 161, 3, 7, 2, -1, -5 },
  { 164, 3, 5, 3, 0, -5 },
  { 166, 2, 5, 2, 0, -5 },
  { 168, 5, 4, 5, 0, -4 },
  { 171, 3, 4, 3, 0, -4 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 3, 5, 3, 0, -4 },
  { 177, 3, 5, 3, 0, -4 },
  { 179, 2, 4, 2, 0, -4 },
  { 180, 3, 4, 3, 0, -4 },
  { 182, 2, 5, 2, 0, -5 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 5, 4, 4, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 3, 6, 3, 0, -4 },
  { 196, 3, 4, 3, 0, -4 },
  { 198, 2, 6, 2, 0, -5 },
  { 200, 2, 6, 2, 0, -5 },
  { 202, 2, 6, 2, 0, -5 },
  { 204, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_Italic7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_ITALIC7PT7B_H_
