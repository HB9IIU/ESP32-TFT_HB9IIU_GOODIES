#ifndef _ROBOTOCONDENSED_ITALIC32PT7B_H_
#define _ROBOTOCONDENSED_ITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x67, 0x66,
  0x66, 0x66, 0x66, 0x46, 0xCC, 0xCC, 0x00, 0x63, 0x00, 0xC3, 0x00, 0xC6,
  0x00, 0xC6, 0x01, 0xC6, 0x01, 0x8C, 0x01, 0x8C, 0x1F, 0xFF, 0x1F, 0xFF,
  0x03, 0x18, 0x07, 0x18, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x7F, 0xFC,
  0x7F, 0xFC, 0x1C, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x31, 0x80,
  0x31, 0x80, 0x71, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x07,
  0xF0, 0x3F, 0xE1, 0xC3, 0x87, 0x06, 0x18, 0x1C, 0x60, 0x71, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xC7, 0x0E, 0x1F, 0xF8, 0x3F, 0xC0,
  0x7C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0x9C,
  0x06, 0x18, 0x6C, 0x31, 0x98, 0x67, 0x30, 0xCC, 0x63, 0xB0, 0xC6, 0xE0,
  0xF9, 0x80, 0xE6, 0x00, 0x18, 0x00, 0x37, 0x80, 0xDF, 0x83, 0x73, 0x0E,
  0xC2, 0x19, 0x86, 0x63, 0x0D, 0xC6, 0x33, 0x0C, 0x64, 0x18, 0xC0, 0x3F,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3D, 0xC0, 0x71, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x1C, 0x0E, 0x38, 0x0F, 0xE0, 0x1F, 0x80, 0x1C, 0x00,
  0xF8, 0x03, 0xF8, 0xCF, 0x71, 0x9C, 0x73, 0x70, 0xEE, 0xE0, 0xF9, 0xC1,
  0xF3, 0x81, 0xC7, 0x03, 0x87, 0x9F, 0x87, 0xFF, 0x07, 0xC7, 0x00, 0x6F,
  0xED, 0xB0, 0x00, 0x80, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x70, 0x10, 0x00, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0x40, 0x00, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0xE6, 0x7F, 0xFF, 0x3F, 0xE0, 0xE0, 0x1F, 0x03,
  0xB0, 0x73, 0x8E, 0x18, 0x01, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1F, 0xFF, 0x7F, 0xFB, 0xFF, 0xE0,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x63, 0x8E, 0x39, 0xCE, 0x10, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x07, 0xC0, 0xFE,
  0x1C, 0xF3, 0x87, 0x30, 0x37, 0x03, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x0E,
  0xC0, 0xCE, 0x1C, 0xF3, 0x87, 0xF0, 0x3E, 0x00, 0x03, 0x0F, 0x3F, 0xFE,
  0xE6, 0x8E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x01, 0xF0, 0x0F, 0xF0, 0x3C,
  0xF0, 0x70, 0xE1, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFF,
  0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x9E, 0x38, 0x73, 0x83, 0x9C,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x81, 0xF0, 0x1F, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xC7,
  0xBC, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0x60, 0x1F, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0xE0, 0xE3,
  0x03, 0x0C, 0x1C, 0x70, 0xE1, 0xC3, 0x07, 0x1C, 0x1C, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x0F, 0xF8,
  0x3F, 0xE1, 0xFF, 0x87, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x37, 0x80, 0xFF, 0x07, 0xFE, 0x0C, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x73, 0x01, 0x8C, 0x0E, 0x38, 0x78, 0xF3, 0xC1, 0xFE,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xC1, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x77, 0x87, 0xFC, 0xFD, 0xEF, 0x0E, 0xE0, 0x6E, 0x07,
  0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0x73, 0xC7, 0xF8,
  0x1E, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xF7,
  0x87, 0x0E, 0x1C, 0x18, 0x60, 0x63, 0x81, 0x86, 0x0E, 0x1C, 0x38, 0x73,
  0xC0, 0xFE, 0x07, 0xF0, 0x38, 0xE1, 0xC1, 0xC6, 0x07, 0x38, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x18, 0x38, 0x79, 0xC0, 0xFF, 0x01, 0xF0, 0x00,
  0x07, 0x81, 0xFE, 0x3C, 0xE3, 0x87, 0x70, 0x77, 0x07, 0x60, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0F, 0x7B, 0xE3, 0xF6, 0x1E, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x3F, 0x07, 0xE0, 0x70, 0x00, 0x00,
  0xE3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x38, 0xE3,
  0x80, 0x02, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x60,
  0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x04, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xEF, 0xFC,
  0x20, 0x03, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x0F,
  0x03, 0xE0, 0xF8, 0x7E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x0F, 0xE7,
  0xFF, 0x87, 0xE1, 0xF0, 0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38,
  0x06, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1E, 0x0E, 0x00, 0xE0,
  0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x0F, 0x82,
  0x38, 0x7F, 0x08, 0xC3, 0x8C, 0x23, 0x0C, 0x30, 0x98, 0x61, 0xC2, 0x61,
  0x86, 0x19, 0x8E, 0x18, 0x6E, 0x30, 0x61, 0xB0, 0xC3, 0x86, 0xC3, 0x0C,
  0x1B, 0x0C, 0x30, 0xCC, 0x31, 0xC3, 0x30, 0xEF, 0x18, 0xC3, 0xEF, 0xC3,
  0x07, 0x1E, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x81, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x03,
  0xB0, 0x03, 0x98, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0,
  0x70, 0x60, 0x30, 0x30, 0x38, 0x18, 0x1F, 0xFE, 0x1F, 0xFF, 0x0C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x1B, 0x80, 0x0E, 0x0F,
  0xF0, 0x3F, 0xF8, 0x70, 0xF0, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC6, 0x03,
  0x9C, 0x07, 0x38, 0x1C, 0x70, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0x03, 0x8E,
  0x03, 0x1C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x33, 0x80, 0xE7, 0x03,
  0xCE, 0x1F, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3E,
  0xF0, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x0E, 0xE0, 0x19, 0xC0, 0x73, 0x80, 0xE7, 0x83, 0x87, 0xDE, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x1C, 0x7C, 0x1C, 0x1E, 0x1C,
  0x0E, 0x1C, 0x06, 0x18, 0x06, 0x38, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38,
  0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70,
  0x1C, 0x60, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE3, 0xF0, 0xFF, 0xC0, 0xFF,
  0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xC1, 0xFF, 0x83,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F,
  0xFC, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7D, 0xF0, 0xE0,
  0x73, 0x80, 0xE6, 0x01, 0xDC, 0x01, 0xB8, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x0F, 0xDC, 0x3F, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0xE3, 0x81, 0xC7, 0xDF, 0x87, 0xFE, 0x07, 0xF0,
  0x00, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01,
  0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x18, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x0E, 0x01, 0xC0, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0C,
  0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xC3, 0x87, 0x07, 0xBE, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0x0C, 0x03,
  0x87, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x78, 0x1C, 0x3C, 0x07, 0x1E, 0x01,
  0x87, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x1F, 0x70, 0x07, 0x9C, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x18, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0E,
  0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xB0, 0x0D, 0x8E, 0xC0, 0x7E, 0x3B,
  0x01, 0xB8, 0xEE, 0x0E, 0xE3, 0xB8, 0x33, 0x8C, 0xE1, 0xCC, 0x33, 0x86,
  0x71, 0xC6, 0x39, 0xC7, 0x18, 0xC7, 0x1C, 0x67, 0x1C, 0x71, 0x98, 0x71,
  0xC7, 0xE1, 0x86, 0x1F, 0x0E, 0x38, 0x3C, 0x38, 0xE0, 0xE0, 0xE3, 0x83,
  0x83, 0x8E, 0x0C, 0x0E, 0x00, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x1C,
  0x7C, 0x07, 0x1F, 0x01, 0x87, 0xC0, 0xE1, 0xB8, 0x38, 0xEE, 0x0E, 0x39,
  0x83, 0x8E, 0x70, 0xE3, 0x9C, 0x30, 0xE3, 0x1C, 0x30, 0xE7, 0x1C, 0x39,
  0xC7, 0x06, 0x71, 0xC1, 0xDC, 0x70, 0x76, 0x1C, 0x0F, 0x8E, 0x03, 0xE3,
  0x80, 0xF8, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x03, 0xF0, 0x07,
  0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x70, 0x06, 0x70,
  0x07, 0x70, 0x06, 0x60, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70,
  0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x1C,
  0x3E, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0,
  0x73, 0x80, 0xE6, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x60, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0x60, 0x0E, 0xC0,
  0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x83, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x80, 0x0F, 0xF0, 0x3F, 0xF8,
  0x70, 0xF0, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC7, 0xC3, 0xFF, 0x0F, 0xFC, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x70, 0xE0, 0xE1, 0x81, 0xC7, 0x01, 0x8E, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0xF1,
  0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0xE0, 0x39,
  0xC0, 0x73, 0x80, 0xE7, 0x83, 0x87, 0xDF, 0x07, 0xFC, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x0E, 0x38, 0x06, 0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x30, 0xC0, 0x38, 0xE0, 0x1C, 0x30, 0x0E, 0x1C, 0x0E,
  0x0E, 0x07, 0x07, 0xDF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x38, 0x60, 0x38, 0x70,
  0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x70, 0xE0, 0x31, 0xC0, 0x31,
  0xC0, 0x31, 0x80, 0x3B, 0x80, 0x3B, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x30, 0x1F, 0x81, 0xC0,
  0x6E, 0x07, 0x03, 0xB8, 0x1C, 0x0E, 0xE0, 0xF8, 0x33, 0x83, 0xE1, 0xCE,
  0x1F, 0x87, 0x38, 0x7E, 0x18, 0x61, 0x98, 0xE1, 0x8E, 0x63, 0x86, 0x31,
  0x8C, 0x18, 0xC6, 0x70, 0x67, 0x19, 0xC1, 0x98, 0x66, 0x06, 0xE1, 0xB8,
  0x1B, 0x06, 0xE0, 0x6C, 0x1B, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x1E,
  0x07, 0x80, 0x78, 0x1E, 0x01, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0x00, 0x0F,
  0x01, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x70, 0x07,
  0x1E, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEE, 0x00, 0x3D,
  0xC0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x0E, 0x03, 0xC0,
  0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0xF3,
  0x81, 0xC7, 0x07, 0x0E, 0x0E, 0x0C, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0x73,
  0x00, 0x6E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0xE3, 0xFF, 0xE0, 0x07, 0xC3, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x3E, 0x0F, 0x80, 0xE3, 0x86, 0x18, 0x61, 0x86, 0x1C,
  0x71, 0xC3, 0x0C, 0x30, 0xC3, 0x8E, 0x38, 0x61, 0x86, 0x18, 0x71, 0xC7,
  0x0C, 0x07, 0xC1, 0xF0, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x3F, 0x0F, 0x80, 0x03, 0x01, 0xC0, 0x70, 0x3E, 0x0D, 0x87, 0x61,
  0x98, 0xE6, 0x31, 0x9C, 0x76, 0x1C, 0x7F, 0xFF, 0xFF, 0x80, 0x71, 0xC3,
  0x8E, 0x18, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x30, 0x70, 0x07, 0x00,
  0x70, 0xFF, 0x3F, 0xF7, 0x86, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1E, 0xFF,
  0xE7, 0xFE, 0x3C, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x7C, 0x1F, 0xF8, 0x7D, 0xE1, 0xC1, 0xC6,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x30, 0x1D, 0xC0, 0x67,
  0x03, 0x9C, 0x0E, 0x78, 0x71, 0xB3, 0xC6, 0xFE, 0x39, 0xF0, 0x07, 0xC0,
  0xFF, 0x0F, 0x3C, 0x70, 0x67, 0x03, 0x38, 0x1D, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0xCE, 0x0E, 0x70, 0x71, 0xC7, 0x07, 0xF0,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x07, 0xCE, 0x1F, 0xD8, 0x7D, 0xF0, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0x8C, 0x06, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x0E, 0x0E, 0x0F, 0x7C, 0x1F, 0xF8, 0x1F, 0x70, 0x07,
  0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70, 0x37, 0x03, 0x60, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x04, 0x79, 0xE3, 0xFC, 0x1F,
  0x00, 0x03, 0xC1, 0xF0, 0xF4, 0x70, 0x1C, 0x07, 0x01, 0x83, 0xFC, 0xFF,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x07, 0xCE, 0x1F, 0xD8, 0x79,
  0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8C, 0x07, 0x38, 0x0C, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x0F, 0x7C, 0x1F,
  0xF8, 0x1F, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x04, 0x0E, 0x1E, 0x78,
  0x1F, 0xE0, 0x1F, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0xBC, 0x1F, 0xF8, 0xFB, 0xC7, 0x0E, 0x30, 0x33,
  0x81, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x81, 0xDC, 0x0C, 0xE0,
  0xE7, 0x07, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0x1C, 0x71, 0xC0, 0x00, 0x03,
  0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8C,
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC2, 0xE0,
  0xF8, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x07, 0x1C, 0x38, 0x71, 0xC1, 0x8E, 0x06, 0x70,
  0x3B, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xEE, 0x07, 0x1C,
  0x1C, 0x70, 0x70, 0xE1, 0xC3, 0x86, 0x0E, 0x38, 0x1C, 0x0C, 0x71, 0xC7,
  0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8C, 0x31, 0xC7, 0x1C, 0x71, 0x86, 0x38,
  0xE3, 0x8E, 0x30, 0x1D, 0xE1, 0xF0, 0x7F, 0xCF, 0xE1, 0xE7, 0xF7, 0x87,
  0x0F, 0x07, 0x18, 0x1C, 0x1C, 0xE0, 0x60, 0x73, 0x83, 0x81, 0xCE, 0x0E,
  0x06, 0x38, 0x38, 0x38, 0xC0, 0xE0, 0xE3, 0x03, 0x83, 0x9C, 0x0C, 0x0E,
  0x70, 0x70, 0x31, 0xC1, 0xC0, 0xC7, 0x07, 0x07, 0x18, 0x1C, 0x1C, 0xE0,
  0x70, 0x70, 0x1D, 0xF0, 0xFF, 0xC7, 0xDE, 0x38, 0x71, 0x81, 0x9C, 0x0C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x67, 0x07, 0x38,
  0x39, 0xC1, 0xCC, 0x0E, 0xE0, 0x60, 0x07, 0xC0, 0xFF, 0x87, 0xBC, 0x70,
  0x77, 0x03, 0xB8, 0x1D, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x6E, 0x07, 0x30, 0x71, 0xE7, 0x87, 0xF8, 0x1F, 0x00, 0x0E, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF0, 0x70, 0x70, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x30, 0x1C, 0x60, 0x31, 0xC0, 0xE3, 0x81, 0xC7, 0x07,
  0x0F, 0x9E, 0x1B, 0xF8, 0x73, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0x9C, 0x7F, 0x63, 0xCF,
  0x8E, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x03, 0xB8, 0x0C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x83, 0x87, 0x9E, 0x1F, 0xF8, 0x3E,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x1D, 0xC7, 0xF1, 0xFC, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x07,
  0x81, 0xFE, 0x3F, 0xE3, 0x87, 0x30, 0x73, 0x00, 0x38, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0E, 0xC0, 0xEE, 0x0E, 0xFB, 0xC7, 0xF8, 0x3F,
  0x00, 0x0C, 0x0C, 0x1C, 0x1C, 0x7F, 0xFF, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x7C, 0x7C, 0x3C, 0x38, 0x19,
  0xC1, 0xCE, 0x0E, 0x60, 0x73, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x03, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0x71, 0xEF, 0x8F, 0xFC,
  0x3E, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0x61, 0xC6, 0x18, 0x63,
  0x86, 0x30, 0x67, 0x07, 0x70, 0x76, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x30, 0x00, 0xE0, 0xC0, 0xFC, 0x1C, 0x3B, 0x87, 0x87, 0x70,
  0xF0, 0xCE, 0x3E, 0x39, 0xC6, 0xC7, 0x19, 0xD8, 0xC3, 0x33, 0x38, 0x66,
  0x66, 0x0D, 0xCD, 0xC1, 0xB1, 0xB0, 0x3E, 0x36, 0x07, 0x87, 0xC0, 0xF0,
  0xF0, 0x1C, 0x1E, 0x03, 0x81, 0x80, 0x70, 0x30, 0x00, 0x1C, 0x1E, 0x1C,
  0x38, 0x38, 0xE0, 0x71, 0xC0, 0x67, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x76, 0x01, 0xCE, 0x03, 0x9C, 0x0E,
  0x18, 0x38, 0x38, 0x70, 0x70, 0x1C, 0x0C, 0x38, 0x38, 0x70, 0x70, 0xE1,
  0xC1, 0xC3, 0x81, 0x8E, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x07,
  0x83, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x80, 0x0C, 0x31, 0xC6,
  0x18, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18,
  0x63, 0x8E, 0x30, 0xC3, 0x0C, 0x00, 0x08, 0x03, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x07, 0x83, 0xC0, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x08, 0x00, 0x3C, 0x06, 0xFE,
  0x1B, 0xFC, 0x36, 0x1F, 0xEC, 0x1F, 0x80, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 23, 8, 1, -23 },
  { 22, 8, 8, 10, 3, -24 },
  { 30, 16, 23, 17, 1, -23 },
  { 76, 14, 29, 15, 1, -26 },
  { 127, 15, 23, 20, 3, -23 },
  { 171, 15, 23, 17, 1, -23 },
  { 215, 3, 7, 5, 3, -24 },
  { 218, 9, 33, 10, 2, -26 },
  { 256, 10, 33, 10, -2, -26 },
  { 298, 12, 13, 13, 2, -23 },
  { 318, 14, 17, 15, 1, -19 },
  { 348, 6, 8, 6, -2, -3 },
  { 354, 6, 2, 8, 1, -10 },
  { 356, 3, 4, 8, 1, -4 },
  { 358, 15, 25, 12, -2, -23 },
  { 405, 12, 23, 15, 2, -23 },
  { 440, 8, 23, 15, 4, -23 },
  { 463, 15, 23, 15, 0, -23 },
  { 507, 13, 23, 15, 1, -23 },
  { 545, 14, 23, 15, 0, -23 },
  { 586, 14, 23, 15, 2, -23 },
  { 627, 12, 23, 15, 2, -23 },
  { 662, 14, 23, 15, 2, -23 },
  { 703, 14, 23, 15, 1, -23 },
  { 744, 12, 23, 15, 2, -23 },
  { 779, 6, 18, 7, 1, -18 },
  { 793, 8, 23, 6, -2, -18 },
  { 816, 12, 14, 14, 1, -17 },
  { 837, 12, 10, 15, 2, -16 },
  { 852, 12, 14, 14, 1, -17 },
  { 873, 10, 23, 13, 3, -23 },
  { 902, 22, 29, 24, 1, -22 },
  { 982, 17, 23, 18, -1, -23 },
  { 1031, 15, 23, 17, 1, -23 },
  { 1075, 15, 23, 18, 2, -23 },
  { 1119, 16, 23, 18, 1, -23 },
  { 1165, 15, 23, 15, 1, -23 },
  { 1209, 15, 23, 15, 1, -23 },
  { 1253, 15, 23, 18, 2, -23 },
  { 1297, 18, 23, 19, 1, -23 },
  { 1349, 7, 23, 8, 1, -23 },
  { 1370, 15, 23, 15, 0, -23 },
  { 1414, 18, 23, 17, 1, -23 },
  { 1466, 12, 23, 15, 1, -23 },
  { 1501, 22, 23, 23, 1, -23 },
  { 1565, 18, 23, 19, 1, -23 },
  { 1617, 16, 23, 19, 2, -23 },
  { 1663, 16, 23, 17, 1, -23 },
  { 1709, 15, 27, 19, 2, -23 },
  { 1760, 15, 23, 16, 1, -23 },
  { 1804, 15, 23, 16, 1, -23 },
  { 1848, 15, 23, 16, 3, -23 },
  { 1892, 17, 23, 17, 1, -23 },
  { 1941, 16, 23, 17, 3, -23 },
  { 1987, 22, 23, 24, 3, -23 },
  { 2051, 19, 23, 17, -1, -23 },
  { 2106, 15, 23, 16, 3, -23 },
  { 2150, 17, 23, 16, 0, -23 },
  { 2199, 10, 31, 8, 0, -26 },
  { 2238, 6, 25, 11, 3, -23 },
  { 2257, 10, 31, 8, -2, -26 },
  { 2296, 10, 11, 12, 1, -23 },
  { 2310, 13, 2, 13, -2, 0 },
  { 2314, 6, 5, 10, 3, -24 },
  { 2318, 12, 17, 15, 1, -17 },
  { 2344, 14, 24, 15, 0, -24 },
  { 2386, 13, 17, 14, 1, -17 },
  { 2414, 15, 24, 15, 1, -24 },
  { 2459, 12, 17, 15, 1, -17 },
  { 2485, 10, 24, 10, 2, -24 },
  { 2515, 15, 24, 15, 0, -17 },
  { 2560, 13, 24, 15, 0, -24 },
  { 2599, 6, 23, 7, 1, -23 },
  { 2617, 10, 30, 7, -3, -23 },
  { 2655, 14, 24, 14, 0, -24 },
  { 2697, 6, 24, 7, 1, -24 },
  { 2715, 22, 17, 23, 0, -17 },
  { 2762, 13, 17, 15, 0, -17 },
  { 2790, 13, 17, 16, 1, -17 },
  { 2818, 15, 24, 15, -1, -17 },
  { 2863, 14, 24, 16, 1, -17 },
  { 2905, 10, 17, 9, 0, -17 },
  { 2927, 12, 17, 14, 1, -17 },
  { 2953, 8, 21, 9, 1, -21 },
  { 2974, 13, 17, 15, 1, -17 },
  { 3002, 12, 17, 13, 2, -17 },
  { 3028, 19, 17, 20, 2, -17 },
  { 3069, 15, 17, 14, -1, -17 },
  { 3101, 15, 24, 13, -1, -17 },
  { 3146, 13, 17, 14, 0, -17 },
  { 3174, 10, 31, 10, 1, -25 },
  { 3213, 6, 27, 8, 1, -23 },
  { 3234, 10, 31, 10, -1, -25 },
  { 3273, 15, 6, 18, 2, -12 },
};

const GFXfont RobotoCondensed_Italic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_ITALIC32PT7B_H_
