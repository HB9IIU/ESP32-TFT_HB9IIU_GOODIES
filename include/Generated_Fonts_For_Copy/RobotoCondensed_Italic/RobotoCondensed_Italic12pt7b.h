#ifndef _ROBOTOCONDENSED_ITALIC12PT7B_H_
#define _ROBOTOCONDENSED_ITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0xC0, 0xB6, 0x80, 0x28, 0xAF, 0x94, 0x51, 0x4F,
  0xA8, 0xA0, 0x11, 0xCA, 0x96, 0x18, 0x31, 0x4B, 0x88, 0x62, 0xAA, 0xBC,
  0x20, 0xE5, 0x65, 0x18, 0x38, 0xA2, 0x8C, 0x21, 0x59, 0xB2, 0x78, 0xE0,
  0x25, 0x49, 0x24, 0x92, 0x44, 0x21, 0x11, 0x11, 0x11, 0x22, 0x24, 0x80,
  0x22, 0xF6, 0xA0, 0x10, 0x9E, 0x42, 0x10, 0x58, 0xE0, 0xC0, 0x04, 0x20,
  0x84, 0x10, 0x82, 0x10, 0x41, 0x00, 0x7D, 0x99, 0x99, 0x9B, 0xE0, 0x26,
  0x22, 0x22, 0x44, 0x40, 0x3A, 0x52, 0x11, 0x88, 0x88, 0xF8, 0x3A, 0x42,
  0x13, 0x04, 0x33, 0x70, 0x08, 0xC6, 0x54, 0xAB, 0xE2, 0x10, 0x7A, 0x11,
  0xE1, 0x08, 0x52, 0xE0, 0x34, 0x8F, 0x99, 0x99, 0xE0, 0xF8, 0xC4, 0x62,
  0x31, 0x18, 0x80, 0x39, 0x52, 0x93, 0x26, 0x29, 0x70, 0x79, 0x99, 0x9F,
  0x12, 0xC0, 0x40, 0x30, 0x20, 0x00, 0x96, 0x09, 0xB0, 0xC1, 0x00, 0xF0,
  0x0F, 0x41, 0x82, 0xE8, 0x00, 0x69, 0x13, 0x24, 0x40, 0x80, 0x1E, 0x21,
  0x21, 0x4D, 0x55, 0x95, 0xA5, 0x9E, 0x80, 0x40, 0x38, 0x08, 0x61, 0x8A,
  0x29, 0x27, 0xE1, 0x84, 0x38, 0x94, 0x51, 0x79, 0x24, 0x92, 0xF0, 0x39,
  0x28, 0xA0, 0x82, 0x08, 0xA4, 0x70, 0x38, 0x94, 0x51, 0x45, 0x14, 0x52,
  0xF0, 0x3C, 0x84, 0x10, 0x79, 0x04, 0x10, 0xF8, 0x3C, 0x84, 0x10, 0x79,
  0x04, 0x10, 0x80, 0x39, 0x28, 0xE0, 0x9A, 0x28, 0xA2, 0x70, 0x22, 0x45,
  0x0A, 0x17, 0xC8, 0x91, 0x22, 0x84, 0x25, 0x24, 0x92, 0x80, 0x04, 0x20,
  0x82, 0x08, 0x20, 0xA4, 0x70, 0x26, 0x59, 0x22, 0x87, 0x0A, 0x12, 0x24,
  0x88, 0x21, 0x10, 0x84, 0x21, 0x08, 0xF8, 0x21, 0x90, 0xD8, 0xCA, 0x65,
  0x52, 0xA9, 0x64, 0xB6, 0x92, 0x00, 0x22, 0x45, 0x4A, 0x95, 0x49, 0x93,
  0x26, 0x84, 0x39, 0x28, 0x61, 0x8A, 0x28, 0xA6, 0x70, 0x3C, 0x94, 0x51,
  0x79, 0x04, 0x10, 0x80, 0x39, 0x28, 0xE2, 0x8A, 0x28, 0xA6, 0x70, 0x60,
  0x38, 0x94, 0x51, 0x79, 0x24, 0x92, 0x88, 0x39, 0x94, 0x58, 0x30, 0x28,
  0x92, 0x70, 0xFC, 0x82, 0x08, 0x21, 0x84, 0x10, 0x40, 0x22, 0x89, 0x12,
  0x24, 0x48, 0x91, 0x24, 0x70, 0x86, 0x28, 0x96, 0x51, 0x46, 0x18, 0x40,
  0x89, 0x99, 0x99, 0x9A, 0xAA, 0xAA, 0xCC, 0xCC, 0xCC, 0x64, 0x48, 0xA1,
  0xC1, 0x06, 0x1A, 0x24, 0x88, 0x8F, 0x25, 0x14, 0x61, 0x84, 0x10, 0x40,
  0x7C, 0x10, 0x84, 0x10, 0x84, 0x30, 0xF8, 0x32, 0x44, 0x44, 0x44, 0x88,
  0x8C, 0xA9, 0x55, 0x50, 0x31, 0x13, 0x22, 0x22, 0x22, 0x4C, 0x23, 0x55,
  0xF8, 0x50, 0x32, 0x42, 0xFC, 0xC9, 0xC0, 0x22, 0x1E, 0x94, 0xA5, 0x39,
  0xB0, 0x3A, 0x51, 0x88, 0x25, 0xC0, 0x04, 0x13, 0xD2, 0x4A, 0x28, 0x92,
  0x70, 0x32, 0x53, 0xF8, 0x21, 0xC0, 0x24, 0xE4, 0x88, 0x88, 0x80, 0x3A,
  0x53, 0x18, 0xA5, 0xD2, 0xE0, 0x22, 0x1E, 0x94, 0xA5, 0x33, 0x90, 0x21,
  0x24, 0x94, 0x80, 0x30, 0x22, 0x22, 0x24, 0x44, 0xC0, 0x22, 0x12, 0xA6,
  0x31, 0xD2, 0x90, 0x25, 0x24, 0x94, 0x80, 0x7F, 0x49, 0x49, 0x49, 0x49,
  0x99, 0x92, 0x7A, 0x52, 0x94, 0xCE, 0x40, 0x3A, 0x53, 0x18, 0xA5, 0xC0,
  0x7A, 0x52, 0x98, 0xE6, 0xD0, 0x80, 0x3A, 0x53, 0x18, 0xA5, 0xC2, 0x10,
  0x74, 0x44, 0x48, 0x80, 0x32, 0x50, 0x61, 0x49, 0xC0, 0x26, 0x44, 0x44,
  0x44, 0x4A, 0x52, 0x94, 0xAD, 0xC0, 0x99, 0xAA, 0xCC, 0x40, 0x93, 0x6A,
  0xD6, 0xAD, 0x9B, 0x24, 0x00, 0x4A, 0x8C, 0x46, 0x2A, 0x40, 0x24, 0xA2,
  0x8A, 0x30, 0xC2, 0x08, 0x40, 0x78, 0x84, 0x44, 0x23, 0xC0, 0x12, 0x22,
  0x6C, 0x44, 0x44, 0x40, 0x29, 0x24, 0x92, 0x92, 0x00, 0x21, 0x11, 0x21,
  0x22, 0x24, 0xC0, 0xED, 0xC0,
};

const GFXglyph RobotoCondensed_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 1, -9 },
  { 14, 5, 11, 6, 0, -10 },
  { 21, 6, 9, 7, 1, -9 },
  { 28, 6, 9, 6, 0, -9 },
  { 35, 1, 3, 2, 1, -9 },
  { 36, 3, 13, 4, 1, -10 },
  { 41, 4, 13, 4, -1, -10 },
  { 48, 4, 5, 5, 1, -9 },
  { 51, 5, 6, 6, 0, -7 },
  { 55, 2, 3, 2, -1, -1 },
  { 56, 3, 1, 3, 0, -4 },
  { 57, 2, 1, 3, 0, -1 },
  { 58, 6, 10, 4, -1, -9 },
  { 66, 4, 9, 6, 1, -9 },
  { 71, 4, 9, 6, 1, -9 },
  { 76, 5, 9, 6, 0, -9 },
  { 82, 5, 9, 6, 0, -9 },
  { 88, 5, 9, 6, 0, -9 },
  { 94, 5, 9, 6, 1, -9 },
  { 100, 4, 9, 6, 1, -9 },
  { 105, 5, 9, 6, 1, -9 },
  { 111, 5, 9, 6, 0, -9 },
  { 117, 4, 9, 6, 1, -9 },
  { 122, 2, 6, 3, 0, -6 },
  { 124, 3, 8, 2, -1, -6 },
  { 127, 5, 5, 5, 0, -6 },
  { 131, 4, 4, 6, 1, -6 },
  { 133, 5, 5, 5, 0, -6 },
  { 137, 4, 9, 5, 1, -9 },
  { 142, 8, 11, 9, 0, -8 },
  { 153, 6, 9, 7, 0, -9 },
  { 160, 6, 9, 6, 0, -9 },
  { 167, 6, 9, 7, 1, -9 },
  { 174, 6, 9, 7, 0, -9 },
  { 181, 6, 9, 6, 0, -9 },
  { 188, 6, 9, 6, 0, -9 },
  { 195, 6, 9, 7, 1, -9 },
  { 202, 7, 9, 7, 0, -9 },
  { 210, 3, 9, 3, 0, -9 },
  { 214, 6, 9, 6, 0, -9 },
  { 221, 7, 9, 6, 0, -9 },
  { 229, 5, 9, 6, 0, -9 },
  { 235, 9, 9, 9, 0, -9 },
  { 246, 7, 9, 7, 0, -9 },
  { 254, 6, 9, 7, 1, -9 },
  { 261, 6, 9, 6, 0, -9 },
  { 268, 6, 10, 7, 1, -9 },
  { 276, 6, 9, 6, 0, -9 },
  { 283, 6, 9, 6, 0, -9 },
  { 290, 6, 9, 6, 1, -9 },
  { 297, 7, 9, 7, 0, -9 },
  { 305, 6, 9, 7, 1, -9 },
  { 312, 8, 9, 9, 1, -9 },
  { 321, 7, 9, 6, 0, -9 },
  { 329, 6, 9, 6, 1, -9 },
  { 336, 6, 9, 6, 0, -9 },
  { 343, 4, 12, 3, 0, -10 },
  { 349, 2, 10, 4, 1, -9 },
  { 352, 4, 12, 3, -1, -10 },
  { 358, 4, 4, 4, 0, -9 },
  { 360, 5, 1, 5, -1, 0 },
  { 361, 2, 2, 4, 1, -9 },
  { 362, 5, 7, 6, 0, -7 },
  { 367, 5, 9, 6, 0, -9 },
  { 373, 5, 7, 5, 0, -7 },
  { 378, 6, 9, 6, 0, -9 },
  { 385, 5, 7, 5, 0, -7 },
  { 390, 4, 9, 4, 1, -9 },
  { 395, 5, 9, 6, 0, -7 },
  { 401, 5, 9, 6, 0, -9 },
  { 407, 3, 9, 3, 0, -9 },
  { 411, 4, 11, 3, -1, -9 },
  { 417, 5, 9, 5, 0, -9 },
  { 423, 3, 9, 3, 0, -9 },
  { 427, 8, 7, 9, 0, -7 },
  { 434, 5, 7, 6, 0, -7 },
  { 439, 5, 7, 6, 0, -7 },
  { 444, 5, 9, 6, 0, -7 },
  { 450, 5, 9, 6, 0, -7 },
  { 456, 4, 7, 4, 0, -7 },
  { 460, 5, 7, 5, 0, -7 },
  { 465, 4, 8, 3, 0, -8 },
  { 469, 5, 7, 6, 0, -7 },
  { 474, 4, 7, 5, 1, -7 },
  { 478, 7, 7, 8, 1, -7 },
  { 485, 5, 7, 5, 0, -7 },
  { 490, 6, 9, 5, -1, -7 },
  { 497, 5, 7, 5, 0, -7 },
  { 502, 4, 11, 4, 0, -9 },
  { 508, 3, 11, 3, 0, -9 },
  { 513, 4, 11, 4, -1, -9 },
  { 519, 5, 2, 7, 1, -4 },
};

const GFXfont RobotoCondensed_Italic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_ITALIC12PT7B_H_
