#ifndef _ROBOTOCONDENSED_ITALIC31PT7B_H_
#define _ROBOTOCONDENSED_ITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x0C, 0x31, 0xC7,
  0x1C, 0x00, 0x00, 0x38, 0xE3, 0x80, 0x66, 0xCD, 0x9B, 0x3C, 0xD9, 0xB3,
  0x00, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x8C, 0x01,
  0x8C, 0x1F, 0xFF, 0x1F, 0xFF, 0x03, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x0C, 0x60, 0x0C, 0x60, 0x7F, 0xFC, 0x7F, 0xF8, 0x18, 0xC0, 0x18,
  0xC0, 0x31, 0x80, 0x31, 0x80, 0x31, 0x80, 0x63, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x07, 0xC0, 0xFF, 0x07, 0xB8, 0x70, 0xE3, 0x07, 0x18, 0x39,
  0xC1, 0xC6, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x06, 0x30, 0x71, 0xEF, 0x87, 0xF8,
  0x1F, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3C, 0x01, 0xF8, 0x06, 0x60,
  0x30, 0xC6, 0xC3, 0x1B, 0x18, 0xCC, 0x66, 0x31, 0xB8, 0x7C, 0xC1, 0xE6,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x70, 0x33, 0xE1, 0xD8, 0xC6, 0x63, 0x33,
  0x0D, 0x8C, 0x36, 0x30, 0xD0, 0x66, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xC0,
  0x1F, 0x80, 0xF7, 0x03, 0x0C, 0x1C, 0x30, 0x70, 0xC1, 0xC7, 0x07, 0x38,
  0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3B, 0x8D, 0xCE, 0x7E, 0x1D,
  0xF8, 0x76, 0xE0, 0xFB, 0x83, 0xCE, 0x07, 0x1C, 0x7C, 0x7F, 0xF8, 0x7C,
  0xE0, 0x6F, 0xED, 0xB0, 0x00, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07,
  0x07, 0x03, 0x01, 0x00, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0xE6, 0x7F,
  0xFF, 0x3F, 0xC0, 0xE0, 0x1F, 0x03, 0xB0, 0x73, 0x8E, 0x18, 0x01, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x81, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x18, 0x63, 0x8E, 0x39, 0xC6, 0x10, 0xFF, 0xF0, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x07, 0xC1, 0xFE, 0x3C, 0xE3, 0x87,
  0x70, 0x77, 0x07, 0x60, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06,
  0xC0, 0x6C, 0x0E, 0xC0, 0xEC, 0x0E, 0xC0, 0xCC, 0x1C, 0xC1, 0xCE, 0x38,
  0x7F, 0x03, 0xE0, 0x03, 0x0E, 0x7E, 0xFE, 0xCE, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30,
  0x70, 0x01, 0xE0, 0x1F, 0xE0, 0xF3, 0x87, 0x07, 0x1C, 0x1C, 0x60, 0x71,
  0x81, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0x07, 0x9C, 0x70, 0x73, 0x83,
  0x98, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x0F, 0x03, 0xF0, 0x1F, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0xE0, 0x67, 0x07, 0x38, 0x38, 0xE7,
  0x87, 0xF8, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xCE, 0x07, 0x30, 0x38, 0xC0, 0xC7, 0x07,
  0x1C, 0x38, 0x70, 0xC1, 0x87, 0x06, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x37, 0x83, 0xFE, 0x1F,
  0xF8, 0x61, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xC0, 0xE6, 0x07,
  0x38, 0x71, 0xE7, 0x87, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0xFC, 0x3E, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0xFC, 0x7F, 0xCF, 0x3B, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1B, 0x87, 0x39, 0xC7, 0xF0,
  0x7C, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x7F, 0x83, 0x9C, 0x38, 0x71,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x18, 0x70, 0xE7, 0x83, 0xF0, 0x3F,
  0x83, 0x8E, 0x38, 0x33, 0x81, 0xDC, 0x0E, 0xE0, 0x67, 0x03, 0x38, 0x38,
  0xE3, 0x87, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xFC, 0x3C, 0xE3, 0x06, 0x70,
  0x66, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xE6, 0x0E, 0x73,
  0xE3, 0xFE, 0x1E, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xF0, 0x7C,
  0x07, 0x00, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x9C,
  0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x0E, 0x18, 0x70, 0xE3, 0x87, 0x0C, 0x00, 0x00, 0x10, 0x06, 0x01, 0xE0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0x80, 0x08, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF7, 0xFE, 0x20, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x70, 0x0F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0xE0, 0x08, 0x00,
  0x1E, 0x1F, 0xEF, 0xBB, 0x87, 0xC1, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x38,
  0x0E, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0x43, 0x07,
  0x83, 0x30, 0x7F, 0x19, 0x87, 0x38, 0xDC, 0x71, 0x86, 0xC3, 0x0C, 0x36,
  0x38, 0x61, 0xB1, 0x87, 0x0F, 0x0C, 0x30, 0x58, 0x61, 0x86, 0xC7, 0x0C,
  0x36, 0x38, 0xE1, 0xB1, 0xC7, 0x19, 0x8E, 0x79, 0x8C, 0x3E, 0xFC, 0x60,
  0xE3, 0x83, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x04, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xCC, 0x01,
  0xCC, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x0E, 0x07, 0x0E, 0x06, 0x0E, 0x0E,
  0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x18, 0x06, 0x38, 0x06, 0x38, 0x07, 0x70,
  0x07, 0x70, 0x07, 0xE0, 0x07, 0x1F, 0xF0, 0x3F, 0xF0, 0x70, 0xF0, 0xE0,
  0xE1, 0xC0, 0xE3, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0xF0,
  0xFF, 0x81, 0xFF, 0x87, 0x03, 0x8E, 0x07, 0x1C, 0x06, 0x38, 0x1C, 0x60,
  0x38, 0xC0, 0x73, 0x81, 0xC7, 0x07, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x7C, 0xF0, 0xE0, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xC3, 0xCF,
  0x03, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x71, 0xF0, 0xE0,
  0xE1, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xC0, 0x39, 0x80, 0x77, 0x00, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60,
  0x38, 0xC0, 0x73, 0x81, 0xC7, 0x1F, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xC1, 0xFF, 0x87, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xC1, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x7C, 0xF1, 0xE0, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x03,
  0xB0, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0xEE, 0x1F, 0xD8,
  0x03, 0xB0, 0x06, 0x60, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xE3, 0xCF,
  0x83, 0xFE, 0x03, 0xF0, 0x00, 0x1C, 0x01, 0x87, 0x00, 0x61, 0xC0, 0x38,
  0x70, 0x0E, 0x18, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x0C, 0x38,
  0x07, 0x0E, 0x01, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x70, 0x06, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xC3,
  0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0x0C, 0x71, 0xC7, 0x1C, 0x61,
  0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x80,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0xE0, 0x71, 0xC0, 0xC1, 0x83, 0x83,
  0xCE, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x1C, 0x07, 0x8E, 0x07, 0x87, 0x07,
  0x83, 0x83, 0x81, 0x83, 0x80, 0xC3, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x3B,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xDC, 0x03, 0xCE, 0x01,
  0xC7, 0x00, 0xE1, 0xC0, 0x60, 0xE0, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x07,
  0x0E, 0x03, 0x87, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x8E, 0xC0, 0xEC, 0x3B, 0x03,
  0xB0, 0xCC, 0x0D, 0xC3, 0x30, 0x77, 0x0C, 0xE1, 0x9C, 0x73, 0x8E, 0x61,
  0xC6, 0x31, 0x87, 0x19, 0xCE, 0x1C, 0x66, 0x38, 0x61, 0xB8, 0xE1, 0x86,
  0xC3, 0x8E, 0x1F, 0x0C, 0x38, 0x78, 0x30, 0xE0, 0xE1, 0xC3, 0x83, 0x07,
  0x00, 0x1C, 0x01, 0x87, 0x80, 0x61, 0xE0, 0x38, 0x78, 0x0E, 0x1F, 0x03,
  0x86, 0xC0, 0xE3, 0xB0, 0x30, 0xEE, 0x0C, 0x39, 0x87, 0x0E, 0x61, 0xC3,
  0x1C, 0x70, 0xC3, 0x1C, 0x70, 0xC6, 0x1C, 0x3B, 0x87, 0x06, 0xE1, 0xC1,
  0xB8, 0x60, 0x7E, 0x18, 0x0F, 0x8E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x1C,
  0x38, 0x07, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7D, 0xF0, 0xE0, 0xE3, 0x80,
  0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x60, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x6E, 0x00, 0xDC, 0x03, 0xB0, 0x07, 0x60, 0x0E, 0xE0, 0x19, 0xC0,
  0x73, 0x81, 0xC3, 0xEF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1C, 0x1E, 0x1C, 0x0E, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38,
  0x06, 0x38, 0x0E, 0x38, 0x1E, 0x30, 0x3C, 0x3F, 0xF8, 0x7F, 0xE0, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7D, 0xF1, 0xE0,
  0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x6E, 0x01, 0xD8, 0x03, 0xB0, 0x07, 0x60, 0x0C, 0xC0,
  0x39, 0xC0, 0x73, 0x81, 0xC3, 0xCF, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x40, 0x1F, 0xF0, 0x3F, 0xF0, 0x70, 0xF0,
  0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70,
  0x38, 0xC1, 0xE1, 0xFF, 0x87, 0xFC, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0x60, 0x70, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x03, 0x9C, 0x07, 0x00,
  0x03, 0xE0, 0x1F, 0xF0, 0x7D, 0xF0, 0xE0, 0xE3, 0x80, 0xC7, 0x01, 0xCE,
  0x03, 0x9C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x60, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xC3,
  0xCF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x1C,
  0x07, 0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38,
  0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70,
  0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0x60, 0x38, 0x70, 0x78, 0x7C,
  0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x00,
  0xEE, 0x03, 0x9C, 0x07, 0x18, 0x1C, 0x30, 0x38, 0x70, 0x60, 0xE1, 0xC1,
  0xC3, 0x83, 0x8E, 0x03, 0x1C, 0x06, 0x70, 0x0C, 0xE0, 0x19, 0x80, 0x37,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0,
  0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0D, 0xC1, 0xE0, 0xEE, 0x0F, 0x07,
  0x70, 0xF8, 0x33, 0x86, 0xC3, 0x9C, 0x36, 0x1C, 0xE3, 0xB0, 0xC7, 0x19,
  0x8E, 0x38, 0xCC, 0x70, 0xCC, 0x63, 0x06, 0x63, 0xB8, 0x37, 0x1D, 0x81,
  0xB0, 0x6C, 0x0D, 0x83, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x1C, 0x03, 0x83,
  0x81, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x33,
  0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07,
  0x0E, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x1C, 0x38, 0x07, 0x00, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0xE3, 0x03, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x38,
  0x18, 0xE0, 0x39, 0x80, 0x77, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0x87, 0xC3, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0F, 0x87, 0xC0, 0xC3,
  0x8E, 0x18, 0x61, 0x86, 0x18, 0x71, 0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x38,
  0xE1, 0x86, 0x18, 0x61, 0xC7, 0x07, 0xC1, 0xF0, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x78, 0x3E, 0x00, 0x03, 0x03, 0x81, 0xC1, 0xE0,
  0xF0, 0xDC, 0x66, 0x63, 0x31, 0xB8, 0xD8, 0x60, 0x7F, 0xF7, 0xFF, 0x73,
  0x8E, 0x30, 0x07, 0xC1, 0xFE, 0x3C, 0xE3, 0x87, 0x30, 0x70, 0x07, 0x00,
  0x70, 0xFE, 0x3F, 0xE7, 0x8E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xF7,
  0xC7, 0xEC, 0x3C, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xDE, 0x07, 0xFC, 0x1E, 0x78, 0x70, 0xE1, 0x81, 0x8E,
  0x07, 0x38, 0x18, 0xE0, 0x63, 0x01, 0x8C, 0x06, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x1C, 0x1C, 0x7C, 0xF1, 0xBF, 0x8E, 0x78, 0x00, 0x07, 0xC1, 0xFE,
  0x3C, 0xE3, 0x07, 0x70, 0x36, 0x03, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xEE, 0x0E, 0x71, 0xC7, 0xF8, 0x1F, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0xF9, 0x87,
  0xFE, 0x3C, 0xF9, 0xE1, 0xE7, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x81, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0x63, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0x73, 0xE1,
  0xFF, 0x83, 0xEC, 0x00, 0x07, 0xC1, 0xFE, 0x3C, 0xE3, 0x07, 0x70, 0x76,
  0x07, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x04, 0x79, 0xE3, 0xFC, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0xF0, 0x70, 0x1C,
  0x06, 0x0F, 0xF3, 0xF8, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x07,
  0xCC, 0x3F, 0xF1, 0xE7, 0xC7, 0x0F, 0x38, 0x18, 0xC0, 0x63, 0x03, 0x9C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x1C, 0x0C, 0x70, 0x71, 0xC1, 0xC3,
  0x9F, 0x0F, 0xFC, 0x1F, 0x60, 0x01, 0x80, 0x0E, 0x10, 0x38, 0xF3, 0xC1,
  0xFE, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x77, 0x83, 0xFE, 0x1E, 0x78, 0xE1, 0xC6, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xC0, 0xC6, 0x06, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0,
  0xE6, 0x06, 0x30, 0x33, 0x81, 0x80, 0x1C, 0x71, 0xC0, 0x00, 0x03, 0x8E,
  0x38, 0xC3, 0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x00,
  0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x83, 0xE0, 0xF0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC3, 0xC7, 0x1E, 0x1C, 0x70, 0x63, 0x81, 0x9C, 0x0E, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3B, 0x81, 0xC6, 0x07, 0x1C, 0x1C, 0x70,
  0x60, 0xE1, 0x83, 0x8E, 0x06, 0x00, 0x0C, 0x71, 0xC7, 0x18, 0x63, 0x8E,
  0x38, 0xE3, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x0C, 0x00,
  0x1D, 0xE1, 0xE0, 0xFF, 0xBF, 0x87, 0x9F, 0xDE, 0x38, 0x78, 0x73, 0x83,
  0x83, 0x9C, 0x1C, 0x1C, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x30, 0x30, 0x39,
  0x81, 0x81, 0x9C, 0x1C, 0x0C, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x38, 0x38,
  0x39, 0x81, 0x81, 0xCC, 0x0C, 0x0C, 0xE0, 0x60, 0x60, 0x1D, 0xE0, 0xDF,
  0x87, 0x9E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x31,
  0x81, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0x81, 0x8C, 0x0C, 0xE0,
  0x60, 0x07, 0xC0, 0xFF, 0x0F, 0x3C, 0x70, 0xE7, 0x03, 0xB8, 0x1D, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x0D, 0xC0, 0xEE, 0x07, 0x30, 0x71,
  0xC7, 0x07, 0xF0, 0x1F, 0x00, 0x0E, 0xF0, 0x1B, 0xF0, 0x3C, 0xF0, 0x70,
  0xE1, 0xC0, 0xC3, 0x81, 0x87, 0x03, 0x0E, 0x06, 0x18, 0x0C, 0x30, 0x18,
  0xE0, 0x71, 0xC0, 0xE3, 0x81, 0x87, 0x07, 0x0F, 0x1E, 0x1B, 0xF8, 0x73,
  0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x98, 0xFF, 0xCF, 0x3E, 0xF0, 0xF7, 0x03, 0x30, 0x19, 0x81,
  0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x19, 0xC0, 0xCE, 0x0E, 0x70, 0x71,
  0xCF, 0x8F, 0xFC, 0x3E, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x1D, 0xC7, 0xF1, 0xFC, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x00, 0x0F, 0x81, 0xFC, 0x3D, 0xE3, 0x06, 0x70, 0x77, 0x00, 0x38, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xC0, 0x0C, 0xC0, 0xCE, 0x1C, 0xF3, 0xC7,
  0xF8, 0x3E, 0x00, 0x0C, 0x1C, 0x1C, 0xFF, 0xFF, 0x18, 0x18, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x74, 0x78, 0x38, 0x38,
  0x39, 0xC1, 0xCC, 0x0C, 0x60, 0x67, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E,
  0x60, 0x63, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF1, 0xCF, 0x0F,
  0xF8, 0x3E, 0xC0, 0xC0, 0xFC, 0x1F, 0x83, 0x70, 0xEE, 0x18, 0xC7, 0x18,
  0xE3, 0x18, 0x67, 0x0C, 0xC1, 0xB8, 0x3E, 0x07, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x30, 0x00, 0xE0, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1B, 0x8F, 0x0E,
  0xE3, 0xC3, 0x38, 0xF1, 0xCE, 0x7E, 0x73, 0x9B, 0x98, 0x6E, 0x6E, 0x1B,
  0x1B, 0x06, 0xC6, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x07,
  0x01, 0xC1, 0xC0, 0x60, 0x70, 0x00, 0x1C, 0x1C, 0x30, 0xF0, 0xE3, 0x83,
  0x9C, 0x06, 0x70, 0x1B, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x7C, 0x03, 0xF0, 0x1C, 0xC0, 0x73, 0x83, 0x8E, 0x1C, 0x18, 0x70, 0x70,
  0x1C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x71, 0xC0, 0xC6,
  0x03, 0x38, 0x0C, 0xC0, 0x37, 0x00, 0xDC, 0x03, 0x60, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x80, 0x70,
  0x30, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x1E, 0x0F, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x02, 0x00, 0x0C,
  0x71, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x31, 0xC7, 0x18, 0x61,
  0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC3, 0x00, 0x08, 0x06, 0x01, 0x80, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x70, 0x38, 0x0E,
  0x0F, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x0E, 0x0E, 0x04, 0x00, 0x3C, 0x0D, 0xF8, 0x3F, 0xF1, 0xF0, 0xEE,
  0xC1, 0xF8, 0x03, 0x80,
};

const GFXglyph RobotoCondensed_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 7, 7, 10, 3, -23 },
  { 25, 16, 22, 16, 1, -22 },
  { 69, 13, 28, 15, 1, -25 },
  { 115, 14, 22, 19, 3, -22 },
  { 154, 14, 22, 16, 1, -22 },
  { 193, 3, 7, 5, 3, -23 },
  { 196, 9, 32, 9, 2, -25 },
  { 232, 9, 32, 10, -1, -25 },
  { 268, 12, 13, 13, 2, -22 },
  { 288, 13, 16, 15, 1, -18 },
  { 314, 6, 8, 6, -2, -3 },
  { 320, 6, 2, 7, 1, -10 },
  { 322, 3, 3, 8, 1, -3 },
  { 324, 14, 24, 11, -2, -22 },
  { 366, 12, 22, 15, 2, -22 },
  { 399, 8, 22, 15, 4, -22 },
  { 421, 14, 22, 15, 0, -22 },
  { 460, 13, 22, 15, 1, -22 },
  { 496, 14, 22, 15, 0, -22 },
  { 535, 13, 22, 15, 2, -22 },
  { 571, 11, 22, 15, 2, -22 },
  { 602, 14, 22, 15, 2, -22 },
  { 641, 13, 22, 15, 1, -22 },
  { 677, 12, 22, 15, 2, -22 },
  { 710, 5, 16, 7, 1, -16 },
  { 720, 7, 21, 6, -1, -16 },
  { 739, 12, 14, 13, 1, -17 },
  { 760, 11, 8, 14, 2, -14 },
  { 771, 12, 14, 14, 1, -17 },
  { 792, 10, 22, 13, 3, -22 },
  { 820, 21, 29, 23, 1, -22 },
  { 897, 16, 22, 17, -1, -22 },
  { 941, 15, 22, 16, 1, -22 },
  { 983, 15, 22, 17, 2, -22 },
  { 1025, 15, 22, 17, 1, -22 },
  { 1067, 15, 22, 15, 1, -22 },
  { 1109, 15, 22, 14, 1, -22 },
  { 1151, 15, 22, 18, 2, -22 },
  { 1193, 18, 22, 19, 1, -22 },
  { 1243, 6, 22, 8, 1, -22 },
  { 1260, 15, 22, 15, 0, -22 },
  { 1302, 17, 22, 16, 1, -22 },
  { 1349, 11, 22, 14, 1, -22 },
  { 1380, 22, 22, 23, 1, -22 },
  { 1441, 18, 22, 19, 1, -22 },
  { 1491, 15, 22, 18, 2, -22 },
  { 1533, 16, 22, 17, 1, -22 },
  { 1577, 15, 26, 18, 2, -22 },
  { 1626, 15, 22, 16, 1, -22 },
  { 1668, 15, 22, 16, 1, -22 },
  { 1710, 14, 22, 16, 3, -22 },
  { 1749, 16, 22, 17, 1, -22 },
  { 1793, 15, 22, 17, 3, -22 },
  { 1835, 21, 22, 23, 3, -22 },
  { 1893, 18, 22, 17, 0, -22 },
  { 1943, 15, 22, 16, 3, -22 },
  { 1985, 16, 22, 16, 0, -22 },
  { 2029, 9, 30, 8, 0, -25 },
  { 2063, 6, 24, 11, 3, -22 },
  { 2081, 10, 30, 8, -2, -25 },
  { 2119, 9, 11, 11, 1, -22 },
  { 2132, 12, 2, 12, -2, 0 },
  { 2135, 5, 4, 9, 3, -23 },
  { 2138, 12, 17, 14, 1, -17 },
  { 2164, 14, 23, 15, 0, -23 },
  { 2205, 12, 17, 14, 1, -17 },
  { 2231, 14, 23, 15, 1, -23 },
  { 2272, 12, 17, 14, 1, -17 },
  { 2298, 10, 23, 10, 2, -23 },
  { 2327, 14, 23, 15, 0, -17 },
  { 2368, 13, 23, 15, 0, -23 },
  { 2406, 6, 23, 7, 1, -23 },
  { 2424, 10, 29, 7, -3, -23 },
  { 2461, 14, 23, 14, 0, -23 },
  { 2502, 6, 23, 7, 1, -23 },
  { 2520, 21, 17, 23, 0, -17 },
  { 2565, 13, 17, 15, 0, -17 },
  { 2593, 13, 17, 15, 1, -17 },
  { 2621, 15, 23, 15, -1, -17 },
  { 2665, 13, 23, 15, 1, -17 },
  { 2703, 10, 17, 9, 0, -17 },
  { 2725, 12, 17, 14, 1, -17 },
  { 2751, 8, 20, 9, 1, -20 },
  { 2771, 13, 17, 15, 1, -17 },
  { 2799, 11, 17, 13, 2, -17 },
  { 2823, 18, 17, 20, 2, -17 },
  { 2862, 14, 17, 13, -1, -17 },
  { 2892, 14, 23, 13, -1, -17 },
  { 2933, 13, 17, 13, 0, -17 },
  { 2961, 10, 30, 9, 1, -24 },
  { 2999, 6, 26, 7, 1, -22 },
  { 3019, 9, 30, 9, -1, -24 },
  { 3053, 14, 6, 18, 2, -12 },
};

const GFXfont RobotoCondensed_Italic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_ITALIC31PT7B_H_
