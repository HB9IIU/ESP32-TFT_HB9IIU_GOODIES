#ifndef _ROBOTOCONDENSED_ITALIC57PT7B_H_
#define _ROBOTOCONDENSED_ITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x3C, 0x79, 0xC3, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F,
  0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0xF0, 0xE7, 0x87, 0x38, 0x79, 0xC3, 0xCE,
  0x1C, 0x70, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xF8, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0,
  0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x87, 0x81, 0xC0, 0x31, 0xC0, 0x70, 0x1E, 0x70,
  0x1C, 0x0F, 0x3C, 0x07, 0x03, 0x8F, 0x01, 0xC1, 0xE3, 0xC0, 0x70, 0xF0,
  0xF0, 0x3C, 0x38, 0x3C, 0x0F, 0x1E, 0x07, 0x07, 0x8F, 0x01, 0xE1, 0xE7,
  0x80, 0x7F, 0xF1, 0xE0, 0x0F, 0xF8, 0xF0, 0x01, 0xFC, 0x78, 0x00, 0x08,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x20, 0x00, 0x78, 0xFF, 0x00, 0x1E, 0x7F, 0xE0, 0x0F, 0x3F,
  0xF8, 0x07, 0x8F, 0x0F, 0x01, 0xE7, 0x83, 0xC0, 0xF1, 0xE0, 0x70, 0x78,
  0x70, 0x1C, 0x1E, 0x1C, 0x07, 0x0F, 0x0F, 0x01, 0xC7, 0x83, 0xC0, 0x71,
  0xE0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x78, 0x0F, 0x03, 0xCC, 0x01, 0xC1,
  0xE1, 0x00, 0x78, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x9F, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0x1F,
  0x9F, 0x07, 0xCF, 0xC7, 0xC1, 0xE7, 0xE0, 0xF8, 0x79, 0xF0, 0x3E, 0x3E,
  0xFC, 0x07, 0xCF, 0xBE, 0x01, 0xF3, 0xCF, 0x80, 0x3F, 0xF3, 0xE0, 0x0F,
  0xF8, 0xF8, 0x01, 0xFE, 0x3E, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0,
  0x03, 0xF0, 0x7C, 0x01, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0x01, 0xFF, 0x07, 0xE0, 0x04, 0x00,
  0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0xE0, 0x00,
  0x01, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0C, 0x0F, 0x03, 0x7C, 0x3C, 0x7D,
  0xFE, 0xEF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x3E, 0x78,
  0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x7E, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87,
  0xC3, 0xE0, 0x70, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x38,
  0xF9, 0xFF, 0xF7, 0xCF, 0x84, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x81, 0xF0,
  0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x9E, 0x00, 0x1F, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9E, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E,
  0x07, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xBE, 0xF0,
  0xFB, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3F, 0x07, 0xC0,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00,
  0x7C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x1E, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0xFC, 0x07, 0xDF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0xFE, 0x03, 0xE7, 0xE0, 0x1F, 0xBF, 0x00,
  0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8,
  0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x07, 0x80, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x03, 0xE1, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF9,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3E, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF8, 0x1F,
  0xC7, 0xE3, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xEF, 0x03, 0xFE, 0x78, 0x0F,
  0xC7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x01, 0xF0, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0x00, 0x00, 0x00,
  0x30, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x80, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x1F,
  0x80, 0x38, 0x1E, 0x01, 0xFF, 0x80, 0x70, 0xF0, 0x0F, 0xFF, 0x01, 0xC3,
  0xC0, 0x7F, 0xFE, 0x07, 0x0E, 0x01, 0xE0, 0x70, 0x1C, 0x78, 0x0F, 0x03,
  0xC0, 0x71, 0xE0, 0x7C, 0x0F, 0x01, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x3C,
  0x0F, 0x00, 0xF0, 0x1C, 0xF0, 0x3C, 0x07, 0x80, 0x77, 0x80, 0xF0, 0x1E,
  0x01, 0xDE, 0x07, 0x80, 0x78, 0x0F, 0x78, 0x1E, 0x01, 0xE0, 0x3D, 0xC0,
  0x78, 0x0F, 0x00, 0xF7, 0x03, 0xE0, 0x3C, 0x03, 0xBC, 0x0F, 0x00, 0xF0,
  0x0E, 0xF0, 0x3C, 0x03, 0xC0, 0x3B, 0xC0, 0xF0, 0x0E, 0x01, 0xEF, 0x03,
  0xC0, 0x78, 0x07, 0x3C, 0x0F, 0x01, 0xE0, 0x1C, 0xF0, 0x3C, 0x07, 0x80,
  0xF3, 0xC0, 0xF0, 0x3E, 0x03, 0x8E, 0x03, 0xC1, 0xF8, 0x1E, 0x3C, 0x0F,
  0x07, 0xE0, 0xF0, 0xF0, 0x3F, 0x7F, 0x87, 0x83, 0xC0, 0xFF, 0xCF, 0xFE,
  0x0F, 0x01, 0xFE, 0x3F, 0xF0, 0x3C, 0x03, 0xF0, 0x7F, 0x00, 0xF0, 0x02,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x07, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x80,
  0xF8, 0x03, 0xF8, 0x07, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7C,
  0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xC7, 0xC0, 0x3F, 0xFC, 0x7C, 0x03,
  0xFF, 0xCF, 0x80, 0x3F, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x03,
  0xE0, 0x1F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xF7, 0xC0, 0x00, 0x1F, 0xE7, 0xC0, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0xF7, 0x80, 0x01, 0xFF, 0x80, 0xFB, 0xC0, 0x00, 0xFF, 0xC0, 0x7D, 0xE0,
  0x00, 0xFB, 0xE0, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x0F, 0x3E, 0x00, 0x3E, 0xF8, 0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x07,
  0xC7, 0x80, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0,
  0x0F, 0x9F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x1F,
  0x07, 0x83, 0xE1, 0xF0, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x07, 0xC1, 0xE1,
  0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x78, 0x1F,
  0x01, 0xF0, 0x3E, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x3C, 0x0F, 0x80, 0x7C,
  0x07, 0xBE, 0x07, 0xC0, 0x3E, 0x03, 0xDE, 0x03, 0xE0, 0x1F, 0x01, 0xFF,
  0x01, 0xF0, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0x7F, 0x80, 0x7C,
  0x07, 0xC0, 0x3F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x01, 0xF0,
  0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0xF0, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0x3E,
  0x03, 0xFE, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x0F,
  0x80, 0xF9, 0xE0, 0x07, 0xC0, 0x7C, 0xF0, 0x03, 0xE0, 0x3E, 0x7C, 0x01,
  0xF0, 0x1F, 0x1E, 0x00, 0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0x07, 0xC7, 0xC0,
  0x7C, 0x07, 0xC1, 0xE0, 0x3E, 0x03, 0xE0, 0xF0, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x07, 0xC0, 0x7E, 0x07,
  0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x80,
  0x7C, 0x7C, 0x07, 0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0x0F, 0x3E, 0x03, 0xE0,
  0x07, 0xDF, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0xF8, 0x00, 0xF7, 0xC0, 0x7C,
  0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0xF0, 0x1F,
  0x00, 0x07, 0xF8, 0x0F, 0x80, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x03,
  0xE0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x33, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0xE0, 0x3E, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xE0,
  0x03, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x3E, 0xF8, 0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0x03, 0xEF, 0x80,
  0x1F, 0xC0, 0x1F, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xFC, 0x01,
  0xF3, 0xE0, 0x1F, 0xF0, 0x0F, 0x8F, 0x80, 0x7B, 0xC0, 0x3E, 0x3E, 0x01,
  0xEF, 0x00, 0xF8, 0xF8, 0x0F, 0xBC, 0x07, 0xC3, 0xE0, 0x3C, 0xF0, 0x1F,
  0x0F, 0x80, 0xF3, 0xC0, 0x78, 0x3E, 0x07, 0x8F, 0x03, 0xE0, 0xF8, 0x1E,
  0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0xF0, 0x3C, 0x0F, 0x83, 0xC3, 0xC1, 0xF0,
  0x3E, 0x0F, 0x0F, 0x07, 0xC0, 0xF8, 0x7C, 0x3C, 0x1E, 0x03, 0xE1, 0xE0,
  0x70, 0xF8, 0x07, 0x87, 0x81, 0xC3, 0xE0, 0x1E, 0x3C, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x1E, 0xF8, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xCE,
  0x01, 0xE7, 0x01, 0xF3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x7C,
  0x3C, 0x3C, 0x1E, 0x3E, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFC,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x81, 0xF0,
  0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8,
  0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0x3E, 0x03, 0xFC,
  0x7C, 0x00, 0x40, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xCF, 0xF0, 0x07, 0xBF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0xFF, 0x03,
  0xF8, 0xFB, 0xFF, 0xF0, 0xFB, 0xFF, 0xE0, 0xF9, 0xFF, 0xC0, 0xF0, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xE1, 0xF0, 0x07, 0xCF,
  0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x7C, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x7F, 0xC7, 0xC0, 0x3F, 0xF9, 0xF0, 0x1F, 0xFF, 0x7C,
  0x0F, 0xFF, 0xDE, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07,
  0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x78,
  0x00, 0xFF, 0x3E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0xC1, 0xF0, 0x07, 0x07, 0xE0, 0x3E, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xF0, 0x0F, 0xFE, 0x7C,
  0x07, 0xFF, 0xDF, 0x03, 0xFF, 0xF7, 0x81, 0xFC, 0x1F, 0xE0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0x80, 0x01, 0x83, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x20,
  0x03, 0xE0, 0x1C, 0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF9, 0xFE, 0x01, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xC0, 0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00,
  0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0x80, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x9F, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x1E, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F,
  0x81, 0xFC, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0xFC, 0x00,
  0xF0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFD, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1E, 0x7F,
  0xC0, 0xFF, 0x00, 0x7B, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFD, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0x07, 0xE0, 0xFC, 0x07,
  0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0x3E, 0x0F, 0x00, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x03, 0xE1,
  0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x80, 0x1F, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x7C,
  0x00, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x1F, 0xE0, 0x1E, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFE, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0,
  0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F,
  0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1E, 0x7C, 0x00, 0x7C,
  0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x1F, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0xFF, 0x00, 0x1E, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C,
  0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x83,
  0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3E, 0xFF, 0xF8, 0x0F, 0x9F, 0xFC,
  0x03, 0xE3, 0xFC, 0x00, 0xF0, 0x18, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0x1F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xDF, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xF3, 0xE0, 0x01, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xCF, 0xC1, 0xEF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xC8, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0x83, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x7E,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x10, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x3F, 0xFF, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x40, 0x00, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x78,
  0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFB, 0xE0, 0x0F, 0xF3, 0xC0, 0x01, 0x00, 0x00, 0xF8,
  0x00, 0xF9, 0xE0, 0x03, 0xE7, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x3C, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0,
  0x78, 0x03, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xF0,
  0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x0F, 0xBC, 0x01, 0xF0, 0x07, 0xDE, 0x00,
  0xF8, 0x03, 0xEF, 0x80, 0xFC, 0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0,
  0x7F, 0x80, 0xF1, 0xF0, 0x3F, 0xC0, 0xF8, 0xF8, 0x1F, 0xE0, 0x78, 0x7C,
  0x1E, 0xF0, 0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x0F, 0xBC, 0x1E, 0x07,
  0x87, 0x9E, 0x1F, 0x03, 0xC7, 0xCF, 0x0F, 0x01, 0xE3, 0xC7, 0x87, 0x80,
  0xF1, 0xE3, 0xC7, 0xC0, 0x79, 0xE1, 0xF3, 0xC0, 0x3C, 0xF0, 0x7B, 0xE0,
  0x1E, 0xF0, 0x3D, 0xE0, 0x0F, 0x78, 0x1E, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xC7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07,
  0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0,
  0x3F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0x1E, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3C, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x01,
  0xE7, 0xFF, 0xE0, 0x3C, 0xF8, 0x7E, 0x0F, 0x9E, 0x07, 0xFF, 0xE7, 0xC0,
  0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x1E, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0,
  0x00,
};

const GFXglyph RobotoCondensed_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 42, 14, 2, -41 },
  { 64, 13, 14, 18, 6, -43 },
  { 87, 28, 41, 30, 3, -41 },
  { 231, 24, 54, 27, 2, -48 },
  { 393, 26, 43, 35, 5, -42 },
  { 533, 26, 43, 30, 2, -42 },
  { 673, 6, 13, 10, 5, -43 },
  { 683, 17, 59, 17, 3, -46 },
  { 809, 17, 59, 18, -3, -46 },
  { 935, 22, 24, 24, 3, -41 },
  { 1001, 24, 30, 27, 2, -34 },
  { 1091, 10, 14, 11, -3, -6 },
  { 1109, 12, 4, 14, 1, -19 },
  { 1115, 7, 7, 15, 1, -6 },
  { 1122, 26, 44, 21, -3, -41 },
  { 1265, 23, 43, 27, 3, -42 },
  { 1389, 14, 41, 27, 7, -41 },
  { 1461, 25, 42, 27, 1, -42 },
  { 1593, 24, 43, 27, 2, -42 },
  { 1722, 25, 41, 27, 0, -41 },
  { 1851, 25, 42, 27, 3, -41 },
  { 1983, 21, 42, 27, 3, -41 },
  { 2094, 25, 41, 27, 4, -41 },
  { 2223, 24, 43, 27, 2, -42 },
  { 2352, 21, 42, 27, 4, -42 },
  { 2463, 11, 32, 13, 1, -31 },
  { 2507, 14, 39, 12, -3, -31 },
  { 2576, 21, 25, 25, 2, -31 },
  { 2642, 22, 15, 27, 3, -27 },
  { 2684, 22, 25, 25, 2, -30 },
  { 2753, 19, 43, 23, 5, -42 },
  { 2856, 38, 53, 43, 2, -40 },
  { 3108, 30, 41, 32, -2, -41 },
  { 3262, 28, 41, 30, 1, -41 },
  { 3406, 28, 43, 31, 3, -42 },
  { 3557, 29, 41, 32, 1, -41 },
  { 3706, 28, 41, 27, 1, -41 },
  { 3850, 28, 41, 27, 1, -41 },
  { 3994, 28, 43, 33, 3, -42 },
  { 4145, 33, 41, 34, 1, -41 },
  { 4315, 12, 41, 14, 2, -41 },
  { 4377, 27, 42, 27, 0, -41 },
  { 4519, 32, 41, 30, 1, -41 },
  { 4683, 22, 41, 26, 1, -41 },
  { 4796, 41, 41, 42, 1, -41 },
  { 5007, 33, 41, 34, 1, -41 },
  { 5177, 28, 43, 33, 3, -42 },
  { 5328, 30, 41, 31, 1, -41 },
  { 5482, 28, 49, 33, 3, -42 },
  { 5654, 28, 41, 29, 1, -41 },
  { 5798, 28, 43, 29, 1, -42 },
  { 5949, 26, 41, 29, 5, -41 },
  { 6083, 30, 42, 31, 2, -41 },
  { 6241, 29, 41, 31, 5, -41 },
  { 6390, 38, 41, 42, 6, -41 },
  { 6585, 33, 41, 30, -1, -41 },
  { 6755, 27, 41, 29, 5, -41 },
  { 6894, 30, 41, 29, 0, -41 },
  { 7048, 17, 55, 14, 0, -46 },
  { 7165, 10, 44, 20, 6, -41 },
  { 7220, 17, 55, 14, -3, -46 },
  { 7337, 17, 20, 21, 2, -41 },
  { 7380, 22, 4, 22, -3, 0 },
  { 7391, 9, 8, 17, 6, -43 },
  { 7400, 23, 32, 27, 1, -31 },
  { 7492, 24, 44, 27, 1, -43 },
  { 7624, 22, 32, 26, 2, -31 },
  { 7712, 26, 44, 27, 2, -43 },
  { 7855, 22, 32, 26, 2, -31 },
  { 7943, 18, 44, 18, 3, -44 },
  { 8042, 26, 43, 27, 0, -31 },
  { 8182, 23, 43, 27, 1, -43 },
  { 8306, 12, 41, 13, 1, -41 },
  { 8368, 17, 53, 12, -5, -41 },
  { 8481, 25, 43, 25, 1, -43 },
  { 8616, 12, 43, 13, 1, -43 },
  { 8681, 38, 31, 42, 1, -31 },
  { 8829, 23, 31, 27, 1, -31 },
  { 8919, 23, 32, 28, 2, -31 },
  { 9011, 26, 43, 27, -1, -31 },
  { 9151, 24, 43, 28, 2, -31 },
  { 9280, 17, 31, 17, 1, -31 },
  { 9346, 22, 32, 25, 1, -31 },
  { 9434, 15, 38, 16, 2, -37 },
  { 9506, 24, 31, 27, 2, -30 },
  { 9599, 22, 30, 24, 3, -30 },
  { 9682, 33, 30, 36, 4, -30 },
  { 9806, 26, 30, 24, -1, -30 },
  { 9904, 26, 42, 23, -2, -30 },
  { 10041, 24, 30, 24, 0, -30 },
  { 10131, 18, 55, 17, 2, -45 },
  { 10255, 12, 49, 14, 1, -41 },
  { 10329, 18, 54, 17, -3, -44 },
  { 10451, 27, 11, 33, 3, -22 },
};

const GFXfont RobotoCondensed_Italic57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_ITALIC57PT7B_H_
