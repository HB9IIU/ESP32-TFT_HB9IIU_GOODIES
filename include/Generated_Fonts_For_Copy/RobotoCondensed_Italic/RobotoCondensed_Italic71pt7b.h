#ifndef _ROBOTOCONDENSED_ITALIC71PT7B_H_
#define _ROBOTOCONDENSED_ITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F,
  0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x10, 0x78,
  0x07, 0x80, 0x38, 0xF8, 0x07, 0x80, 0x3C, 0xF8, 0x07, 0x80, 0x7C, 0xF0,
  0x07, 0x80, 0xF8, 0xF0, 0x07, 0x81, 0xF0, 0xF0, 0x07, 0x81, 0xF0, 0xF0,
  0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0xF0, 0x0F, 0x87, 0xC0, 0xF0,
  0x0F, 0x0F, 0x80, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0x1F, 0x1F, 0x00, 0x7C,
  0x3E, 0x3E, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x3F, 0xFC, 0x78, 0x00, 0x1F,
  0xF8, 0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x87, 0xF0, 0x00, 0x1F, 0x1F, 0xF8, 0x00, 0x3E, 0x3F, 0xFC, 0x00,
  0x3E, 0x7F, 0xFE, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x1E, 0x00,
  0xF0, 0xF0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x07,
  0xC1, 0xE0, 0x0F, 0x07, 0xC1, 0xE0, 0x0F, 0x0F, 0x81, 0xE0, 0x1F, 0x1F,
  0x01, 0xE0, 0x1F, 0x1F, 0x03, 0xE0, 0x1F, 0x3E, 0x03, 0xE0, 0x1F, 0x7C,
  0x01, 0xE0, 0x1E, 0x7C, 0x01, 0xE0, 0x3E, 0x38, 0x01, 0xF0, 0x3E, 0x10,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x7F,
  0x9F, 0x80, 0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0x7F, 0x83, 0xF0, 0x3E, 0x3F,
  0x81, 0xFC, 0x3F, 0x3F, 0x80, 0x7E, 0x1F, 0x1F, 0xC0, 0x3F, 0x8F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xC7, 0xE0, 0x07, 0xF7, 0xC7, 0xF0, 0x01, 0xFF, 0xE3,
  0xF0, 0x00, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFE,
  0x07, 0xF0, 0x01, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xCF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xF8,
  0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x0F, 0x80, 0x6F, 0x81, 0xF0,
  0x3D, 0xFC, 0x3E, 0x3F, 0xFF, 0xF7, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xC7, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0x80,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0x38, 0x01, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xC0, 0x3C, 0x7E, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xDF, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xE3, 0xF1, 0xF0, 0x7E, 0x30, 0x0F, 0xC8, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x1F,
  0xC0, 0x00, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE3, 0xF8, 0x01, 0xFB, 0xFF, 0x80, 0xFD, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x8F, 0xF1, 0xFF, 0x80, 0xFE,
  0x7F, 0x80, 0x1F, 0x9F, 0xE0, 0x07, 0xE7, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE,
  0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x9F, 0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF8, 0xFE, 0x03, 0xFE, 0x3F, 0xE7,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFC, 0x07,
  0xFF, 0x3F, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7E, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xF0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1E, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0xFF,
  0xE0, 0x0E, 0x03, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0x07, 0xC0, 0x1F, 0xE7,
  0xF0, 0x0F, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x0F, 0x0F, 0x80, 0x3F, 0x01,
  0xF0, 0x0F, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x3E, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x3E, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x7C, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x7C, 0x07, 0xE0, 0x0F,
  0x80, 0x1E, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x78, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x78, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0xF0, 0xF8, 0x07, 0xC0, 0x7E,
  0x01, 0xE0, 0xF8, 0x07, 0xC0, 0xFE, 0x03, 0xE0, 0xF8, 0x07, 0xF3, 0xFF,
  0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xDF, 0x9F, 0xC0, 0x78, 0x03, 0xFF, 0x8F,
  0xFF, 0x80, 0x78, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x78, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x7C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x01,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F,
  0xC0, 0x7E, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xC0,
  0x03, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFE, 0x3F, 0x00,
  0x3F, 0xFF, 0x87, 0xE0, 0x07, 0xFF, 0xF1, 0xFC, 0x00, 0xFF, 0xFE, 0x3F,
  0x00, 0x1F, 0xFF, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00,
  0x03, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xE1,
  0xFE, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xF8, 0x00,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFD, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x00, 0xFD,
  0xF8, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x03,
  0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x80, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3E, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xDF, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0x80,
  0x00, 0x7E, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x00, 0x7E,
  0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xF7,
  0xE0, 0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0x03, 0xF3, 0xE0, 0x00,
  0xFC, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0x07,
  0xF1, 0xF0, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x1F, 0x80, 0x0F, 0xCF, 0xE0,
  0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x3F, 0x00,
  0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x03, 0xEF,
  0xC0, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x7E,
  0x00, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x01,
  0xFF, 0x80, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F,
  0xF0, 0x0F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xF8, 0x7C, 0x00, 0x7D, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7D, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF9, 0xF0,
  0x07, 0xE0, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF9, 0xF0,
  0x07, 0xE0, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF1, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xE1, 0xF0,
  0x1F, 0x80, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xC1, 0xF0,
  0x1F, 0x00, 0x7E, 0x07, 0xC1, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC1, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0x80, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0x00, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0xF8,
  0x7C, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0xF8,
  0xFC, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0xF9,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xF9,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0xFB,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xFC,
  0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0x0F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDE, 0x00, 0x7E,
  0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80,
  0xF8, 0x7C, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03,
  0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0xFC,
  0x00, 0xF8, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0,
  0x1F, 0x8F, 0xF0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFB, 0xF0, 0x3F, 0xFE, 0x7E, 0x03, 0xFF, 0x0F, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC,
  0x7F, 0xE0, 0x03, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0x7F,
  0x00, 0x07, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xFC, 0x01, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF0, 0x7D, 0xFF, 0xFF, 0x83, 0xF3, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF,
  0xE0, 0x3F, 0x1F, 0xFF, 0x00, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x7F, 0xE1, 0xF8, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xFE, 0x7E, 0x00,
  0xFF, 0xFF, 0xBF, 0x00, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0x80, 0xFF, 0xC0,
  0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF7, 0xC0, 0x01, 0xFF, 0xF3, 0xE0, 0x00, 0x3F, 0xF3, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x3F, 0x00, 0x1E, 0x03,
  0xF8, 0x03, 0xF0, 0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x1F, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x7F, 0xFF, 0x3F, 0x00, 0xFF,
  0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xBF, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xEF, 0xC0, 0x00, 0xFF, 0xCF, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x10, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0xF0,
  0x03, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x03, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0x03, 0xF0, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0,
  0x1F, 0x80, 0xFF, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x0F,
  0xC7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE7, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xDF,
  0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0x8F, 0xFC, 0x00, 0xFD, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8,
  0x1F, 0xC0, 0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0xF8,
  0x00, 0x1F, 0xBF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFF, 0xCF, 0xFC, 0x03, 0xF7, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFC,
  0x00, 0xFC, 0x7F, 0xFC, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xC1, 0xF0, 0x0F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF,
  0xFE, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xF8, 0x01,
  0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0xFC, 0x00, 0x7F, 0xF3, 0xF0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x9F, 0xC0, 0xFD, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFE, 0x60, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xE0, 0x07, 0xFE, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF9, 0xF0, 0x00,
  0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0,
  0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xF8, 0x03, 0xF1,
  0xF8, 0x03, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x7E, 0x01,
  0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0xFF, 0xC0,
  0x3E, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x81,
  0xF0, 0x3E, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F,
  0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x8F, 0x87, 0xE0, 0x1F, 0x0F, 0x87, 0xC3,
  0xF0, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0x07, 0xC7, 0xC1, 0xF1, 0xF8, 0x03,
  0xE3, 0xE0, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x7C, 0xFC, 0x00, 0xF9, 0xF0,
  0x1E, 0x7C, 0x00, 0x7D, 0xF8, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xE0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC7, 0xF0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xF0, 0x7F, 0xF8, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x1F,
  0x1F, 0xFF, 0xE0, 0x0F, 0x87, 0xFF, 0xFC, 0x03, 0xE3, 0xF0, 0x7F, 0x81,
  0xF8, 0xF8, 0x0F, 0xE0, 0x7C, 0x7E, 0x01, 0xFF, 0xFF, 0x1F, 0x00, 0x3F,
  0xFF, 0x87, 0xC0, 0x07, 0xFF, 0xE1, 0xF0, 0x00, 0xFF, 0xF0, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 15, 51, 17, 2, -50 },
  { 97, 17, 17, 22, 7, -53 },
  { 134, 36, 50, 38, 3, -50 },
  { 359, 29, 65, 34, 3, -58 },
  { 595, 32, 52, 44, 7, -51 },
  { 803, 33, 52, 37, 2, -51 },
  { 1018, 8, 17, 12, 6, -53 },
  { 1035, 21, 73, 22, 4, -57 },
  { 1227, 21, 73, 22, -3, -57 },
  { 1419, 27, 29, 30, 4, -50 },
  { 1517, 29, 37, 34, 3, -42 },
  { 1652, 12, 18, 14, -4, -8 },
  { 1679, 15, 5, 17, 1, -24 },
  { 1689, 8, 8, 18, 2, -7 },
  { 1697, 32, 54, 26, -3, -50 },
  { 1913, 29, 52, 34, 3, -51 },
  { 2102, 19, 50, 34, 8, -50 },
  { 2221, 31, 51, 34, 1, -51 },
  { 2419, 30, 52, 34, 2, -51 },
  { 2614, 32, 50, 34, 0, -50 },
  { 2814, 30, 51, 34, 4, -50 },
  { 3006, 26, 51, 34, 4, -50 },
  { 3172, 32, 50, 34, 4, -50 },
  { 3372, 30, 52, 34, 2, -51 },
  { 3567, 26, 51, 34, 5, -51 },
  { 3733, 13, 39, 16, 2, -38 },
  { 3797, 17, 48, 14, -3, -38 },
  { 3899, 27, 31, 31, 2, -38 },
  { 4004, 27, 21, 33, 4, -34 },
  { 4075, 28, 31, 32, 2, -38 },
  { 4184, 23, 52, 29, 6, -51 },
  { 4334, 48, 66, 53, 2, -50 },
  { 4730, 37, 50, 40, -2, -50 },
  { 4962, 34, 50, 38, 2, -50 },
  { 5175, 35, 52, 39, 4, -51 },
  { 5403, 35, 50, 39, 2, -50 },
  { 5622, 34, 50, 34, 2, -50 },
  { 5835, 34, 50, 33, 2, -50 },
  { 6048, 35, 52, 41, 4, -51 },
  { 6276, 41, 50, 43, 2, -50 },
  { 6533, 15, 50, 17, 2, -50 },
  { 6627, 34, 51, 33, 0, -50 },
  { 6844, 40, 50, 38, 2, -50 },
  { 7094, 26, 50, 33, 2, -50 },
  { 7257, 50, 50, 52, 2, -50 },
  { 7570, 40, 50, 43, 2, -50 },
  { 7820, 35, 52, 41, 4, -51 },
  { 8048, 36, 50, 38, 2, -50 },
  { 8273, 35, 60, 41, 4, -51 },
  { 8536, 35, 50, 37, 2, -50 },
  { 8755, 34, 52, 36, 2, -51 },
  { 8976, 33, 50, 36, 6, -50 },
  { 9183, 37, 51, 39, 3, -50 },
  { 9419, 36, 50, 39, 6, -50 },
  { 9644, 48, 50, 52, 7, -50 },
  { 9944, 41, 50, 38, -1, -50 },
  { 10201, 34, 50, 36, 6, -50 },
  { 10414, 38, 50, 36, -1, -50 },
  { 10652, 22, 69, 17, 0, -58 },
  { 10842, 13, 54, 25, 7, -50 },
  { 10930, 22, 69, 17, -4, -58 },
  { 11120, 21, 25, 26, 3, -50 },
  { 11186, 28, 5, 28, -4, 0 },
  { 11204, 12, 10, 21, 7, -53 },
  { 11219, 27, 40, 33, 2, -39 },
  { 11354, 30, 54, 34, 1, -53 },
  { 11557, 28, 40, 32, 2, -39 },
  { 11697, 33, 54, 34, 2, -53 },
  { 11920, 28, 40, 32, 2, -39 },
  { 12060, 24, 54, 22, 3, -54 },
  { 12222, 32, 53, 34, 0, -39 },
  { 12434, 29, 53, 33, 1, -53 },
  { 12627, 15, 51, 16, 1, -51 },
  { 12723, 23, 65, 15, -7, -51 },
  { 12910, 31, 53, 31, 1, -53 },
  { 13116, 16, 53, 16, 1, -53 },
  { 13222, 47, 39, 52, 1, -39 },
  { 13452, 29, 39, 33, 1, -39 },
  { 13594, 30, 40, 35, 2, -39 },
  { 13744, 33, 53, 34, -2, -39 },
  { 13963, 30, 53, 34, 2, -39 },
  { 14162, 21, 39, 21, 1, -39 },
  { 14265, 28, 40, 31, 1, -39 },
  { 14405, 18, 48, 20, 3, -47 },
  { 14513, 29, 39, 33, 3, -38 },
  { 14655, 27, 38, 29, 4, -38 },
  { 14784, 41, 38, 45, 5, -38 },
  { 14979, 33, 38, 30, -2, -38 },
  { 15136, 33, 52, 29, -3, -38 },
  { 15351, 30, 38, 30, 0, -38 },
  { 15494, 22, 68, 21, 2, -55 },
  { 15681, 15, 59, 17, 1, -50 },
  { 15792, 22, 68, 21, -3, -55 },
  { 15979, 34, 14, 41, 3, -28 },
};

const GFXfont RobotoCondensed_Italic71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_ITALIC71PT7B_H_
