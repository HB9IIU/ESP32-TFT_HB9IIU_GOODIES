#ifndef _ROBOTOCONDENSED_ITALIC43PT7B_H_
#define _ROBOTOCONDENSED_ITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x0F, 0x07, 0x81, 0xC0,
  0x39, 0xCE, 0x77, 0x1D, 0xC7, 0x71, 0x9C, 0xE6, 0x39, 0x8E, 0xE3, 0x38,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1C, 0x38, 0x00,
  0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x38,
  0x70, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3F,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0x83, 0xC1, 0xE1, 0xE0, 0x78,
  0x78, 0x0E, 0x1E, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF3,
  0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0x7C,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0x1C, 0x00, 0x60, 0xE0, 0xCE, 0x0E, 0x1C, 0xE0, 0xE1, 0xCE, 0x0E,
  0x38, 0xE0, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xCE, 0x07, 0xF9, 0xC0, 0x7F,
  0x38, 0x01, 0xE3, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x78, 0x03, 0x9F, 0xC0, 0x3B, 0xFE, 0x07, 0x38, 0x60, 0xE3, 0x07,
  0x1C, 0x70, 0x71, 0xC7, 0x07, 0x38, 0x70, 0x77, 0x07, 0x06, 0x70, 0x70,
  0xE2, 0x07, 0x0E, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3C, 0x78, 0x07, 0x83, 0x80,
  0x78, 0x38, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x07, 0x80, 0x70, 0xF0,
  0x07, 0x9F, 0x00, 0x7B, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x71, 0xEF, 0x0F, 0x3C, 0x78, 0xE7, 0x87,
  0x8E, 0x78, 0x3C, 0xE7, 0x03, 0xDE, 0xF0, 0x1F, 0xCF, 0x01, 0xFC, 0xF0,
  0x0F, 0x87, 0x00, 0xF0, 0x78, 0x0F, 0x87, 0xC3, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xBC, 0x07, 0xE1, 0xE0, 0x77, 0x77, 0xEE, 0xEE, 0xEC, 0x00, 0x08,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x01, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0x07,
  0x0D, 0xE3, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFC, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xF3, 0x80, 0xF1, 0xE0, 0xF0, 0x70, 0x30, 0x38,
  0x08, 0x08, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7,
  0x8E, 0x3C, 0xF1, 0xC1, 0x00, 0xFF, 0xFF, 0xBF, 0xC0, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x1C, 0x70,
  0x0E, 0x78, 0x07, 0x3C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEF, 0x00, 0x77,
  0x80, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0xB8, 0x03,
  0xBC, 0x01, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x39, 0xE0,
  0x1C, 0xF0, 0x1E, 0x78, 0x0E, 0x1C, 0x0F, 0x0F, 0x0F, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x9F, 0xF7, 0xFD, 0xFB,
  0xB8, 0x74, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xE0,
  0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3E, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x3C, 0xF0,
  0x0F, 0x1C, 0x03, 0x87, 0x81, 0xE1, 0xF1, 0xF0, 0x3F, 0xF8, 0x07, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7B,
  0xC0, 0x0E, 0x78, 0x03, 0xCE, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x07, 0x8F,
  0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C,
  0x1E, 0x07, 0x87, 0x80, 0xF0, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x7C, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x0E, 0x03, 0xC1, 0xE0, 0x78, 0x3E, 0x3E, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3D, 0xF8, 0x3B, 0xFC, 0x7F, 0xFE, 0x7F,
  0x1E, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78,
  0x3C, 0x3C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xC0, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xE3, 0xE0, 0x78, 0x3C, 0x1E,
  0x03, 0x83, 0xC0, 0x70, 0x78, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0F, 0x1E, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x03, 0x87, 0x80,
  0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x78, 0x3E, 0x1F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0x3E, 0x3C, 0x1E, 0x38,
  0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x3E, 0x7C,
  0x7E, 0x3F, 0xFE, 0x1F, 0xDC, 0x0F, 0x9C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0x78, 0x00, 0x06, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0,
  0xF8, 0xF8, 0x70, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x07,
  0x81, 0xC0, 0xF0, 0x18, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x03,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x60, 0x00, 0x40, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x0F, 0x01, 0xC3, 0x81, 0xFE, 0x06, 0x1C, 0x1F, 0xF8,
  0x31, 0xC1, 0xE1, 0xC1, 0x8E, 0x0E, 0x0E, 0x0C, 0xE0, 0xE0, 0x60, 0x67,
  0x07, 0x07, 0x03, 0x38, 0x70, 0x38, 0x1B, 0x83, 0x81, 0xC1, 0xDC, 0x1C,
  0x0E, 0x0E, 0xE1, 0xE0, 0xE0, 0x77, 0x0E, 0x07, 0x03, 0x38, 0x70, 0x38,
  0x19, 0x83, 0x81, 0xC1, 0xDC, 0x1C, 0x1C, 0x0E, 0xE0, 0xE0, 0xE0, 0x67,
  0x07, 0x0F, 0x07, 0x38, 0x3C, 0xF8, 0x71, 0xC1, 0xFE, 0xFF, 0x06, 0x07,
  0xE7, 0xF0, 0x30, 0x1E, 0x1F, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x08, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8E,
  0x00, 0x1E, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x00,
  0x78, 0x3C, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x1C, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x0E, 0x78,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0E, 0x07, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x38,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x70, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0x70, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xE0, 0x3F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x03, 0xC3,
  0xC0, 0x1E, 0x1F, 0x01, 0xE0, 0x7C, 0x3E, 0x01, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x0F, 0x0F, 0xC0, 0x70, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00,
  0x79, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C,
  0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x3E,
  0x1E, 0x03, 0xE0, 0xE0, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0xF8, 0x0F, 0x87,
  0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0xF3, 0x80, 0xFF, 0x9C, 0x07, 0xFD,
  0xE0, 0x01, 0xEF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8E, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0xF8, 0x7E, 0x3F, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E,
  0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0,
  0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x81,
  0xF0, 0x78, 0x1E, 0x07, 0xE7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x7C, 0x07,
  0x80, 0xF8, 0x07, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0F,
  0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x0E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xBC, 0x00, 0x3F, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x83, 0xB8, 0x00, 0xFE, 0x0E, 0xE0, 0x07, 0xF8, 0x3B,
  0x80, 0x1F, 0xE1, 0xEE, 0x00, 0x77, 0x87, 0xBC, 0x03, 0xDC, 0x1E, 0xF0,
  0x0E, 0x70, 0x79, 0xC0, 0x7B, 0xC1, 0xC7, 0x01, 0xCF, 0x07, 0x1C, 0x0F,
  0x3C, 0x3C, 0x70, 0x38, 0xF0, 0xF1, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x0E,
  0x0F, 0x1E, 0x3C, 0x78, 0x3C, 0x38, 0xE1, 0xE0, 0xE0, 0xE7, 0x87, 0x87,
  0x83, 0x9C, 0x1E, 0x1E, 0x0E, 0xF0, 0x70, 0x78, 0x3B, 0x83, 0xC1, 0xE0,
  0xFE, 0x0F, 0x07, 0x81, 0xF0, 0x3C, 0x1C, 0x07, 0xC0, 0xF0, 0xF0, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x0E, 0x0F, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0x81, 0xF0, 0x01, 0xC0, 0xF8, 0x01, 0xE0, 0x7C,
  0x00, 0xF0, 0x7F, 0x00, 0x78, 0x3F, 0x80, 0x3C, 0x1F, 0xC0, 0x1C, 0x0F,
  0xF0, 0x0E, 0x07, 0x38, 0x0F, 0x07, 0x9C, 0x07, 0x83, 0xCF, 0x03, 0xC1,
  0xE3, 0x81, 0xE0, 0xF1, 0xC0, 0xE0, 0x78, 0xF0, 0xF0, 0x38, 0x38, 0x78,
  0x3C, 0x1C, 0x3C, 0x1E, 0x0F, 0x1E, 0x0F, 0x03, 0x8F, 0x07, 0x81, 0xC7,
  0x03, 0xC0, 0xF7, 0x81, 0xC0, 0x3B, 0xC1, 0xE0, 0x1D, 0xE0, 0xF0, 0x0F,
  0xF0, 0x78, 0x03, 0xF8, 0x3C, 0x01, 0xF8, 0x1E, 0x00, 0xFC, 0x0E, 0x00,
  0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFC, 0xFC, 0x07, 0x80,
  0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x38,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xE0,
  0x00, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xC0, 0x01,
  0xE7, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xC7,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0xCF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xC0, 0x7E,
  0x07, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x00, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFD, 0xFC, 0x0F, 0x80, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x0E,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x70,
  0x00, 0x79, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0x70, 0x01, 0xC1,
  0xE0, 0x0F, 0x07, 0xC0, 0x78, 0x0F, 0xCF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0x07, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x1F, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x1C, 0x03, 0xC0,
  0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xC7, 0xC0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xC3, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C,
  0x1E, 0x03, 0xE0, 0xFE, 0x7E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x07, 0x80, 0xF8, 0x1F, 0x8F,
  0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x38,
  0x00, 0xF1, 0xC0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x0F, 0x00, 0xE0,
  0x78, 0x07, 0x83, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00,
  0x38, 0xF0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x03, 0xBC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3B,
  0xC0, 0x1E, 0x01, 0xEF, 0x00, 0xF8, 0x07, 0xBC, 0x03, 0xE0, 0x1C, 0xF0,
  0x0F, 0x80, 0xF3, 0xC0, 0x7E, 0x03, 0xC7, 0x01, 0xF8, 0x0E, 0x1C, 0x07,
  0xE0, 0x78, 0x70, 0x3B, 0x81, 0xE1, 0xC0, 0xEE, 0x07, 0x07, 0x07, 0xB8,
  0x3C, 0x1C, 0x1C, 0xE0, 0xF0, 0x70, 0x73, 0x83, 0x81, 0xC3, 0xCE, 0x1E,
  0x07, 0x0E, 0x38, 0x78, 0x1C, 0x38, 0xE1, 0xC0, 0x71, 0xC1, 0x8F, 0x01,
  0xC7, 0x07, 0x3C, 0x07, 0x3C, 0x1C, 0xE0, 0x1C, 0xE0, 0x77, 0x80, 0x73,
  0x81, 0xDC, 0x01, 0xDC, 0x07, 0x70, 0x07, 0x70, 0x1F, 0xC0, 0x1D, 0xC0,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0,
  0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07,
  0x80, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0x03,
  0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x38, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x1C, 0x3C, 0x01, 0xC3, 0xC0,
  0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x00, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07,
  0x07, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1,
  0xC7, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0xF0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x78, 0x78, 0x3C, 0x1C, 0x0E, 0x0E, 0x00, 0xF8, 0x01,
  0xFF, 0x03, 0xFF, 0xC1, 0xF3, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x01, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0,
  0xF3, 0xC0, 0x79, 0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x0F, 0x8F, 0x9F, 0xC7, 0xFF, 0xE1, 0xFE, 0xF0, 0x7C, 0x78, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE7, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFC, 0x7C, 0x1E, 0x07, 0x83, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1C,
  0x78, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x71,
  0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xF1, 0xF0, 0xEF, 0xFC, 0x1C, 0xFF, 0x03,
  0x8F, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF1, 0xE1, 0xE0,
  0x79, 0xE0, 0x1C, 0xF0, 0x0E, 0xF0, 0x07, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x70, 0x0E, 0x38, 0x07, 0x1E, 0x07, 0x8F, 0x8F, 0x83, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x1F, 0x1E, 0x07, 0xF9, 0xC0, 0xFF, 0xDC, 0x1F, 0x8F, 0xC1,
  0xE0, 0x7C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x38,
  0x78, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x07,
  0x0F, 0x00, 0x70, 0xF0, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x81,
  0xE0, 0x7C, 0x7E, 0x03, 0xFF, 0xE0, 0x1F, 0xEE, 0x00, 0xF9, 0xE0, 0x01,
  0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE1, 0xE0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x02, 0x1E, 0x03, 0x0F, 0x87, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xF9, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x01, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x3F,
  0xCE, 0x07, 0xFE, 0xE0, 0xFC, 0x7E, 0x0F, 0x03, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3,
  0x80, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x78, 0x03, 0x83, 0x80, 0x78,
  0x38, 0x07, 0x83, 0x80, 0x78, 0x3C, 0x0F, 0x83, 0xE3, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xCF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x06, 0x03, 0xC0, 0xF8, 0x7C, 0x0F, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xCF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xC7, 0x83, 0xC0, 0xF0,
  0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70,
  0x0E, 0x1C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07,
  0x8E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x00, 0xF1, 0xC0, 0x38, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x81, 0xF1, 0xE0, 0xF8, 0x78,
  0x3C, 0x1E, 0x1E, 0x07, 0x0F, 0x01, 0xC7, 0x80, 0xF3, 0xE0, 0x3D, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07,
  0xDE, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x1C, 0x1C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0E, 0x01, 0xE3, 0x80, 0x78, 0x07, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1E, 0x7C,
  0x0F, 0x81, 0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0x7F, 0xE1, 0xF8, 0xFF, 0x1F,
  0x1E, 0x07, 0xE0, 0xF1, 0xC0, 0x7C, 0x0F, 0x3C, 0x07, 0x80, 0xF3, 0xC0,
  0x78, 0x0F, 0x3C, 0x07, 0x80, 0xF3, 0x80, 0x78, 0x0F, 0x38, 0x07, 0x00,
  0xF7, 0x80, 0x70, 0x0E, 0x78, 0x0F, 0x00, 0xE7, 0x80, 0xF0, 0x1E, 0x78,
  0x0F, 0x01, 0xE7, 0x00, 0xF0, 0x1E, 0x70, 0x0E, 0x01, 0xEF, 0x00, 0xE0,
  0x1C, 0xF0, 0x1E, 0x01, 0xCF, 0x01, 0xE0, 0x3C, 0xF0, 0x1E, 0x03, 0xCE,
  0x01, 0xE0, 0x3C, 0xE0, 0x1C, 0x03, 0xC0, 0x0F, 0x3E, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x38, 0x07, 0x1E, 0x01, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x3E, 0x1E, 0x07, 0x8F, 0x00,
  0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D,
  0xC0, 0x0F, 0x70, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x1E, 0x70,
  0x07, 0x9E, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0xF8, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0x7E, 0x00, 0x07, 0x9F, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E,
  0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0E, 0x1E, 0x00, 0xE1,
  0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC3, 0xC0, 0x3C,
  0x3E, 0x07, 0xC3, 0xF0, 0xF8, 0x3F, 0xFF, 0x03, 0x9F, 0xE0, 0x38, 0xFC,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF1, 0xE0, 0xFF, 0x38, 0x3F, 0xF7, 0x0F, 0xC7, 0xE1, 0xE0, 0x7C, 0x78,
  0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xC0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x78, 0x3E, 0x1F, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xF3, 0xE1, 0xE0, 0xF1, 0xE0, 0x38, 0xF0, 0x1C, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F,
  0x0F, 0x8F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE1, 0xFF, 0xBF, 0xF7, 0xFE, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0xC1, 0xF8, 0x1F, 0x00,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x73, 0xC0,
  0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0x9E,
  0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1C,
  0x78, 0x1E, 0x3C, 0x1F, 0x1F, 0x1F, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x7C,
  0xE0, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x03, 0xDE, 0x0F,
  0x3C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07,
  0x1C, 0x0E, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x07,
  0xF0, 0x1E, 0x03, 0xB8, 0x0F, 0x03, 0xDC, 0x0F, 0x81, 0xCE, 0x07, 0xC1,
  0xE7, 0x87, 0xE0, 0xF3, 0xC3, 0xF0, 0x71, 0xE1, 0xF8, 0x78, 0xF1, 0xDC,
  0x38, 0x78, 0xEE, 0x1C, 0x3C, 0xF3, 0x9E, 0x0E, 0x71, 0xCE, 0x07, 0x78,
  0xEF, 0x03, 0xB8, 0x77, 0x01, 0xDC, 0x3B, 0x80, 0xFC, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0x80, 0xF8, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x01, 0xE0,
  0xF0, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x03, 0x87, 0x80, 0x38, 0xF0,
  0x03, 0xDE, 0x00, 0x1D, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7B,
  0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xC0, 0x1E, 0x1C, 0x03, 0xE1, 0xE0, 0x3C,
  0x1E, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x70, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x83,
  0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x38,
  0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xBC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0xF0, 0x07,
  0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x03, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x03, 0x3F, 0xE0, 0x77, 0xDF, 0x07, 0x70, 0xFD,
  0xEF, 0x07, 0xFE, 0xE0, 0x3F, 0xC0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 31, 10, 1, -31 },
  { 36, 10, 10, 13, 4, -32 },
  { 49, 21, 31, 23, 2, -31 },
  { 131, 18, 40, 21, 2, -36 },
  { 221, 20, 31, 26, 4, -31 },
  { 299, 20, 31, 23, 1, -31 },
  { 377, 4, 10, 7, 4, -32 },
  { 382, 13, 45, 13, 2, -35 },
  { 456, 13, 44, 13, -2, -34 },
  { 528, 17, 18, 18, 2, -31 },
  { 567, 18, 23, 21, 2, -26 },
  { 619, 7, 11, 8, -2, -5 },
  { 629, 9, 3, 10, 1, -14 },
  { 633, 5, 5, 11, 1, -5 },
  { 637, 19, 34, 15, -2, -31 },
  { 718, 17, 31, 21, 2, -31 },
  { 784, 11, 31, 21, 5, -31 },
  { 827, 20, 31, 21, 0, -31 },
  { 905, 18, 31, 21, 1, -31 },
  { 975, 19, 31, 21, 0, -31 },
  { 1049, 19, 31, 21, 2, -31 },
  { 1123, 16, 31, 21, 2, -31 },
  { 1185, 19, 31, 21, 3, -31 },
  { 1259, 19, 31, 21, 1, -31 },
  { 1333, 16, 31, 21, 3, -31 },
  { 1395, 8, 24, 10, 1, -24 },
  { 1419, 10, 30, 9, -2, -24 },
  { 1457, 15, 19, 19, 2, -23 },
  { 1493, 17, 11, 20, 2, -20 },
  { 1517, 17, 19, 19, 1, -23 },
  { 1558, 14, 31, 18, 4, -31 },
  { 1613, 29, 40, 32, 1, -30 },
  { 1758, 22, 31, 24, -1, -31 },
  { 1844, 21, 31, 23, 1, -31 },
  { 1926, 21, 31, 24, 2, -31 },
  { 2008, 21, 31, 24, 1, -31 },
  { 2090, 21, 31, 21, 1, -31 },
  { 2172, 21, 31, 20, 1, -31 },
  { 2254, 21, 31, 25, 2, -31 },
  { 2336, 25, 31, 26, 1, -31 },
  { 2433, 9, 31, 10, 1, -31 },
  { 2468, 20, 31, 20, 0, -31 },
  { 2546, 24, 31, 23, 1, -31 },
  { 2639, 16, 31, 20, 1, -31 },
  { 2701, 30, 31, 32, 1, -31 },
  { 2818, 25, 31, 26, 1, -31 },
  { 2915, 22, 31, 25, 2, -31 },
  { 3001, 22, 31, 23, 1, -31 },
  { 3087, 22, 36, 25, 2, -31 },
  { 3186, 21, 31, 22, 1, -31 },
  { 3268, 21, 31, 22, 1, -31 },
  { 3350, 20, 31, 22, 4, -31 },
  { 3428, 22, 31, 23, 2, -31 },
  { 3514, 21, 31, 23, 4, -31 },
  { 3596, 30, 31, 32, 4, -31 },
  { 3713, 25, 31, 23, -1, -31 },
  { 3810, 20, 31, 22, 4, -31 },
  { 3888, 23, 31, 22, 0, -31 },
  { 3978, 13, 42, 10, 0, -35 },
  { 4047, 8, 34, 15, 4, -31 },
  { 4081, 13, 42, 10, -2, -35 },
  { 4150, 12, 15, 15, 2, -31 },
  { 4173, 16, 3, 17, -2, 0 },
  { 4179, 8, 6, 13, 4, -32 },
  { 4185, 17, 23, 20, 1, -23 },
  { 4234, 19, 32, 21, 0, -32 },
  { 4310, 17, 23, 19, 1, -23 },
  { 4359, 20, 32, 21, 1, -32 },
  { 4439, 17, 23, 20, 1, -23 },
  { 4488, 14, 32, 13, 2, -32 },
  { 4544, 20, 32, 21, 0, -23 },
  { 4624, 18, 32, 20, 0, -32 },
  { 4696, 9, 31, 10, 1, -31 },
  { 4731, 13, 41, 9, -4, -32 },
  { 4798, 18, 32, 19, 1, -32 },
  { 4870, 9, 32, 10, 1, -32 },
  { 4906, 28, 23, 31, 1, -23 },
  { 4987, 18, 23, 20, 0, -23 },
  { 5039, 18, 23, 21, 1, -23 },
  { 5091, 20, 32, 21, -1, -23 },
  { 5171, 19, 32, 21, 1, -23 },
  { 5247, 14, 23, 13, 0, -23 },
  { 5288, 17, 23, 19, 1, -23 },
  { 5337, 11, 28, 12, 2, -28 },
  { 5376, 17, 23, 20, 2, -23 },
  { 5425, 15, 23, 18, 3, -23 },
  { 5469, 25, 23, 27, 3, -23 },
  { 5541, 20, 23, 18, -1, -23 },
  { 5599, 20, 32, 17, -2, -23 },
  { 5679, 18, 23, 18, 0, -23 },
  { 5731, 14, 42, 13, 1, -34 },
  { 5805, 8, 37, 10, 1, -31 },
  { 5842, 14, 42, 13, -2, -34 },
  { 5916, 20, 8, 25, 2, -16 },
};

const GFXfont RobotoCondensed_Italic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_ITALIC43PT7B_H_
