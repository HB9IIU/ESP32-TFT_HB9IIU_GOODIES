#ifndef _ROBOTOCONDENSED_ITALIC61PT7B_H_
#define _ROBOTOCONDENSED_ITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x02, 0x00, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x7D, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1,
  0xC7, 0x0F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xE3, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x10, 0x78, 0x1E, 0x01, 0x8F, 0x01,
  0xE0, 0x3C, 0xF0, 0x1E, 0x07, 0xCF, 0x01, 0xE0, 0x78, 0xF0, 0x1E, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0x1C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0x3C, 0x78, 0x0F, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0xF0, 0x07, 0xFF, 0x1E,
  0x00, 0x3F, 0xE3, 0xE0, 0x01, 0xFC, 0x3C, 0x00, 0x02, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x78, 0xFF, 0x80, 0x0F, 0x1F, 0xFC,
  0x01, 0xF3, 0xE3, 0xE0, 0x1E, 0x3C, 0x1E, 0x03, 0xC7, 0x80, 0xE0, 0x7C,
  0x78, 0x0E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x78, 0x0E, 0x1E, 0x07, 0x00,
  0xE1, 0xE0, 0x70, 0x1E, 0x3C, 0x0F, 0x01, 0xE7, 0x80, 0x70, 0x1E, 0x78,
  0x07, 0x81, 0xE3, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF3, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x81, 0xF1, 0xFD, 0xF8, 0x1E, 0x3F, 0x8F, 0xC1, 0xE3, 0xF0,
  0xFC, 0x3E, 0x7E, 0x07, 0xE3, 0xE7, 0xC0, 0x7E, 0x3E, 0xFC, 0x03, 0xF7,
  0xCF, 0xC0, 0x1F, 0x7C, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x0F, 0xF8, 0xF8,
  0x00, 0xFF, 0x0F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0xF8, 0x0F, 0xFF, 0xCF, 0xC0, 0x7F, 0xF0, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3,
  0x8F, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x1E, 0x03, 0x7C,
  0x1E, 0x1F, 0x7F, 0x9E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xCF, 0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x87, 0x80, 0x3F,
  0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1C, 0x03, 0x80, 0x08,
  0x01, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x1C, 0x02,
  0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x7B, 0xFF,
  0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3F, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7F, 0x3E, 0x7C, 0x7C, 0xF0, 0x7C, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC1, 0xF8,
  0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x0D, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x81, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x0F, 0xC1, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x1F, 0x7F, 0xE0, 0x7D, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xCF, 0xF0, 0x0F,
  0x9F, 0xC0, 0x1F, 0x3F, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81,
  0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xF7, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F,
  0x0F, 0xC1, 0xF0, 0x1F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F,
  0xBF, 0x00, 0xFE, 0x7E, 0x0F, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xF9, 0xF0, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xC0, 0x10, 0x00,
  0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1E,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xF8, 0xFE, 0x7F, 0x03, 0xF7,
  0xE0, 0x3F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x3F, 0x00, 0x38, 0x1F,
  0x00, 0x7F, 0xE0, 0x1C, 0x0F, 0x00, 0x7F, 0xF8, 0x0F, 0x0F, 0x80, 0x7F,
  0xFE, 0x07, 0x87, 0x80, 0x7C, 0x0F, 0x03, 0xC3, 0xC0, 0x7C, 0x0F, 0x01,
  0xE3, 0xC0, 0x3C, 0x07, 0x80, 0xF1, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x3C, 0x0F, 0x80, 0x78, 0x07, 0xBC, 0x07, 0xC0, 0x3C, 0x03,
  0xDE, 0x03, 0xC0, 0x3E, 0x01, 0xCF, 0x01, 0xE0, 0x1E, 0x00, 0xE7, 0x81,
  0xF0, 0x0F, 0x00, 0x73, 0xC0, 0xF8, 0x07, 0x80, 0x7B, 0xC0, 0x78, 0x07,
  0xC0, 0x3D, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0xF0, 0x1E, 0x01, 0xE0, 0x0E,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x3C, 0x07, 0x80, 0xF8, 0x07, 0x1E, 0x07,
  0xC0, 0x7C, 0x03, 0x8F, 0x01, 0xE0, 0x3E, 0x03, 0xC7, 0x80, 0xF0, 0x3F,
  0x03, 0xC3, 0xC0, 0x7C, 0x3F, 0x81, 0xE1, 0xE0, 0x3F, 0xFB, 0xC3, 0xE0,
  0xF0, 0x1F, 0xFD, 0xFF, 0xE0, 0x78, 0x07, 0xFC, 0x7F, 0xE0, 0x3C, 0x01,
  0xFC, 0x1F, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20,
  0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x3F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xFF, 0x9F, 0x00, 0x7F, 0xFC, 0x7C, 0x01, 0xFF, 0xF1,
  0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x1F, 0xFF, 0x3F, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F,
  0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x00, 0xF9, 0xFC,
  0x00, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xDF, 0x00, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x03, 0xFC, 0x7E, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x00, 0xF9, 0xF8, 0x07,
  0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x01, 0xF8, 0x3C, 0x0F, 0x83, 0xE0, 0x1F, 0x83, 0xC0, 0xF8, 0x3E,
  0x01, 0xF0, 0x3E, 0x1F, 0x07, 0xE0, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x01,
  0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x03, 0xF0,
  0x1E, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xE7, 0xC0, 0x7C, 0x03, 0xE0, 0x1E,
  0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xEF, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x0F,
  0x80, 0x7E, 0x00, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x7C, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x01, 0xF0, 0x1F,
  0xE0, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x01, 0xF0,
  0x0F, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x7F, 0xE0, 0x00,
  0xF8, 0x0F, 0xBE, 0x00, 0x3F, 0x01, 0xF7, 0xC0, 0x07, 0xC0, 0x3E, 0x78,
  0x00, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x01, 0xF9, 0xF0, 0x03, 0xE0, 0x3F,
  0x1E, 0x00, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE0,
  0x1F, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xFC, 0x1F, 0x01,
  0xF0, 0x1F, 0x81, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x07,
  0xC1, 0xF0, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xF0, 0x0F, 0x87, 0xC0, 0x7E,
  0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0x1E, 0x3F, 0x01, 0xF0, 0x03, 0xE7, 0xE0,
  0x3E, 0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x07, 0x9F, 0x01, 0xF8, 0x00, 0xFB,
  0xE0, 0x3F, 0x00, 0x1F, 0xFC, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x07, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x18,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F,
  0x01, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xE0,
  0x01, 0xFB, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x3E, 0x00, 0x3F, 0x80, 0x0F, 0xCF, 0x80, 0x0F, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xFF, 0x00, 0x7E, 0x3E, 0x00, 0x7B,
  0xC0, 0x1F, 0x0F, 0xC0, 0x1E, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0xBC, 0x03,
  0xF0, 0x7C, 0x03, 0xCF, 0x00, 0xF8, 0x1F, 0x01, 0xF3, 0xC0, 0x3E, 0x07,
  0xC0, 0x7C, 0xF0, 0x1F, 0x81, 0xF0, 0x1E, 0x3C, 0x07, 0xC0, 0x7C, 0x0F,
  0x8F, 0x01, 0xF0, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x07, 0xC0, 0xF0, 0xF0,
  0x3E, 0x01, 0xF0, 0x7C, 0x3C, 0x0F, 0x80, 0x7C, 0x1E, 0x0F, 0x07, 0xC0,
  0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x01, 0xF0,
  0xF0, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x03,
  0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x1E, 0x7C,
  0x00, 0x7C, 0xF0, 0x07, 0x9F, 0x00, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x07,
  0xDE, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0x80, 0x1E, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFB,
  0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xFE, 0x1F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xFC, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0xC0, 0x7C, 0xF0,
  0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x3E,
  0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0xF8, 0x07, 0xBE, 0x01,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x01, 0xF3,
  0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x8F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7C, 0x1F, 0xFC,
  0xF8, 0x1F, 0xF1, 0xF0, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0x80, 0x1F, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xF8, 0x3F, 0x80, 0x7E,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xE0,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0xF0, 0xFF, 0x0F,
  0xBF, 0xFF, 0x83, 0xE7, 0xFF, 0xC0, 0xF8, 0xFF, 0xE0, 0x3E, 0x1F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7E, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0x87, 0xC0, 0x1F, 0xFC, 0xFC, 0x03, 0xFF, 0xEF, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xFC,
  0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0xF0, 0x00,
  0x7F, 0x8F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0x7F, 0xF0, 0x3E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x20, 0x7C, 0x00, 0x60, 0x7E, 0x00, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x7F, 0xF1, 0xF0, 0x0F, 0xFF,
  0x9E, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0x7C, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x02, 0x00, 0x1F, 0x80,
  0x30, 0x01, 0xF8, 0x07, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x40, 0x07, 0xC7, 0xF8, 0x07, 0xDF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xFE, 0x00,
  0xF8, 0x3F, 0x80, 0x1F, 0x0F, 0xE0, 0x03, 0xE3, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x40, 0x00, 0xC0,
  0x07, 0xCF, 0xF8, 0x0F, 0xF8, 0x07, 0xDF, 0xFC, 0x3F, 0xFC, 0x07, 0xFF,
  0xFE, 0x7F, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xF8,
  0x7F, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x07, 0xC7, 0xF8, 0x07, 0xDF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x3F, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F,
  0xE0, 0x01, 0xF7, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0x03,
  0xEF, 0xFF, 0xE0, 0x3E, 0x7F, 0xFC, 0x03, 0xE7, 0xFF, 0x80, 0x3E, 0x1F,
  0xF0, 0x03, 0xE0, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x3F, 0xE1, 0xF0, 0x1F, 0xFC, 0x7C, 0x1F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81,
  0xF8, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xF9, 0xF0, 0x00, 0x30, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0x01, 0xF3, 0xF0, 0x7D, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x3E, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x20, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0,
  0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFB, 0xE0, 0x1F, 0xF3, 0xE0, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xC7, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x7C, 0x03,
  0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x03,
  0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x07, 0xCF,
  0x80, 0x7F, 0x00, 0xF8, 0xF8, 0x07, 0xF0, 0x0F, 0x8F, 0x80, 0xFF, 0x01,
  0xF0, 0x78, 0x0F, 0xF0, 0x1F, 0x07, 0x81, 0xFF, 0x01, 0xF0, 0x78, 0x1F,
  0xF8, 0x3E, 0x07, 0x81, 0xEF, 0x83, 0xE0, 0x78, 0x3E, 0xF8, 0x3C, 0x07,
  0xC3, 0xCF, 0x87, 0xC0, 0x7C, 0x7C, 0x78, 0x7C, 0x07, 0xC7, 0x87, 0x8F,
  0x80, 0x7C, 0xF8, 0x78, 0xF8, 0x07, 0xCF, 0x07, 0x8F, 0x00, 0x7D, 0xF0,
  0x79, 0xF0, 0x07, 0xDF, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x7B, 0xE0, 0x07,
  0xFE, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x78, 0xFC, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC7,
  0xFF, 0x80, 0x1E, 0x3F, 0xFC, 0x01, 0xE3, 0xFF, 0xF0, 0x0F, 0x3F, 0x0F,
  0xC0, 0xF9, 0xF0, 0x3F, 0x0F, 0x8F, 0x00, 0xFF, 0xFC, 0xF8, 0x07, 0xFF,
  0xC7, 0xC0, 0x1F, 0xFC, 0x3C, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 44, 15, 2, -43 },
  { 67, 14, 15, 19, 6, -46 },
  { 94, 30, 43, 32, 3, -43 },
  { 256, 26, 57, 29, 2, -50 },
  { 442, 28, 45, 37, 6, -44 },
  { 600, 28, 45, 32, 2, -44 },
  { 758, 7, 14, 10, 5, -46 },
  { 771, 18, 63, 19, 3, -49 },
  { 913, 18, 63, 19, -3, -49 },
  { 1055, 24, 25, 26, 3, -43 },
  { 1130, 25, 32, 29, 3, -36 },
  { 1230, 10, 15, 12, -3, -7 },
  { 1249, 13, 5, 15, 1, -21 },
  { 1258, 6, 7, 16, 2, -6 },
  { 1264, 28, 47, 22, -3, -43 },
  { 1429, 25, 45, 29, 3, -44 },
  { 1570, 16, 43, 29, 7, -43 },
  { 1656, 27, 44, 29, 1, -44 },
  { 1805, 25, 45, 29, 2, -44 },
  { 1946, 27, 43, 29, 0, -43 },
  { 2092, 27, 44, 29, 3, -43 },
  { 2241, 23, 44, 29, 3, -43 },
  { 2368, 27, 43, 29, 4, -43 },
  { 2514, 26, 45, 29, 2, -44 },
  { 2661, 22, 44, 29, 5, -44 },
  { 2782, 12, 33, 14, 1, -32 },
  { 2832, 15, 40, 12, -3, -32 },
  { 2907, 23, 27, 26, 2, -33 },
  { 2985, 24, 17, 28, 3, -29 },
  { 3036, 23, 27, 27, 2, -33 },
  { 3114, 20, 45, 25, 5, -44 },
  { 3227, 41, 57, 46, 2, -43 },
  { 3520, 32, 43, 34, -2, -43 },
  { 3692, 30, 43, 32, 1, -43 },
  { 3854, 30, 45, 34, 3, -44 },
  { 4023, 31, 43, 34, 1, -43 },
  { 4190, 30, 43, 29, 1, -43 },
  { 4352, 30, 43, 28, 1, -43 },
  { 4514, 30, 45, 35, 3, -44 },
  { 4683, 36, 43, 37, 1, -43 },
  { 4877, 13, 43, 15, 2, -43 },
  { 4947, 29, 44, 29, 0, -43 },
  { 5107, 35, 43, 32, 1, -43 },
  { 5296, 23, 43, 28, 1, -43 },
  { 5420, 44, 43, 45, 1, -43 },
  { 5657, 35, 43, 37, 1, -43 },
  { 5846, 31, 45, 36, 3, -44 },
  { 6021, 32, 43, 33, 1, -43 },
  { 6193, 30, 51, 36, 3, -44 },
  { 6385, 30, 43, 31, 1, -43 },
  { 6547, 30, 45, 31, 1, -44 },
  { 6716, 29, 43, 31, 5, -43 },
  { 6872, 31, 44, 33, 3, -43 },
  { 7043, 31, 43, 33, 5, -43 },
  { 7210, 42, 43, 45, 6, -43 },
  { 7436, 36, 43, 33, -1, -43 },
  { 7630, 30, 43, 31, 5, -43 },
  { 7792, 32, 43, 31, 0, -43 },
  { 7964, 19, 59, 15, 0, -50 },
  { 8105, 11, 47, 22, 6, -43 },
  { 8170, 18, 59, 15, -3, -50 },
  { 8303, 18, 22, 22, 3, -43 },
  { 8353, 23, 5, 24, -3, 0 },
  { 8368, 11, 9, 18, 6, -46 },
  { 8381, 23, 34, 28, 2, -33 },
  { 8479, 26, 47, 29, 1, -46 },
  { 8632, 24, 34, 27, 2, -33 },
  { 8734, 28, 47, 29, 2, -46 },
  { 8899, 24, 34, 28, 2, -33 },
  { 9001, 20, 47, 19, 3, -47 },
  { 9119, 28, 45, 29, 0, -33 },
  { 9277, 24, 46, 29, 1, -46 },
  { 9415, 13, 43, 14, 1, -43 },
  { 9485, 19, 55, 13, -6, -43 },
  { 9616, 27, 46, 27, 1, -46 },
  { 9772, 13, 46, 14, 1, -46 },
  { 9847, 40, 33, 45, 1, -33 },
  { 10012, 24, 33, 29, 1, -33 },
  { 10111, 25, 34, 30, 2, -33 },
  { 10218, 28, 45, 29, -1, -33 },
  { 10376, 26, 45, 30, 2, -33 },
  { 10523, 18, 33, 18, 1, -33 },
  { 10598, 24, 34, 27, 1, -33 },
  { 10700, 16, 41, 18, 2, -40 },
  { 10782, 24, 33, 29, 3, -32 },
  { 10881, 22, 32, 25, 4, -32 },
  { 10969, 36, 32, 38, 4, -32 },
  { 11113, 28, 32, 26, -1, -32 },
  { 11225, 29, 44, 25, -3, -32 },
  { 11385, 26, 32, 26, 0, -32 },
  { 11489, 19, 59, 18, 2, -48 },
  { 11630, 12, 51, 14, 1, -43 },
  { 11707, 19, 59, 18, -3, -48 },
  { 11848, 29, 12, 35, 3, -24 },
};

const GFXfont RobotoCondensed_Italic61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_ITALIC61PT7B_H_
