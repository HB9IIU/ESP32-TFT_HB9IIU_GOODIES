#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0x7E,
  0x7E, 0x18, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC,
  0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9,
  0xE0, 0x3E, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x3C,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF9, 0xFE, 0xE7, 0xE3, 0xF1, 0xC0, 0xCF, 0xC3, 0x80,
  0x1F, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x1C, 0x00, 0xF8, 0x38, 0x01,
  0xF0, 0x70, 0x03, 0xE0, 0xE0, 0x07, 0xC1, 0xC0, 0x0F, 0xC3, 0x80, 0x0F,
  0xC7, 0x00, 0x1F, 0xCE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0E, 0xFF, 0x00, 0x1C, 0x7E, 0x00, 0x38, 0x7E, 0x00, 0x70,
  0x7C, 0x00, 0xE0, 0xF8, 0x01, 0xC1, 0xF0, 0x03, 0x83, 0xE0, 0x07, 0x07,
  0xC0, 0x0E, 0x0F, 0x80, 0x1C, 0x1F, 0x80, 0x38, 0x7D, 0xC0, 0x71, 0xFB,
  0xF0, 0xEF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x7C, 0x00,
  0x7C, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x7C,
  0x07, 0xC0, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x7C, 0x00, 0x07, 0x80,
  0xF0, 0xF0, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xFC, 0x1F, 0x07, 0xC7, 0xC3,
  0xFC, 0x3E, 0x0F, 0x8F, 0x0F, 0xFC, 0x3C, 0x1E, 0x1E, 0x3F, 0xFC, 0x78,
  0x3C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF1, 0xF0, 0xF8, 0xFF, 0xE3, 0xE3,
  0xC1, 0xF1, 0xFF, 0xC7, 0xC7, 0x81, 0xE1, 0xFF, 0x0F, 0x0F, 0x03, 0xC1,
  0xFC, 0x3E, 0x1E, 0x07, 0xC0, 0x40, 0x7C, 0x7C, 0x0F, 0x80, 0x00, 0xF0,
  0xF8, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x7C,
  0x00, 0x0F, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x00, 0x78,
  0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0x07, 0x80, 0x78, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x3C, 0x00, 0x3E,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x07, 0xC3,
  0xE0, 0x03, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0x07,
  0xEF, 0xC0, 0x7C, 0x3F, 0x1F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0xFC, 0x07, 0xE3, 0xE3, 0xF0, 0x0F,
  0xDF, 0x8F, 0xC0, 0x1F, 0x7E, 0x3F, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0xFF,
  0xC3, 0xF0, 0x03, 0xFE, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xFC, 0x1F,
  0xC0, 0xFF, 0xF0, 0x7F, 0xCF, 0xF7, 0xE0, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF,
  0xFC, 0x3F, 0x03, 0xFF, 0xE0, 0x7E, 0x07, 0xFE, 0x01, 0xFC, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x79,
  0xE7, 0x9E, 0x78, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x04, 0x07, 0x80, 0x9E, 0x1E, 0x1E,
  0x7F, 0xFB, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x07, 0xCF,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0x03, 0xC0,
  0x0C, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x38, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3,
  0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7E,
  0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xFC, 0x1F, 0x81, 0xFE,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF, 0x7F, 0x3F,
  0xFE, 0x3F, 0x7C, 0x3F, 0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3E, 0x03,
  0xF8, 0x38, 0x01, 0xFC, 0x10, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF,
  0xF8, 0x7C, 0x01, 0xFC, 0x38, 0x00, 0xFC, 0x10, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x80, 0x00, 0xFC, 0x60, 0x03, 0xFC, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x80, 0x00,
  0x7B, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0xF9, 0xF8,
  0x00, 0x1E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3C, 0x07, 0xE0, 0x0F, 0x80,
  0xFC, 0x01, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07,
  0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF9, 0x00, 0x07, 0xF3, 0x80, 0x1F, 0xC7, 0xE0,
  0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xDF, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE1,
  0xFC, 0x0F, 0x8F, 0xFC, 0x1F, 0x3F, 0xFC, 0x3E, 0xFF, 0xFC, 0x7D, 0xFF,
  0xFC, 0xFF, 0x83, 0xF9, 0xFE, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x03,
  0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7,
  0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x7E,
  0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFE,
  0x7F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0xFE,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x7E,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0x3F, 0x81, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3E,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xFC, 0x1F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0x81, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0x3E, 0x07, 0xFF, 0x3E, 0x03,
  0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x18, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0x1F, 0x07, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFE, 0xFF, 0x9C, 0x03, 0xF1, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x78, 0x01, 0xFE, 0x03, 0xC3, 0xE0, 0x1F, 0xFE, 0x0F, 0x0F,
  0x80, 0xFF, 0xF8, 0x3E, 0x3C, 0x07, 0xFF, 0xE0, 0xF9, 0xF0, 0x1F, 0x0F,
  0x81, 0xE7, 0xC0, 0xF8, 0x3E, 0x07, 0x9F, 0x03, 0xC0, 0xF8, 0x1E, 0x78,
  0x1F, 0x03, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x81, 0xF7, 0x81, 0xE0, 0x3E,
  0x07, 0xFE, 0x07, 0x80, 0xF8, 0x1F, 0xF8, 0x1E, 0x03, 0xC0, 0x7F, 0xE0,
  0xF8, 0x0F, 0x01, 0xFF, 0x83, 0xE0, 0x3C, 0x07, 0xFE, 0x0F, 0x80, 0xF0,
  0x1E, 0xF8, 0x3E, 0x07, 0xC0, 0x7B, 0xE0, 0xF8, 0x1F, 0x01, 0xEF, 0x83,
  0xE0, 0x7C, 0x07, 0xBE, 0x07, 0x81, 0xF0, 0x1E, 0xF8, 0x1E, 0x07, 0xC0,
  0xFB, 0xE0, 0x78, 0x1F, 0x03, 0xC7, 0x81, 0xF0, 0xEE, 0x0F, 0x1E, 0x07,
  0xC3, 0xB8, 0x7C, 0x78, 0x0F, 0xFE, 0xFF, 0xE1, 0xF0, 0x3F, 0xF3, 0xFF,
  0x87, 0xC0, 0x7F, 0x87, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x00,
  0x03, 0xF8, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0xFC,
  0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xF8, 0xFC,
  0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC,
  0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xE0, 0x1C, 0x1F, 0xC0, 0x02, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x60, 0x3F,
  0xF3, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x03,
  0xFF, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x07,
  0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F, 0xC0,
  0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0x01, 0xFC, 0x00, 0x0C,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFF, 0x00, 0x0F, 0xC1,
  0xFE, 0x00, 0x3F, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xF0, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xDF, 0x80,
  0x1F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xEF, 0x80, 0x00, 0x3D, 0xFF,
  0xBE, 0x00, 0x01, 0xF7, 0xFE, 0xF8, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00,
  0x1F, 0x7F, 0xE7, 0xC0, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x03, 0xE7, 0xFE,
  0x7C, 0x00, 0x0F, 0x9F, 0xF8, 0xF8, 0x00, 0x3C, 0x7F, 0xE3, 0xE0, 0x01,
  0xF1, 0xFF, 0x8F, 0x80, 0x07, 0xC7, 0xFE, 0x3E, 0x00, 0x1F, 0x1F, 0xF8,
  0x7C, 0x00, 0x78, 0x7F, 0xE1, 0xF0, 0x03, 0xE1, 0xFF, 0x87, 0xC0, 0x0F,
  0x87, 0xFE, 0x0F, 0x80, 0x3C, 0x1F, 0xF8, 0x3E, 0x01, 0xF0, 0x7F, 0xE0,
  0xF8, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x1F, 0x07, 0xFE, 0x07, 0xC0, 0x78,
  0x1F, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0x80,
  0xF0, 0x3E, 0x07, 0xFE, 0x03, 0xE1, 0xF0, 0x1F, 0xF8, 0x0F, 0x87, 0xC0,
  0x7F, 0xE0, 0x3E, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x78, 0x07, 0xFE, 0x01,
  0xF3, 0xE0, 0x1F, 0xF8, 0x07, 0xCF, 0x80, 0x7F, 0xE0, 0x0F, 0x3E, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFB,
  0xE0, 0x01, 0xFF, 0xBF, 0x00, 0x1F, 0xF9, 0xF0, 0x01, 0xFF, 0x9F, 0x00,
  0x1F, 0xF9, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0xFC, 0x01, 0xFF,
  0x87, 0xC0, 0x1F, 0xF8, 0x7E, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3E,
  0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF8, 0x1F,
  0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xFC, 0x1F, 0xF8, 0x0F, 0xC1, 0xFF, 0x80,
  0x7C, 0x1F, 0xF8, 0x07, 0xE1, 0xFF, 0x80, 0x3E, 0x1F, 0xF8, 0x03, 0xF1,
  0xFF, 0x80, 0x1F, 0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0x80, 0x1F, 0x9F, 0xF8,
  0x00, 0xF9, 0xFF, 0x80, 0x0F, 0xDF, 0xF8, 0x00, 0x7D, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x81, 0xFF, 0x3F, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03,
  0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0xFE, 0x7E, 0x03, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7,
  0xF8, 0x0F, 0x1F, 0xC0, 0x04, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE8, 0x00, 0x3F, 0xBC, 0x01, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0xEF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x78, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x78, 0x00, 0xF8, 0x1F,
  0x80, 0x1E, 0x78, 0x00, 0xF8, 0x1F, 0x80, 0x1E, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x0F,
  0x80, 0x3E, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x3C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3C, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x07,
  0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x07,
  0xE0, 0x7C, 0x1E, 0x03, 0xE0, 0x07, 0xE0, 0x78, 0x1F, 0x07, 0xE0, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0x03,
  0xF0, 0xF0, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x01, 0xF9, 0xE0, 0x07, 0x9F, 0x80, 0x00,
  0xF9, 0xE0, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x00,
  0xFB, 0xC0, 0x03, 0xDF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xDF, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE1,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x0F,
  0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF8,
  0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xE7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE7, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE1, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3C, 0x0F, 0xC0, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFC, 0x3F, 0x3F, 0x80, 0xFD, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF7, 0xC0, 0x1F, 0xDF,
  0x80, 0xFF, 0x7F, 0x07, 0x7C, 0xFF, 0xFD, 0xF3, 0xFF, 0xE7, 0xC7, 0xFF,
  0x1F, 0x0F, 0xF8, 0x7C, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x04, 0x00, 0xFC, 0x3F, 0xC0, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF,
  0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xE3, 0xFC, 0xFF, 0x80, 0xFC, 0xFF, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3E, 0xFE, 0x00, 0x3E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0x7E, 0xFF, 0x80,
  0xFC, 0xFF, 0xC1, 0xFC, 0xFB, 0xFF, 0xF8, 0xF9, 0xFF, 0xF0, 0xF8, 0xFF,
  0xF0, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF8,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xC3, 0x8F, 0xE0, 0x11,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0x3F,
  0xC1, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x3F, 0x03,
  0xFC, 0x3F, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xC7, 0xFF, 0x3F, 0x01, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x01, 0xFF, 0x3F, 0x83, 0xDF, 0x1F,
  0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x03, 0xFE, 0x1F, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x3E,
  0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x06, 0x1F, 0xC0, 0x78, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F,
  0x1F, 0xFF, 0x9F, 0x3F, 0xC7, 0xDF, 0x3F, 0x01, 0xFF, 0x7F, 0x00, 0xFF,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7F,
  0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x01, 0xFF,
  0x3F, 0xC3, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F,
  0x03, 0xFC, 0x3F, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x20, 0x00, 0xFC, 0x38, 0x03, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xE0, 0x3F, 0x1F, 0xF0, 0xFC,
  0xFF, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xBE, 0xF8, 0xFE, 0xFF, 0x81,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0,
  0x11, 0xEF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x80, 0x78, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0,
  0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFB, 0xFE, 0x03, 0xFE, 0xF8, 0x0F, 0xF3, 0xF0, 0x3F, 0xCF, 0xC0,
  0xFE, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xF8, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x0E, 0x07, 0xC3, 0xFE, 0x03, 0xFC, 0x3E, 0x3F, 0xF8, 0x7F, 0xF9, 0xF3,
  0xFF, 0xE3, 0xFF, 0xCF, 0xBF, 0xFF, 0x3F, 0xFF, 0x7D, 0xE3, 0xFB, 0xE3,
  0xFB, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFE, 0x00,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x80,
  0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x00, 0x0E, 0x03, 0xE1, 0xFF, 0x0F, 0x8F, 0xFE, 0x3E, 0x7F, 0xFC,
  0xFB, 0xFF, 0xFB, 0xEF, 0x0F, 0xEF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC3,
  0xF8, 0x3F, 0x01, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0xF8, 0x7F, 0xC0, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF,
  0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xC1, 0xFC, 0xFF, 0x80, 0xFC, 0xFF, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFE, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0x7E, 0xFF, 0x80,
  0xFC, 0xFF, 0xC3, 0xFC, 0xFD, 0xFF, 0xF8, 0xFD, 0xFF, 0xF0, 0xFC, 0xFF,
  0xE0, 0xFC, 0x3F, 0xC0, 0xFC, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF,
  0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0x9F, 0x3F, 0xC7, 0xDF, 0x3F, 0x01,
  0xFF, 0x7E, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7C, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0xFF, 0x3F, 0x01, 0xFF, 0x3F, 0xC3, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0xBF, 0x0F, 0xFF, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0x60, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF8, 0xFE, 0xF9, 0xFE, 0xFB, 0xFE, 0xFB, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x0F, 0x1F,
  0x00, 0x27, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xA0, 0x01, 0xF7, 0x00,
  0x7E, 0xFC, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF,
  0xC0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF1, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0x07, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x01,
  0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0xDF, 0xE3, 0xFF, 0x3F, 0xFF, 0x7C,
  0x7F, 0xF8, 0xF1, 0xFF, 0xE3, 0xC3, 0xFE, 0x0F, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x03,
  0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xF0, 0x03, 0xE7,
  0xC0, 0x1F, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0xC0, 0x1F, 0x9F, 0x00, 0x7F,
  0xC0, 0x3F, 0x3F, 0x00, 0xF7, 0x80, 0x7C, 0x7E, 0x01, 0xEF, 0x00, 0xF8,
  0x7C, 0x07, 0xDE, 0x01, 0xF0, 0xF8, 0x0F, 0xBC, 0x07, 0xE1, 0xF0, 0x1E,
  0x7C, 0x0F, 0x83, 0xF0, 0x3C, 0xF8, 0x1F, 0x07, 0xE0, 0xF9, 0xF0, 0x3E,
  0x07, 0xC1, 0xF1, 0xE0, 0x7C, 0x0F, 0x83, 0xE3, 0xC1, 0xF8, 0x1F, 0x07,
  0xC7, 0xC3, 0xE0, 0x3F, 0x0F, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x1F, 0x0F,
  0x80, 0x7C, 0x7C, 0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x3C, 0x7C, 0x01, 0xF1,
  0xE0, 0x7C, 0xF8, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x03, 0xE7, 0x81, 0xF3,
  0xE0, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x0F, 0xBE, 0x03, 0xCF, 0x00, 0x1F,
  0x78, 0x07, 0xBE, 0x00, 0x3E, 0xF0, 0x0F, 0xFC, 0x00, 0x3D, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F,
  0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0xC0,
  0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3F, 0x03,
  0xE0, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xCF, 0xC0, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x03,
  0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00,
  0x3F, 0xFD, 0x00, 0x07, 0xF8, 0x80, 0x00, 0x20, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 49, 16, 4, -48 },
  { 50, 18, 17, 25, 4, -48 },
  { 89, 29, 48, 31, 1, -48 },
  { 263, 23, 55, 29, 3, -51 },
  { 422, 39, 50, 44, 3, -49 },
  { 666, 30, 50, 32, 2, -49 },
  { 854, 6, 17, 14, 4, -48 },
  { 867, 15, 59, 20, 3, -48 },
  { 978, 14, 59, 20, 2, -48 },
  { 1082, 22, 22, 27, 2, -51 },
  { 1143, 25, 31, 29, 2, -39 },
  { 1240, 10, 17, 15, 2, -8 },
  { 1262, 15, 6, 18, 2, -21 },
  { 1274, 7, 9, 15, 4, -8 },
  { 1282, 23, 48, 25, 1, -48 },
  { 1420, 23, 50, 29, 3, -49 },
  { 1564, 16, 48, 29, 4, -48 },
  { 1660, 24, 49, 29, 2, -49 },
  { 1807, 24, 50, 29, 2, -49 },
  { 1957, 27, 48, 29, 1, -48 },
  { 2119, 23, 49, 29, 3, -48 },
  { 2260, 23, 50, 29, 3, -49 },
  { 2404, 24, 48, 29, 2, -48 },
  { 2548, 25, 50, 29, 2, -49 },
  { 2705, 24, 50, 29, 2, -49 },
  { 2855, 7, 37, 15, 4, -36 },
  { 2888, 10, 45, 15, 2, -36 },
  { 2945, 25, 30, 29, 2, -39 },
  { 3039, 25, 19, 29, 2, -33 },
  { 3099, 25, 30, 29, 2, -39 },
  { 3193, 19, 50, 21, 1, -49 },
  { 3312, 38, 54, 44, 3, -48 },
  { 3569, 30, 48, 30, 0, -48 },
  { 3749, 24, 48, 32, 5, -48 },
  { 3893, 25, 50, 30, 3, -49 },
  { 4050, 26, 48, 35, 5, -48 },
  { 4206, 19, 48, 27, 5, -48 },
  { 4320, 19, 48, 25, 5, -48 },
  { 4434, 30, 50, 37, 3, -49 },
  { 4622, 26, 48, 36, 5, -48 },
  { 4778, 15, 48, 19, 2, -48 },
  { 4868, 13, 61, 15, -3, -48 },
  { 4968, 25, 48, 30, 5, -48 },
  { 5118, 19, 48, 25, 5, -48 },
  { 5232, 38, 48, 48, 5, -48 },
  { 5460, 28, 48, 38, 5, -48 },
  { 5628, 31, 50, 37, 3, -49 },
  { 5822, 23, 48, 30, 5, -48 },
  { 5960, 31, 60, 37, 3, -49 },
  { 6193, 25, 48, 31, 5, -48 },
  { 6343, 22, 50, 28, 3, -49 },
  { 6481, 24, 48, 26, 1, -48 },
  { 6625, 26, 49, 35, 4, -48 },
  { 6785, 30, 48, 30, 0, -48 },
  { 6965, 48, 48, 48, 0, -48 },
  { 7253, 26, 48, 27, 0, -48 },
  { 7409, 26, 48, 26, 0, -48 },
  { 7565, 21, 48, 24, 2, -48 },
  { 7691, 14, 59, 21, 5, -48 },
  { 7795, 23, 48, 25, 1, -48 },
  { 7933, 14, 59, 21, 2, -48 },
  { 8037, 28, 26, 30, 1, -48 },
  { 8128, 29, 4, 29, 0, 6 },
  { 8143, 12, 10, 18, 3, -51 },
  { 8158, 22, 38, 28, 2, -37 },
  { 8263, 24, 52, 31, 4, -51 },
  { 8419, 19, 38, 23, 3, -37 },
  { 8510, 24, 52, 31, 3, -51 },
  { 8666, 22, 38, 28, 3, -37 },
  { 8771, 17, 51, 17, 1, -51 },
  { 8880, 24, 53, 31, 3, -37 },
  { 9039, 22, 51, 31, 4, -51 },
  { 9180, 6, 50, 14, 4, -50 },
  { 9218, 11, 66, 14, -1, -50 },
  { 9309, 22, 51, 27, 4, -51 },
  { 9450, 6, 51, 14, 4, -51 },
  { 9489, 37, 37, 46, 4, -37 },
  { 9661, 22, 37, 31, 4, -37 },
  { 9763, 24, 38, 30, 3, -37 },
  { 9877, 24, 53, 31, 4, -37 },
  { 10036, 24, 53, 31, 3, -37 },
  { 10195, 16, 37, 20, 4, -37 },
  { 10269, 19, 38, 23, 2, -37 },
  { 10360, 15, 45, 17, 1, -44 },
  { 10445, 22, 37, 31, 4, -36 },
  { 10547, 25, 36, 25, 0, -36 },
  { 10660, 39, 36, 41, 1, -36 },
  { 10836, 23, 36, 25, 1, -36 },
  { 10940, 25, 52, 25, 0, -36 },
  { 11103, 17, 36, 20, 2, -36 },
  { 11180, 18, 59, 24, 3, -48 },
  { 11313, 5, 67, 27, 11, -51 },
  { 11355, 18, 59, 24, 3, -48 },
  { 11488, 25, 9, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Regular67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR67PT7B_H_
