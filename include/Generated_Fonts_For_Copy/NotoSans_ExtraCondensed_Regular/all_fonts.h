#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_Regular
// Headers: 67

#include "NotoSans_ExtraCondensed_Regular6pt7b.h"
#include "NotoSans_ExtraCondensed_Regular7pt7b.h"
#include "NotoSans_ExtraCondensed_Regular8pt7b.h"
#include "NotoSans_ExtraCondensed_Regular9pt7b.h"
#include "NotoSans_ExtraCondensed_Regular10pt7b.h"
#include "NotoSans_ExtraCondensed_Regular11pt7b.h"
#include "NotoSans_ExtraCondensed_Regular12pt7b.h"
#include "NotoSans_ExtraCondensed_Regular13pt7b.h"
#include "NotoSans_ExtraCondensed_Regular14pt7b.h"
#include "NotoSans_ExtraCondensed_Regular15pt7b.h"
#include "NotoSans_ExtraCondensed_Regular16pt7b.h"
#include "NotoSans_ExtraCondensed_Regular17pt7b.h"
#include "NotoSans_ExtraCondensed_Regular18pt7b.h"
#include "NotoSans_ExtraCondensed_Regular19pt7b.h"
#include "NotoSans_ExtraCondensed_Regular20pt7b.h"
#include "NotoSans_ExtraCondensed_Regular21pt7b.h"
#include "NotoSans_ExtraCondensed_Regular22pt7b.h"
#include "NotoSans_ExtraCondensed_Regular23pt7b.h"
#include "NotoSans_ExtraCondensed_Regular24pt7b.h"
#include "NotoSans_ExtraCondensed_Regular25pt7b.h"
#include "NotoSans_ExtraCondensed_Regular26pt7b.h"
#include "NotoSans_ExtraCondensed_Regular27pt7b.h"
#include "NotoSans_ExtraCondensed_Regular28pt7b.h"
#include "NotoSans_ExtraCondensed_Regular29pt7b.h"
#include "NotoSans_ExtraCondensed_Regular30pt7b.h"
#include "NotoSans_ExtraCondensed_Regular31pt7b.h"
#include "NotoSans_ExtraCondensed_Regular32pt7b.h"
#include "NotoSans_ExtraCondensed_Regular33pt7b.h"
#include "NotoSans_ExtraCondensed_Regular34pt7b.h"
#include "NotoSans_ExtraCondensed_Regular35pt7b.h"
#include "NotoSans_ExtraCondensed_Regular36pt7b.h"
#include "NotoSans_ExtraCondensed_Regular37pt7b.h"
#include "NotoSans_ExtraCondensed_Regular38pt7b.h"
#include "NotoSans_ExtraCondensed_Regular39pt7b.h"
#include "NotoSans_ExtraCondensed_Regular40pt7b.h"
#include "NotoSans_ExtraCondensed_Regular41pt7b.h"
#include "NotoSans_ExtraCondensed_Regular42pt7b.h"
#include "NotoSans_ExtraCondensed_Regular43pt7b.h"
#include "NotoSans_ExtraCondensed_Regular44pt7b.h"
#include "NotoSans_ExtraCondensed_Regular45pt7b.h"
#include "NotoSans_ExtraCondensed_Regular46pt7b.h"
#include "NotoSans_ExtraCondensed_Regular47pt7b.h"
#include "NotoSans_ExtraCondensed_Regular48pt7b.h"
#include "NotoSans_ExtraCondensed_Regular49pt7b.h"
#include "NotoSans_ExtraCondensed_Regular50pt7b.h"
#include "NotoSans_ExtraCondensed_Regular51pt7b.h"
#include "NotoSans_ExtraCondensed_Regular52pt7b.h"
#include "NotoSans_ExtraCondensed_Regular53pt7b.h"
#include "NotoSans_ExtraCondensed_Regular54pt7b.h"
#include "NotoSans_ExtraCondensed_Regular55pt7b.h"
#include "NotoSans_ExtraCondensed_Regular56pt7b.h"
#include "NotoSans_ExtraCondensed_Regular57pt7b.h"
#include "NotoSans_ExtraCondensed_Regular58pt7b.h"
#include "NotoSans_ExtraCondensed_Regular59pt7b.h"
#include "NotoSans_ExtraCondensed_Regular60pt7b.h"
#include "NotoSans_ExtraCondensed_Regular61pt7b.h"
#include "NotoSans_ExtraCondensed_Regular62pt7b.h"
#include "NotoSans_ExtraCondensed_Regular63pt7b.h"
#include "NotoSans_ExtraCondensed_Regular64pt7b.h"
#include "NotoSans_ExtraCondensed_Regular65pt7b.h"
#include "NotoSans_ExtraCondensed_Regular66pt7b.h"
#include "NotoSans_ExtraCondensed_Regular67pt7b.h"
#include "NotoSans_ExtraCondensed_Regular68pt7b.h"
#include "NotoSans_ExtraCondensed_Regular69pt7b.h"
#include "NotoSans_ExtraCondensed_Regular70pt7b.h"
#include "NotoSans_ExtraCondensed_Regular71pt7b.h"
#include "NotoSans_ExtraCondensed_Regular72pt7b.h"
