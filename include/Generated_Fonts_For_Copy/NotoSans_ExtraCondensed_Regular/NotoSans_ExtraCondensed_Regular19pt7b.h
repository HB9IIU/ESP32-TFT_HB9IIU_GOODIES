#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF5, 0x50, 0xF0, 0xDE, 0xF7, 0x9C, 0x80, 0x12, 0x12, 0x12,
  0x12, 0x7F, 0x32, 0x36, 0x24, 0x24, 0xFF, 0x24, 0x24, 0x24, 0x6C, 0x11,
  0xEF, 0xE4, 0x93, 0x47, 0x0E, 0x1C, 0x51, 0x67, 0xF8, 0x41, 0x00, 0x61,
  0x1E, 0x22, 0x4C, 0x49, 0x09, 0x21, 0x2C, 0x25, 0x77, 0xAB, 0x69, 0x21,
  0x64, 0x2C, 0x88, 0xB1, 0x16, 0x63, 0x80, 0x30, 0x78, 0x48, 0x48, 0x48,
  0x78, 0x30, 0x71, 0xDA, 0x9A, 0x8E, 0x84, 0xCE, 0x7B, 0xFF, 0xC0, 0x32,
  0x64, 0x4C, 0xCC, 0x8C, 0xCC, 0xC4, 0x62, 0x30, 0x8C, 0x46, 0x62, 0x23,
  0x33, 0x22, 0x26, 0x4C, 0x80, 0x32, 0x9F, 0xCC, 0x5B, 0x20, 0x30, 0x60,
  0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0xFE, 0x80, 0xFF, 0xF0, 0x06, 0x08,
  0x10, 0x60, 0x83, 0x06, 0x08, 0x30, 0x40, 0x83, 0x04, 0x18, 0x00, 0x31,
  0xEC, 0xF3, 0xC6, 0x18, 0x61, 0x86, 0x1C, 0x73, 0x4D, 0xE0, 0x19, 0xDF,
  0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x73, 0xE8, 0xC3, 0x0C, 0x30,
  0x86, 0x10, 0xC6, 0x10, 0x83, 0xF0, 0x73, 0xE8, 0xC3, 0x0C, 0x37, 0x9E,
  0x0C, 0x10, 0x43, 0x8F, 0xE0, 0x04, 0x0C, 0x0C, 0x1C, 0x14, 0x34, 0x24,
  0x64, 0x44, 0xC4, 0xFF, 0x04, 0x04, 0x04, 0xFF, 0xFC, 0x30, 0xC3, 0x0F,
  0x83, 0x04, 0x10, 0x43, 0x9F, 0xE0, 0x1D, 0xF6, 0x30, 0xC2, 0x4B, 0xF3,
  0xC6, 0x1C, 0x71, 0x4D, 0xE0, 0xFF, 0xF0, 0x43, 0x0C, 0x21, 0x86, 0x10,
  0xC3, 0x08, 0x61, 0x80, 0x38, 0xFB, 0x36, 0x2C, 0x49, 0x9E, 0x3C, 0xCD,
  0x0A, 0x1C, 0x2C, 0xCF, 0x00, 0x31, 0xEC, 0xE3, 0x86, 0x1C, 0xF7, 0x74,
  0x10, 0xC2, 0x1B, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xFE, 0x80, 0x02,
  0x1C, 0xE7, 0x0C, 0x0E, 0x07, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81,
  0x81, 0xC0, 0xE0, 0xE7, 0x18, 0x40, 0x73, 0xE0, 0xC3, 0x0C, 0x21, 0x8C,
  0x20, 0x80, 0x00, 0x70, 0x80, 0x0E, 0x07, 0x71, 0x82, 0x20, 0x2C, 0xE5,
  0xB4, 0xA4, 0x94, 0x93, 0x92, 0x52, 0x4A, 0x75, 0x66, 0xC4, 0x00, 0xC0,
  0x0F, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x02, 0x83, 0x41, 0xA0, 0x98, 0x4C,
  0x7E, 0x3F, 0x18, 0xC8, 0x6C, 0x16, 0x0C, 0xF1, 0xFB, 0x1E, 0x3C, 0x78,
  0xFF, 0x7E, 0xC7, 0x87, 0x0E, 0x3C, 0xFF, 0x80, 0x1C, 0x7D, 0x82, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x07, 0x27, 0xC0, 0xF0, 0xFC, 0xC6,
  0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0xC6, 0xCC, 0xF8, 0xFF,
  0xFC, 0x30, 0xC3, 0x0F, 0xFF, 0xC3, 0x0C, 0x30, 0xC3, 0xF0, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x3F, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x1E, 0x3F, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0xC7, 0xC1, 0xC1, 0xC1, 0x61, 0x71, 0x3F, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFE, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xEC, 0xC2, 0xC6, 0xC4, 0xCC, 0xD8, 0xD8, 0xF0,
  0xF8, 0xD8, 0xC8, 0xCC, 0xC4, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF0, 0xE0, 0x7C, 0x0F, 0x83, 0xF8, 0x7F,
  0x0B, 0xA1, 0x74, 0x6E, 0xC9, 0xC9, 0x39, 0x67, 0x3C, 0xE7, 0x1C, 0x63,
  0x8C, 0x40, 0xC1, 0xE1, 0xE1, 0xF1, 0xD1, 0xD1, 0xD9, 0xC9, 0xCD, 0xC5,
  0xC7, 0xC7, 0xC3, 0xC3, 0x1C, 0x3F, 0x18, 0xD8, 0x6C, 0x16, 0x0B, 0x07,
  0x83, 0xC1, 0x60, 0xB0, 0xC8, 0x66, 0x61, 0xE0, 0xF1, 0xFB, 0x1E, 0x3C,
  0x78, 0xF1, 0xFE, 0xF1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x1C, 0x3F, 0x18,
  0xD8, 0x6C, 0x16, 0x0B, 0x07, 0x83, 0xC1, 0x60, 0xB0, 0xC8, 0x66, 0x61,
  0xE0, 0x10, 0x0C, 0x03, 0x00, 0xF0, 0xFC, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC,
  0xF8, 0xD8, 0xC8, 0xCC, 0xC4, 0xC6, 0xC3, 0x39, 0xFC, 0x20, 0xC3, 0x07,
  0x0E, 0x0C, 0x30, 0x43, 0x9F, 0xE0, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x66, 0x3C, 0xC1, 0xC3, 0xC3,
  0x43, 0x62, 0x62, 0x66, 0x26, 0x24, 0x34, 0x3C, 0x1C, 0x18, 0x18, 0xC3,
  0x0F, 0x0C, 0x24, 0x30, 0x91, 0xC6, 0x47, 0x19, 0x96, 0x66, 0x59, 0x09,
  0x24, 0x2C, 0xB0, 0xB2, 0xC3, 0x8F, 0x0E, 0x38, 0x18, 0x60, 0x61, 0x80,
  0xC2, 0x8D, 0x99, 0x23, 0xC7, 0x06, 0x0C, 0x38, 0x58, 0x93, 0x34, 0x78,
  0x40, 0xC3, 0x8D, 0x1B, 0x26, 0xC5, 0x8E, 0x1C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x00, 0x7D, 0xF0, 0xC3, 0x08, 0x61, 0x84, 0x30, 0x86, 0x18, 0x43,
  0xF0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC0, 0x81,
  0x83, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0xC0, 0xFF,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x08, 0x18, 0x1C, 0x34,
  0x26, 0x62, 0x43, 0xC1, 0xFF, 0xD9, 0x80, 0xFA, 0x30, 0xC3, 0x7F, 0x38,
  0xE3, 0xDF, 0xF0, 0xC1, 0x83, 0x06, 0x0F, 0xD8, 0xB1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3E, 0x5F, 0x80, 0x7E, 0x31, 0x08, 0x42, 0x18, 0xCB, 0xC0, 0x06,
  0x0C, 0x18, 0x37, 0xF9, 0xF1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0xEE, 0xC0,
  0x7B, 0x3C, 0x61, 0xFE, 0x08, 0x30, 0x45, 0xF0, 0x11, 0xC8, 0xC6, 0x7D,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80, 0x7F, 0x9F, 0x1C, 0x38, 0x70, 0xE1,
  0xE3, 0xCE, 0xEC, 0x18, 0x20, 0xDF, 0x8C, 0x00, 0xC3, 0x0C, 0x30, 0xFF,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x10, 0xF0, 0xFF, 0xFF, 0xF0, 0x6C,
  0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x7A, 0x00, 0xC1, 0x83, 0x06, 0x0C, 0xD9,
  0x36, 0x78, 0xF1, 0xB3, 0x66, 0x4C, 0xD8, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFD, 0xD9, 0xCF, 0x11, 0xE2, 0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xC4,
  0x78, 0x8C, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x10, 0x79, 0x9B,
  0x14, 0x38, 0x70, 0xE1, 0xE2, 0x4C, 0xF0, 0xFD, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xE5, 0xFB, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x7F, 0x9F, 0x1C,
  0x38, 0x70, 0xE1, 0xE3, 0xCE, 0xEC, 0x18, 0x30, 0x60, 0xC1, 0x80, 0xFF,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0xFC, 0x61, 0x86, 0x18, 0x63, 0x9F,
  0x80, 0x21, 0x19, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC3, 0x80, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xCD, 0xD0, 0xC6, 0x8D, 0x12, 0x26, 0xC5, 0x0A,
  0x14, 0x38, 0x20, 0xC6, 0x28, 0xCD, 0x39, 0xA5, 0x36, 0xB4, 0xD6, 0x8A,
  0x71, 0xCE, 0x31, 0x86, 0x30, 0xC6, 0xD8, 0xB1, 0xC1, 0x87, 0x0A, 0x36,
  0x65, 0x8C, 0xC6, 0x8D, 0x13, 0x26, 0xC5, 0x0A, 0x14, 0x38, 0x20, 0x41,
  0x83, 0x1C, 0x10, 0x00, 0x78, 0xC6, 0x23, 0x11, 0x8C, 0x47, 0xC0, 0x09,
  0xC8, 0x42, 0x10, 0x8C, 0xC3, 0x08, 0x42, 0x10, 0x86, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x18, 0x42, 0x10, 0x84, 0x19, 0x88, 0x42, 0x10,
  0x8C, 0xC0, 0xE3, 0x7E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 5, 5, 7, 1, -14 },
  { 9, 8, 14, 9, 0, -14 },
  { 23, 6, 15, 8, 1, -14 },
  { 35, 11, 14, 13, 1, -14 },
  { 55, 8, 14, 9, 1, -14 },
  { 69, 2, 5, 4, 1, -14 },
  { 71, 4, 17, 6, 1, -14 },
  { 80, 4, 17, 6, 1, -14 },
  { 89, 6, 6, 8, 1, -14 },
  { 94, 7, 9, 8, 1, -11 },
  { 102, 2, 5, 4, 1, -2 },
  { 104, 4, 2, 5, 1, -6 },
  { 105, 2, 2, 4, 1, -2 },
  { 106, 7, 14, 7, 0, -14 },
  { 119, 6, 14, 8, 1, -14 },
  { 130, 5, 14, 8, 1, -14 },
  { 139, 6, 14, 8, 1, -14 },
  { 150, 6, 14, 8, 1, -14 },
  { 161, 8, 14, 8, 0, -14 },
  { 175, 6, 14, 8, 1, -14 },
  { 186, 6, 14, 8, 1, -14 },
  { 197, 6, 14, 8, 1, -14 },
  { 208, 7, 14, 8, 1, -14 },
  { 221, 6, 14, 8, 1, -14 },
  { 232, 2, 10, 4, 1, -10 },
  { 235, 2, 13, 4, 1, -10 },
  { 239, 7, 8, 8, 1, -11 },
  { 246, 7, 5, 8, 1, -9 },
  { 251, 7, 8, 8, 1, -11 },
  { 258, 6, 14, 6, 0, -14 },
  { 269, 11, 16, 12, 1, -14 },
  { 291, 9, 14, 9, 0, -14 },
  { 307, 7, 14, 9, 1, -14 },
  { 320, 7, 14, 8, 1, -14 },
  { 333, 8, 14, 10, 1, -14 },
  { 347, 6, 14, 8, 1, -14 },
  { 358, 6, 14, 7, 1, -14 },
  { 369, 8, 14, 10, 1, -14 },
  { 383, 8, 14, 10, 1, -14 },
  { 397, 4, 14, 5, 1, -14 },
  { 404, 4, 18, 4, -1, -14 },
  { 413, 8, 14, 9, 1, -14 },
  { 427, 6, 14, 7, 1, -14 },
  { 438, 11, 14, 14, 1, -14 },
  { 458, 8, 14, 11, 1, -14 },
  { 472, 9, 14, 10, 1, -14 },
  { 488, 7, 14, 8, 1, -14 },
  { 501, 9, 17, 10, 1, -14 },
  { 521, 8, 14, 9, 1, -14 },
  { 535, 6, 14, 8, 1, -14 },
  { 546, 7, 14, 7, 0, -14 },
  { 559, 8, 14, 10, 1, -14 },
  { 573, 8, 14, 8, 0, -14 },
  { 587, 14, 14, 14, 0, -14 },
  { 612, 7, 14, 8, 0, -14 },
  { 625, 7, 14, 7, 0, -14 },
  { 638, 6, 14, 7, 0, -14 },
  { 649, 4, 17, 6, 1, -14 },
  { 658, 7, 14, 7, 0, -14 },
  { 671, 4, 17, 6, 1, -14 },
  { 680, 8, 8, 8, 0, -14 },
  { 688, 8, 1, 8, 0, 2 },
  { 689, 3, 3, 5, 1, -15 },
  { 691, 6, 10, 8, 1, -10 },
  { 699, 7, 14, 9, 1, -14 },
  { 712, 5, 10, 7, 1, -10 },
  { 719, 7, 14, 9, 1, -14 },
  { 732, 6, 10, 8, 1, -10 },
  { 740, 5, 15, 5, 0, -15 },
  { 750, 7, 15, 9, 1, -10 },
  { 764, 6, 14, 9, 1, -14 },
  { 775, 2, 14, 4, 1, -14 },
  { 779, 3, 19, 4, 0, -14 },
  { 787, 7, 14, 8, 1, -14 },
  { 800, 2, 14, 4, 1, -14 },
  { 804, 11, 10, 13, 1, -10 },
  { 818, 6, 10, 9, 1, -10 },
  { 826, 7, 10, 8, 1, -10 },
  { 835, 7, 15, 9, 1, -10 },
  { 849, 7, 15, 9, 1, -10 },
  { 863, 5, 10, 6, 1, -10 },
  { 870, 5, 10, 6, 1, -10 },
  { 877, 5, 13, 5, 0, -13 },
  { 886, 6, 10, 9, 1, -10 },
  { 894, 7, 10, 7, 0, -10 },
  { 903, 11, 10, 12, 0, -10 },
  { 917, 7, 10, 7, 0, -10 },
  { 926, 7, 15, 7, 0, -10 },
  { 940, 5, 10, 6, 0, -10 },
  { 947, 5, 17, 7, 1, -14 },
  { 958, 2, 20, 8, 3, -15 },
  { 963, 5, 17, 7, 1, -14 },
  { 974, 7, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Regular19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR19PT7B_H_
