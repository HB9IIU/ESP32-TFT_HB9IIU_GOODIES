#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x08, 0xC0, 0x88, 0x7F, 0xF1, 0x88,
  0x19, 0x81, 0x98, 0x19, 0x81, 0x98, 0xFF, 0xE1, 0x10, 0x11, 0x03, 0x10,
  0x33, 0x03, 0x30, 0x33, 0x00, 0x08, 0x04, 0x03, 0x0F, 0xF6, 0x96, 0x43,
  0x21, 0x90, 0xE8, 0x3C, 0x0F, 0x81, 0xE0, 0xB8, 0x4C, 0x26, 0x13, 0xCB,
  0xFF, 0x87, 0x01, 0x00, 0x80, 0x40, 0x30, 0x30, 0xF0, 0x43, 0x31, 0x86,
  0x63, 0x0C, 0xC4, 0x19, 0x98, 0x33, 0x30, 0x66, 0x40, 0xCD, 0xBD, 0x9B,
  0x6D, 0xED, 0x99, 0x9B, 0x30, 0x36, 0x60, 0xCC, 0xC1, 0x99, 0x82, 0x33,
  0x0C, 0x26, 0x18, 0x7C, 0x60, 0x70, 0x1C, 0x07, 0xC1, 0x98, 0x31, 0x06,
  0x30, 0xCC, 0x1D, 0x81, 0xF0, 0x3C, 0x07, 0x01, 0xB1, 0xF7, 0x7C, 0x6D,
  0x87, 0xB0, 0xF6, 0x0C, 0xC3, 0xDF, 0xD9, 0xF1, 0x80, 0xFF, 0xFC, 0x0C,
  0x61, 0x8C, 0x31, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x0E, 0x18, 0x61,
  0x87, 0x0C, 0x30, 0x61, 0xC0, 0xC6, 0x18, 0xE3, 0x18, 0xE3, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x19, 0x8C, 0x66, 0x33, 0x00, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x1C, 0x34, 0x67, 0x24, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFF,
  0xFE, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x76, 0x66, 0xCC, 0xFF, 0xC0,
  0xFC, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x00, 0x1C,
  0x1F, 0x1D, 0xCC, 0x66, 0x3F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x86, 0xC6, 0x63, 0x3F, 0x8F, 0x80, 0x0C, 0x73, 0xDB,
  0xCE, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0,
  0x3C, 0x7F, 0x31, 0xC0, 0x60, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x01,
  0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0x3C, 0x7F,
  0xB1, 0xC0, 0x60, 0x38, 0x1C, 0x0C, 0x06, 0x3E, 0x1E, 0x03, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x07, 0x83, 0x7F, 0xBF, 0x80, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x58, 0x1B, 0x02, 0x60, 0xCC, 0x11, 0x86, 0x30, 0xC6, 0x30,
  0xC6, 0x19, 0xFF, 0xFF, 0xF8, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x7F,
  0x3F, 0x98, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xFE, 0x37, 0x80, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x83, 0x7F, 0xBF, 0x80, 0x07, 0x0F, 0x8E,
  0x0E, 0x06, 0x03, 0x03, 0x81, 0x9C, 0xDF, 0x79, 0xB8, 0x78, 0x3C, 0x1E,
  0x0F, 0x86, 0xC3, 0x63, 0x9F, 0x8F, 0x80, 0xFF, 0xFF, 0xC0, 0x60, 0x30,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x18, 0x1C, 0x00, 0x1C, 0x3F, 0x98, 0xDC, 0x3C, 0x1F, 0x0D,
  0x8E, 0xE6, 0x3E, 0x0E, 0x1D, 0xCC, 0x6C, 0x1E, 0x0F, 0x07, 0x83, 0xE1,
  0xBF, 0x8F, 0x80, 0x1C, 0x3F, 0x19, 0xDC, 0x6C, 0x3E, 0x0F, 0x07, 0x83,
  0xC3, 0xF1, 0xDF, 0xE7, 0xB0, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x3F, 0x1F,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x66, 0x60, 0x00, 0x00, 0x00, 0x07, 0x66,
  0x6C, 0xC0, 0x00, 0x80, 0xC1, 0xC3, 0xC7, 0x87, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x60, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x0E, 0x1C, 0x38, 0x78,
  0x30, 0x10, 0x00, 0x3C, 0xFE, 0x46, 0x07, 0x03, 0x03, 0x06, 0x06, 0x0C,
  0x1C, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x38, 0x38, 0x38, 0x03, 0xC0,
  0x1F, 0xE0, 0x60, 0xE1, 0x80, 0xC3, 0x00, 0xCC, 0x39, 0x99, 0xF9, 0x23,
  0x33, 0xCC, 0x67, 0x98, 0x8F, 0x31, 0x1E, 0x66, 0x3C, 0xCC, 0x79, 0x98,
  0xB1, 0xFF, 0x33, 0x9C, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE7, 0x00,
  0xFE, 0x00, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0B, 0x01, 0xB0, 0x19,
  0x81, 0x98, 0x19, 0x83, 0x18, 0x31, 0xC3, 0xFC, 0x3F, 0xC7, 0x0C, 0x60,
  0xE6, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x70, 0xF0, 0x7F, 0xB1, 0xD8, 0x7C,
  0x1E, 0x0F, 0x07, 0x86, 0xFF, 0x7F, 0x31, 0xD8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xFF, 0xBF, 0x80, 0x07, 0x87, 0xF3, 0x88, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0xF0, 0xFC, 0xF0, 0x3F, 0x8C, 0xF3, 0x0E, 0xC1, 0xB0,
  0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1B,
  0x06, 0xC3, 0xBF, 0xCF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x00, 0x07, 0xC1, 0xFF, 0x3C, 0x63, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x1F, 0xE1, 0xFE, 0x03, 0xE0, 0x36, 0x03,
  0x60, 0x37, 0x03, 0x38, 0x31, 0xFF, 0x0F, 0xE0, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFF, 0xCC, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xFE, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x9F, 0xDC, 0xC1,
  0xB0, 0x6C, 0x33, 0x1C, 0xC6, 0x33, 0x8C, 0xC3, 0x70, 0xD8, 0x3E, 0x0F,
  0xC3, 0xB0, 0xCE, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0x6C, 0x1C, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xFF, 0xF8, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0x7A, 0x06, 0xF6, 0x0D, 0xEC, 0x1B, 0xD8, 0x67, 0x98, 0xCF, 0x31,
  0x9E, 0x62, 0x3C, 0x4C, 0x78, 0xD8, 0xF1, 0xB1, 0xE3, 0xC3, 0xC3, 0x87,
  0x87, 0x0F, 0x0C, 0x18, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xB0,
  0xF6, 0x1E, 0xE3, 0xCC, 0x79, 0x8F, 0x19, 0xE3, 0x3C, 0x37, 0x86, 0xF0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0x80, 0x0F, 0x01, 0xFC, 0x39, 0xC7,
  0x0E, 0x60, 0x66, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x36, 0x07, 0x60, 0x67, 0x06, 0x30, 0xE3, 0xFC, 0x1F, 0x80,
  0xF0, 0x7F, 0x33, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x63, 0xBF,
  0x9F, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x0F, 0x01,
  0xFC, 0x39, 0xC7, 0x0E, 0x60, 0x66, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x67, 0x06, 0x30, 0xE3,
  0xFC, 0x1F, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0xF0, 0x3F, 0x8C,
  0xF3, 0x0C, 0xC3, 0xB0, 0xEC, 0x3B, 0x0E, 0xC3, 0x3F, 0xCF, 0xC3, 0x30,
  0xCE, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0x6C, 0x1C, 0x1E, 0x3F, 0xDC,
  0x5C, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x38,
  0x1C, 0x06, 0x07, 0x83, 0x7F, 0xBF, 0x80, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xE1, 0x9F, 0xE3, 0xF0, 0xC0, 0x7C, 0x0F, 0x81, 0xB0,
  0x76, 0x0C, 0xC1, 0x9C, 0x31, 0x86, 0x31, 0xC6, 0x30, 0xE6, 0x0C, 0xC1,
  0xB8, 0x36, 0x06, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0xC0,
  0xFC, 0x1C, 0x19, 0x83, 0x83, 0x30, 0x70, 0x66, 0x0E, 0x0C, 0xC3, 0x43,
  0x9C, 0x6C, 0x61, 0x8D, 0x8C, 0x31, 0xB1, 0x86, 0x66, 0x30, 0xCC, 0x4E,
  0x19, 0x8D, 0x81, 0xB1, 0xB0, 0x36, 0x36, 0x06, 0x86, 0xC0, 0xF0, 0x58,
  0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x00, 0x60, 0xD8, 0x77, 0x18,
  0xC6, 0x33, 0x86, 0xC1, 0xB0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1B,
  0x0E, 0xC3, 0x38, 0xC6, 0x61, 0x98, 0x7E, 0x0C, 0xC0, 0xF8, 0x36, 0x19,
  0x86, 0x71, 0x8C, 0xC3, 0x30, 0xEC, 0x1E, 0x07, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xFF, 0xFF, 0x07, 0x06,
  0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xE0, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x04, 0x00, 0xC0, 0x38, 0x07,
  0x81, 0xB0, 0x33, 0x0C, 0x61, 0x86, 0x60, 0xDC, 0x0C, 0xFF, 0xFF, 0xFC,
  0xE3, 0x0C, 0x30, 0x7E, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x3F, 0x63, 0xC3,
  0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x79, 0xFE, 0xE3, 0x61, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3,
  0xF1, 0xBF, 0xD3, 0xC0, 0x3E, 0xFD, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x83, 0x07, 0xE7, 0xC0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0xF6, 0xFF, 0x63, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1,
  0xB1, 0xDF, 0xE7, 0x90, 0x3E, 0x3F, 0x98, 0xDC, 0x3C, 0x1E, 0x0F, 0xFF,
  0x80, 0xC0, 0x60, 0x18, 0x0C, 0x17, 0xF1, 0xF8, 0x0E, 0x3C, 0xC1, 0x83,
  0x06, 0x1F, 0x7E, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x80, 0x3C, 0xBF, 0xD8, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF8, 0x6C, 0x77, 0xF9, 0xEC, 0x06, 0x03, 0x01, 0xC1, 0xDF, 0xCF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xE3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x33, 0x20, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3E, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xC6, 0xCC,
  0xCC, 0xD8, 0xF8, 0xF8, 0xFC, 0xCC, 0xCC, 0xC6, 0xC6, 0xC7, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x7B, 0xFB, 0xFE, 0x78, 0xF0, 0xC3, 0xC3,
  0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0,
  0xC3, 0xC3, 0x0F, 0x0C, 0x30, 0x9E, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3E, 0x3F, 0x98, 0xFC, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0x9E,
  0x7F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xFC,
  0x6F, 0xF6, 0xF3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x3C, 0xBF,
  0xD8, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x6C, 0x77,
  0xF9, 0xEC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x9F, 0xEE, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7F, 0xFF, 0x06, 0x0C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0C, 0x1C, 0x3F, 0xDF, 0x80, 0x30, 0xC3, 0x1F,
  0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0x1C, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B,
  0xC1, 0xF8, 0x66, 0x19, 0x86, 0x63, 0x1C, 0xC3, 0x30, 0xCC, 0x36, 0x0D,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x00, 0xC1, 0x87, 0x63, 0x86, 0x63, 0xC6,
  0x63, 0xC6, 0x63, 0xC6, 0x62, 0xCC, 0x36, 0x4C, 0x36, 0x6C, 0x36, 0x6C,
  0x36, 0x68, 0x34, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x61, 0xB1,
  0xCC, 0xC6, 0x61, 0xE0, 0xF0, 0x30, 0x38, 0x1E, 0x1B, 0x0C, 0xCE, 0x66,
  0x3F, 0x0C, 0xC1, 0xF8, 0x66, 0x19, 0x86, 0x63, 0x0C, 0xC3, 0x30, 0xCC,
  0x36, 0x05, 0x81, 0xE0, 0x78, 0x1C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06,
  0x0F, 0x03, 0xC0, 0xFF, 0xF0, 0xC6, 0x18, 0xE3, 0x0C, 0x61, 0x8E, 0x30,
  0xFF, 0xF0, 0x02, 0x1C, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC7,
  0x0F, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xC3, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xE0, 0xC1, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x70, 0xE3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x9E, 0x38, 0x00, 0x70, 0xFE, 0x63, 0xF0, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 6, 7, 10, 2, -19 },
  { 12, 12, 19, 12, 0, -19 },
  { 41, 9, 22, 11, 1, -20 },
  { 66, 15, 19, 17, 1, -19 },
  { 102, 11, 19, 12, 1, -19 },
  { 129, 2, 7, 5, 2, -19 },
  { 131, 6, 23, 8, 1, -19 },
  { 149, 5, 23, 8, 1, -19 },
  { 164, 8, 9, 10, 1, -20 },
  { 173, 9, 12, 11, 1, -15 },
  { 187, 4, 6, 6, 1, -3 },
  { 190, 5, 2, 7, 1, -8 },
  { 192, 2, 3, 6, 2, -3 },
  { 193, 9, 19, 10, 0, -19 },
  { 215, 9, 19, 11, 1, -19 },
  { 237, 6, 19, 11, 2, -19 },
  { 252, 9, 19, 11, 1, -19 },
  { 274, 9, 19, 11, 1, -19 },
  { 296, 11, 19, 11, 0, -19 },
  { 323, 9, 19, 11, 1, -19 },
  { 345, 9, 19, 11, 1, -19 },
  { 367, 9, 19, 11, 1, -19 },
  { 389, 9, 19, 11, 1, -19 },
  { 411, 9, 19, 11, 1, -19 },
  { 433, 2, 14, 6, 2, -14 },
  { 437, 4, 17, 6, 1, -14 },
  { 446, 9, 12, 11, 1, -15 },
  { 460, 9, 8, 11, 1, -13 },
  { 469, 9, 12, 11, 1, -15 },
  { 483, 8, 19, 8, 0, -19 },
  { 502, 15, 21, 17, 1, -19 },
  { 542, 12, 19, 12, 0, -19 },
  { 571, 9, 19, 12, 2, -19 },
  { 593, 10, 19, 12, 1, -19 },
  { 617, 10, 19, 13, 2, -19 },
  { 641, 7, 19, 10, 2, -19 },
  { 658, 7, 19, 10, 2, -19 },
  { 675, 12, 19, 14, 1, -19 },
  { 704, 10, 19, 14, 2, -19 },
  { 728, 5, 19, 7, 1, -19 },
  { 740, 5, 24, 6, -1, -19 },
  { 755, 10, 19, 12, 2, -19 },
  { 779, 7, 19, 10, 2, -19 },
  { 796, 15, 19, 19, 2, -19 },
  { 832, 11, 19, 15, 2, -19 },
  { 859, 12, 19, 14, 1, -19 },
  { 888, 9, 19, 12, 2, -19 },
  { 910, 12, 23, 14, 1, -19 },
  { 945, 10, 19, 12, 2, -19 },
  { 969, 9, 19, 11, 1, -19 },
  { 991, 10, 19, 10, 0, -19 },
  { 1015, 10, 19, 14, 2, -19 },
  { 1039, 11, 19, 11, 0, -19 },
  { 1066, 19, 19, 19, 0, -19 },
  { 1112, 10, 19, 10, 0, -19 },
  { 1136, 10, 19, 10, 0, -19 },
  { 1160, 8, 19, 9, 1, -19 },
  { 1179, 5, 23, 8, 2, -19 },
  { 1194, 9, 19, 10, 0, -19 },
  { 1216, 5, 23, 8, 1, -19 },
  { 1231, 11, 10, 11, 0, -19 },
  { 1245, 11, 2, 11, 0, 2 },
  { 1248, 5, 4, 7, 1, -20 },
  { 1251, 8, 14, 11, 1, -14 },
  { 1265, 9, 20, 12, 2, -20 },
  { 1288, 7, 14, 9, 1, -14 },
  { 1301, 9, 20, 12, 1, -20 },
  { 1324, 9, 14, 11, 1, -14 },
  { 1340, 7, 20, 7, 0, -20 },
  { 1358, 9, 20, 12, 1, -14 },
  { 1381, 8, 20, 12, 2, -20 },
  { 1401, 2, 19, 5, 2, -19 },
  { 1406, 4, 25, 5, 0, -19 },
  { 1419, 8, 20, 10, 2, -20 },
  { 1439, 2, 20, 5, 2, -20 },
  { 1444, 14, 14, 18, 2, -14 },
  { 1469, 8, 14, 12, 2, -14 },
  { 1483, 9, 14, 12, 1, -14 },
  { 1499, 9, 20, 12, 2, -14 },
  { 1522, 9, 20, 12, 1, -14 },
  { 1545, 6, 14, 8, 2, -14 },
  { 1556, 7, 14, 9, 1, -14 },
  { 1569, 6, 17, 7, 0, -17 },
  { 1582, 8, 14, 12, 2, -14 },
  { 1596, 10, 14, 10, 0, -14 },
  { 1614, 16, 14, 16, 0, -14 },
  { 1642, 9, 14, 10, 0, -14 },
  { 1658, 10, 20, 10, 0, -14 },
  { 1683, 6, 14, 8, 1, -14 },
  { 1694, 7, 23, 9, 1, -19 },
  { 1715, 2, 26, 11, 4, -20 },
  { 1722, 7, 23, 9, 1, -19 },
  { 1743, 9, 4, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Regular26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR26PT7B_H_
