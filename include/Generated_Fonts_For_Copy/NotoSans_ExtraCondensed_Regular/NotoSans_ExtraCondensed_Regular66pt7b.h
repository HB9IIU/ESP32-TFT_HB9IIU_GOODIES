#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x08, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFC, 0xE1,
  0xE3, 0xE1, 0xC0, 0x8F, 0x83, 0x80, 0x1F, 0x07, 0x00, 0x3E, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x70, 0x03, 0xE0, 0xE0, 0x07,
  0xC1, 0xC0, 0x0F, 0xC3, 0x80, 0x0F, 0xC7, 0x00, 0x1F, 0xEE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0E, 0x7F, 0x00, 0x1C,
  0x7E, 0x00, 0x38, 0x7C, 0x00, 0x70, 0x7C, 0x00, 0xE0, 0xF8, 0x01, 0xC1,
  0xF0, 0x03, 0x83, 0xE0, 0x07, 0x07, 0xC0, 0x0E, 0x1F, 0x40, 0x1C, 0x3E,
  0xC0, 0x38, 0xFD, 0xF0, 0x77, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x3C, 0x00,
  0x7C, 0xF8, 0x00, 0xF0, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x07, 0x83, 0xC0,
  0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x03,
  0xC0, 0xF8, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x81,
  0xF0, 0x00, 0xF0, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x3E, 0x00, 0x0F,
  0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3E, 0x1F,
  0x00, 0x03, 0xC0, 0xF8, 0x78, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0x00, 0x3C,
  0x0F, 0x8F, 0x83, 0xE0, 0xF0, 0x3E, 0x3C, 0x1F, 0xC3, 0xC0, 0xF0, 0xF0,
  0xFF, 0x8F, 0x83, 0xC7, 0xC7, 0xFF, 0x1E, 0x0F, 0x1E, 0x3E, 0x3E, 0x78,
  0x7C, 0x78, 0xF0, 0xF9, 0xF3, 0xE3, 0xE3, 0xC1, 0xE3, 0xFF, 0x8F, 0x0F,
  0x07, 0xC7, 0xFC, 0x3C, 0x7C, 0x1F, 0x0F, 0xE1, 0xF1, 0xF0, 0x7C, 0x1E,
  0x07, 0x87, 0x80, 0xF0, 0x00, 0x1E, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x78,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0xF0, 0x00,
  0x7C, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0x0F, 0x81, 0xE0,
  0x3C, 0x00, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x03, 0xC1,
  0xE0, 0x03, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x3C,
  0x00, 0x7D, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x03, 0xFE,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x3F, 0x0F, 0xC7, 0xC0, 0xFC, 0x3E, 0x1F, 0x83, 0xE1, 0xF8,
  0x3F, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x3F, 0x01, 0xF9, 0xF8, 0xFC, 0x03,
  0xE7, 0xE3, 0xF0, 0x0F, 0xDF, 0x0F, 0x80, 0x1F, 0xFC, 0x3E, 0x00, 0x7F,
  0xF0, 0xF8, 0x00, 0xFF, 0x83, 0xE0, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x07,
  0xF0, 0x3F, 0xFC, 0x1F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7, 0xE0, 0x7F,
  0xFF, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x06, 0x07, 0x81, 0x9F, 0x1E,
  0x3E, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0x03,
  0x80, 0x08, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBE, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7E,
  0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x7F,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xDF, 0x3F, 0x3E, 0xFC, 0x7F, 0xF0, 0xFB,
  0xC1, 0xF3, 0x03, 0xE2, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xE0,
  0xFF, 0x0F, 0x00, 0x7E, 0x08, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0x0E, 0x00, 0x7E, 0x18, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFD,
  0x00, 0x03, 0xF9, 0x80, 0x0F, 0xE3, 0xE0, 0x7F, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xBF, 0x00, 0x01, 0xEF, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0x3C, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0x8F, 0xC0,
  0x01, 0xE3, 0xF0, 0x00, 0xF0, 0xFC, 0x00, 0x3C, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF0, 0x3F, 0x00, 0x7C,
  0x0F, 0xC0, 0x1E, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x3F, 0x01,
  0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x04, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x80, 0x03, 0xFB, 0x80, 0x1F, 0xCF, 0xC1, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0x02, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x78, 0x07, 0xC3, 0xFC, 0x0F, 0x9F, 0xFE, 0x1F,
  0x3F, 0xFE, 0x3E, 0xFF, 0xFC, 0x7F, 0xC3, 0xFC, 0xFF, 0x01, 0xF9, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7E, 0x03, 0xF0,
  0xFE, 0x07, 0xE0, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x81, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xEF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8,
  0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x01, 0xFE, 0x7F, 0x8F, 0xFC, 0x7F,
  0xFE, 0xF8, 0x7F, 0xF9, 0xF0, 0xFF, 0xF3, 0xE0, 0x7F, 0x87, 0xC0, 0x3C,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x83, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xE1, 0x00, 0x04, 0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3E, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C,
  0x3E, 0x1E, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xF8, 0x7F, 0x98, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0xF8, 0x07,
  0xFF, 0x07, 0xC7, 0xC0, 0x7F, 0xF8, 0x1E, 0x3C, 0x07, 0xFF, 0xC0, 0xF3,
  0xE0, 0x3E, 0x1E, 0x07, 0x9F, 0x03, 0xE0, 0xF0, 0x3E, 0xF0, 0x1E, 0x07,
  0x81, 0xF7, 0x81, 0xF0, 0x3C, 0x0F, 0xBC, 0x0F, 0x03, 0xE0, 0x7D, 0xE0,
  0x78, 0x1F, 0x01, 0xFF, 0x03, 0xC0, 0xF8, 0x0F, 0xF8, 0x3E, 0x07, 0xC0,
  0x7F, 0xC1, 0xF0, 0x3E, 0x03, 0xFE, 0x0F, 0x81, 0xF0, 0x1F, 0xF0, 0x7C,
  0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7C, 0x0F, 0xFC, 0x1F, 0x03, 0xE0, 0x7F,
  0xE0, 0xF8, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0xF8, 0x1E, 0xF8, 0x3E, 0x07,
  0xC0, 0xF7, 0xC0, 0xF0, 0x7E, 0x07, 0xBE, 0x07, 0x83, 0xF0, 0x7C, 0xF0,
  0x3E, 0x1F, 0xC3, 0xC7, 0x80, 0xFF, 0xCF, 0xFE, 0x3C, 0x07, 0xFE, 0x7F,
  0xE1, 0xF0, 0x1F, 0xE3, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0xE0, 0x3C, 0x00,
  0x40, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x03,
  0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xC0,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFE,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xE0, 0xF8, 0x1F, 0xC0, 0x08, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xC0,
  0xFF, 0xC7, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3E,
  0x01, 0xFF, 0x0F, 0x80, 0x1F, 0xC3, 0xE0, 0x03, 0xF8, 0xF8, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x07, 0xE3, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xFC, 0x3E, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xF8, 0x1F, 0xE0,
  0x03, 0xC1, 0xFC, 0x00, 0x04, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7F, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x3E,
  0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xFA, 0x1F, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0xFC,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xDF, 0xC0, 0x03, 0xEF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xDF, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0xFC, 0x03,
  0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xF7, 0xC0,
  0x01, 0xFB, 0xE0, 0x00, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xDF, 0xFF, 0xC0, 0x00, 0x1F, 0x7F, 0xEF, 0x00,
  0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x01, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0xBF,
  0xFB, 0xE0, 0x00, 0x3E, 0xFF, 0xE7, 0xC0, 0x00, 0xFB, 0xFF, 0x9F, 0x00,
  0x03, 0xCF, 0xFE, 0x7C, 0x00, 0x1F, 0x3F, 0xF8, 0xF0, 0x00, 0x7C, 0xFF,
  0xE3, 0xE0, 0x01, 0xF3, 0xFF, 0x8F, 0x80, 0x0F, 0x8F, 0xFE, 0x3E, 0x00,
  0x3E, 0x3F, 0xF8, 0x7C, 0x00, 0xF8, 0xFF, 0xE1, 0xF0, 0x03, 0xC3, 0xFF,
  0x87, 0xC0, 0x1F, 0x0F, 0xFE, 0x0F, 0x00, 0x7C, 0x3F, 0xF8, 0x3E, 0x01,
  0xF0, 0xFF, 0xE0, 0xF8, 0x0F, 0x83, 0xFF, 0x83, 0xE0, 0x3E, 0x0F, 0xFE,
  0x07, 0xC0, 0xF8, 0x3F, 0xF8, 0x1F, 0x03, 0xC0, 0xFF, 0xE0, 0x7C, 0x1F,
  0x03, 0xFF, 0x80, 0xF0, 0x7C, 0x0F, 0xFE, 0x03, 0xE1, 0xF0, 0x3F, 0xF8,
  0x0F, 0x8F, 0x80, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xFF, 0x80, 0x7C, 0xF8,
  0x0F, 0xFE, 0x01, 0xF3, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xE0,
  0x01, 0xFF, 0xBE, 0x00, 0x1F, 0xF9, 0xF0, 0x01, 0xFF, 0x9F, 0x00, 0x1F,
  0xF9, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0xFC, 0x01, 0xFF, 0x87,
  0xC0, 0x1F, 0xF8, 0x7C, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3E, 0x01,
  0xFF, 0x83, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0xF8,
  0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0xC1, 0xFF, 0x80, 0x7C,
  0x1F, 0xF8, 0x07, 0xE1, 0xFF, 0x80, 0x3E, 0x1F, 0xF8, 0x03, 0xF1, 0xFF,
  0x80, 0x1F, 0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0x80, 0x1F, 0x9F, 0xF8, 0x00,
  0xF9, 0xFF, 0x80, 0x0F, 0xDF, 0xF8, 0x00, 0x7D, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x40, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xE0, 0x3F, 0xCF, 0x80, 0x3F, 0xBE, 0x00, 0x7E, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFB, 0xE0, 0x0F,
  0xEF, 0x80, 0x7F, 0x3E, 0x07, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x7F, 0xC3, 0xE0,
  0x0F, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x87, 0xC0, 0x3F,
  0x83, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F, 0xC7,
  0xF0, 0x07, 0x1F, 0x80, 0x04, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFA,
  0x00, 0x0F, 0xCE, 0x00, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xCF, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x1F, 0x00,
  0x07, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7B, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF7, 0xC0, 0x0F, 0xC1, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x83, 0xF0, 0x07,
  0xDF, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x9E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x78,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE1,
  0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC3, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0x87,
  0xC0, 0xFC, 0x01, 0xF0, 0x1E, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x7C, 0x1F,
  0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x3C,
  0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x7C, 0x3F, 0x00, 0x1F, 0x07, 0x80, 0xF8,
  0x7E, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x01, 0xE1,
  0xF0, 0x00, 0x7C, 0x7C, 0x03, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x07, 0xCF,
  0xC0, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x80, 0x03, 0xE3, 0xC0, 0x1F, 0x3E,
  0x00, 0x07, 0xEF, 0x80, 0x1E, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x3C, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0xFF, 0xE0,
  0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07,
  0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x01,
  0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x07,
  0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xEF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xF8, 0xFF, 0x06, 0x01, 0xF8, 0x20, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xFF, 0xBE, 0x7F, 0x01, 0xF7, 0xF0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xE0,
  0xFF, 0x3F, 0xFE, 0x79, 0xFF, 0xF3, 0xC7, 0xFF, 0x1E, 0x1F, 0xF0, 0xF0,
  0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x7F, 0xC0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8,
  0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7C, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFF, 0x00, 0xFC, 0xFF, 0x00, 0xFC, 0xFF, 0xC3, 0xF8, 0xFB, 0xFF, 0xF8,
  0xF9, 0xFF, 0xF0, 0xF8, 0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0x01, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x11, 0xFE, 0x0E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x83,
  0xFF, 0x1F, 0x0F, 0xFF, 0x3E, 0x3F, 0xFF, 0x7C, 0xFF, 0xFF, 0xF9, 0xFC,
  0x1F, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xBE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF3, 0xF0,
  0x1F, 0xE7, 0xF0, 0x7F, 0xC7, 0xFF, 0xEF, 0x8F, 0xFF, 0xCF, 0x0F, 0xFF,
  0x1E, 0x07, 0xF8, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0xFC, 0x0F, 0xC3,
  0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0xBF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0x87, 0xF0, 0x1E, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7E, 0x10,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x3C, 0x3F, 0xFC, 0x78, 0xFF, 0xFD, 0xF1,
  0xFF, 0xFB, 0xE7, 0xF0, 0x7F, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xCF, 0xC0, 0x7F, 0x9F, 0xC1, 0xFF, 0x1F, 0xFF, 0xBE, 0x3F,
  0xFE, 0x7C, 0x3F, 0xF8, 0xF8, 0x1F, 0xE1, 0xF0, 0x06, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xCC, 0x00, 0x3F,
  0x9F, 0x01, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x3F,
  0x3F, 0xF0, 0xFD, 0xFF, 0xE3, 0xE7, 0xFF, 0xCF, 0xBF, 0xFF, 0xBF, 0xE0,
  0x7E, 0xFF, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF0,
  0x33, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x47, 0xEF,
  0xFD, 0xFF, 0x3F, 0xE7, 0xF8, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3E, 0x00,
  0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0xC0, 0x3E, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFC, 0xF8, 0x0F, 0xF3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x1F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xF3, 0xF0,
  0x07, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x07, 0xC7, 0xFE, 0x07, 0xFE,
  0x3E, 0x7F, 0xF8, 0x7F, 0xF9, 0xF7, 0xFF, 0xC7, 0xFF, 0xCF, 0xBF, 0xFF,
  0x7F, 0xFF, 0x7F, 0xC1, 0xFB, 0x83, 0xFB, 0xFC, 0x07, 0xF8, 0x0F, 0xDF,
  0xC0, 0x3F, 0xC0, 0x3E, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x03, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x03,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x3F, 0x83, 0xE3, 0xFF, 0x0F, 0x9F, 0xFE, 0x3E, 0x7F,
  0xFC, 0xFB, 0xFF, 0xFB, 0xFE, 0x07, 0xEF, 0xF0, 0x1F, 0xBF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0xF8,
  0x7F, 0xE0, 0xF8, 0xFF, 0xF0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF,
  0x81, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7C, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7C, 0xFF,
  0x00, 0xFC, 0xFF, 0x00, 0xFC, 0xFB, 0xC3, 0xF8, 0xFB, 0xFF, 0xF8, 0xFD,
  0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0xFC, 0x7F, 0xC0, 0xFC, 0x0E, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFC, 0x3C, 0x3F, 0xFC, 0x78, 0xFF, 0xFD, 0xF1, 0xFF, 0xFB, 0xE7, 0xF0,
  0x7F, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0,
  0x7F, 0x9F, 0xC1, 0xFF, 0x1F, 0xFF, 0xBE, 0x3F, 0xFE, 0x7C, 0x3F, 0xF8,
  0xF8, 0x1F, 0xE1, 0xF0, 0x06, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0x7E, 0xFE, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xDF, 0x9F, 0x80, 0xEF,
  0xC0, 0x0B, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x87,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0x80, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x7F, 0x7C, 0x01, 0xFD, 0xF8, 0x0F, 0xF7, 0xF0, 0xF7, 0xCF, 0xFF,
  0xDF, 0x3F, 0xFE, 0x7C, 0x7F, 0xF1, 0xF0, 0xFF, 0x87, 0xC0, 0x38, 0x00,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0x80, 0x3E, 0x7C, 0x01, 0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0xE0, 0x0F, 0x9F, 0x80, 0xFF, 0xC0, 0x7E, 0x3E,
  0x03, 0xFF, 0x01, 0xF0, 0xF8, 0x0F, 0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0xF0,
  0x1F, 0x0F, 0x80, 0xF3, 0xC0, 0x7C, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x7C,
  0x1F, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0xF8, 0x3E, 0x07, 0xC1, 0xE1, 0xE0,
  0xF8, 0x1F, 0x07, 0x87, 0x83, 0xE0, 0x7E, 0x3E, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x7C, 0x7C, 0x03, 0xE3, 0xC1, 0xF1, 0xF0, 0x0F, 0x8F, 0x03, 0xC7,
  0xC0, 0x3E, 0x3C, 0x0F, 0x1F, 0x00, 0x79, 0xF0, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0xFB, 0xE0, 0x07, 0xDE, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x07, 0xBE,
  0x00, 0x7D, 0xE0, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x03, 0xDE,
  0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0,
  0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFB, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E,
  0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xE7,
  0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8F, 0xF0, 0x00, 0x5F,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x80, 0x7F, 0xFD, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0xF0, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 48, 16, 4, -47 },
  { 43, 17, 17, 25, 4, -47 },
  { 80, 28, 47, 30, 1, -47 },
  { 245, 23, 54, 28, 3, -50 },
  { 401, 38, 49, 44, 3, -48 },
  { 634, 30, 49, 31, 2, -48 },
  { 818, 6, 17, 14, 4, -47 },
  { 831, 14, 58, 19, 3, -48 },
  { 933, 14, 58, 19, 2, -48 },
  { 1035, 22, 22, 26, 2, -50 },
  { 1096, 24, 31, 28, 2, -39 },
  { 1189, 9, 17, 15, 2, -8 },
  { 1209, 14, 5, 18, 2, -20 },
  { 1218, 7, 9, 15, 4, -8 },
  { 1226, 23, 47, 24, 1, -47 },
  { 1362, 23, 49, 28, 3, -48 },
  { 1503, 15, 47, 28, 4, -47 },
  { 1592, 23, 48, 28, 2, -48 },
  { 1730, 23, 49, 28, 2, -48 },
  { 1871, 26, 48, 28, 1, -48 },
  { 2027, 22, 48, 28, 3, -47 },
  { 2159, 23, 49, 28, 3, -48 },
  { 2300, 24, 47, 28, 2, -47 },
  { 2441, 24, 49, 28, 2, -48 },
  { 2588, 23, 49, 28, 2, -48 },
  { 2729, 7, 37, 15, 4, -36 },
  { 2762, 9, 45, 15, 2, -36 },
  { 2813, 24, 29, 28, 2, -38 },
  { 2900, 24, 19, 28, 2, -33 },
  { 2957, 24, 29, 28, 2, -38 },
  { 3044, 19, 49, 21, 1, -48 },
  { 3161, 37, 54, 43, 3, -48 },
  { 3411, 30, 47, 30, 0, -47 },
  { 3588, 24, 47, 31, 5, -47 },
  { 3729, 25, 49, 29, 3, -48 },
  { 3883, 26, 47, 34, 5, -47 },
  { 4036, 19, 47, 27, 5, -47 },
  { 4148, 19, 47, 25, 5, -47 },
  { 4260, 29, 49, 36, 3, -48 },
  { 4438, 25, 47, 35, 5, -47 },
  { 4585, 14, 47, 19, 2, -47 },
  { 4668, 13, 60, 15, -3, -47 },
  { 4766, 25, 47, 30, 5, -47 },
  { 4913, 18, 47, 24, 5, -47 },
  { 5019, 38, 47, 47, 5, -47 },
  { 5243, 28, 47, 38, 5, -47 },
  { 5408, 30, 49, 36, 3, -48 },
  { 5592, 22, 47, 29, 5, -47 },
  { 5722, 30, 59, 36, 3, -48 },
  { 5944, 25, 47, 30, 5, -47 },
  { 6091, 22, 49, 27, 3, -48 },
  { 6226, 23, 47, 25, 1, -47 },
  { 6362, 26, 48, 34, 4, -47 },
  { 6518, 29, 47, 29, 0, -47 },
  { 6689, 47, 47, 47, 0, -47 },
  { 6966, 26, 47, 26, 0, -47 },
  { 7119, 26, 47, 26, 0, -47 },
  { 7272, 21, 47, 24, 2, -47 },
  { 7396, 14, 59, 21, 5, -48 },
  { 7500, 23, 47, 24, 1, -47 },
  { 7636, 14, 59, 21, 2, -48 },
  { 7740, 27, 25, 29, 1, -47 },
  { 7825, 29, 5, 29, 0, 5 },
  { 7844, 12, 11, 18, 3, -51 },
  { 7861, 21, 37, 27, 2, -36 },
  { 7959, 24, 51, 30, 4, -50 },
  { 8112, 19, 37, 23, 3, -36 },
  { 8200, 23, 51, 30, 3, -50 },
  { 8347, 22, 37, 28, 3, -36 },
  { 8449, 17, 50, 17, 1, -50 },
  { 8556, 23, 52, 30, 3, -36 },
  { 8706, 22, 50, 30, 4, -50 },
  { 8844, 6, 49, 14, 4, -49 },
  { 8881, 11, 65, 14, -1, -49 },
  { 8971, 22, 50, 26, 4, -50 },
  { 9109, 6, 50, 14, 4, -50 },
  { 9147, 37, 36, 45, 4, -36 },
  { 9314, 22, 36, 30, 4, -36 },
  { 9413, 24, 37, 29, 3, -36 },
  { 9524, 24, 52, 30, 4, -36 },
  { 9680, 23, 52, 30, 3, -36 },
  { 9830, 15, 36, 20, 4, -36 },
  { 9898, 18, 37, 22, 2, -36 },
  { 9982, 15, 44, 17, 1, -43 },
  { 10065, 22, 36, 30, 4, -35 },
  { 10164, 24, 35, 24, 0, -35 },
  { 10269, 38, 35, 40, 1, -35 },
  { 10436, 23, 35, 25, 1, -35 },
  { 10537, 24, 51, 24, 0, -35 },
  { 10690, 17, 35, 20, 2, -35 },
  { 10765, 18, 58, 24, 3, -47 },
  { 10896, 5, 66, 27, 11, -50 },
  { 10938, 18, 58, 24, 3, -47 },
  { 11069, 25, 9, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Regular66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR66PT7B_H_
