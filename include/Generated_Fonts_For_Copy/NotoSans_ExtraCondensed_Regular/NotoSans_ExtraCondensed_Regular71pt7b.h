#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0xC0, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x03, 0xC0,
  0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xF7, 0x87, 0xC7, 0xE3,
  0xC0, 0x47, 0xE1, 0xE0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8,
  0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F,
  0x83, 0xC0, 0x07, 0xE1, 0xE0, 0x01, 0xF8, 0xF0, 0x00, 0xFE, 0x78, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3C, 0xFE, 0x00, 0x1E, 0x3F, 0x80, 0x0F, 0x0F, 0xC0, 0x07,
  0x83, 0xE0, 0x03, 0xC1, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x3E, 0x00,
  0x78, 0x1F, 0x00, 0x3C, 0x1F, 0x80, 0x1E, 0x0F, 0xA0, 0x0F, 0x0F, 0xD8,
  0x07, 0x87, 0xEF, 0x83, 0xCF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xC0,
  0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x00, 0xF0,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0x03, 0xE0,
  0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC1, 0xE0, 0x00,
  0x1F, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x78, 0x3F, 0xC3, 0xE0, 0x7C, 0x7C, 0x3F, 0xF0, 0xF0, 0x3E, 0x3E,
  0x3F, 0xFC, 0x78, 0x1E, 0x1E, 0x1F, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F,
  0x8F, 0x9F, 0x8F, 0x8F, 0x87, 0xC7, 0xFF, 0x8F, 0x87, 0x81, 0xF1, 0xFF,
  0x87, 0xC7, 0xC0, 0xF8, 0x7F, 0xC3, 0xE3, 0xE0, 0x7C, 0x1F, 0x83, 0xE1,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x00,
  0x3C, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x03,
  0xC0, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x7C,
  0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0xFC, 0x1F, 0x9F, 0xC0, 0xFC, 0x3F, 0x8F,
  0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xE0, 0xF8, 0x7E, 0x03,
  0xF1, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0xFC, 0x00,
  0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF0, 0xFC, 0x00,
  0x7F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0x00,
  0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x3C, 0x0E, 0xFE,
  0x79, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xCF,
  0x80, 0x1F, 0x9F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x7C, 0x01, 0x80, 0x60, 0x01, 0x00, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F,
  0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0x9F, 0xCF, 0xDF,
  0xC7, 0xFF, 0xC3, 0xF7, 0xC1, 0xF9, 0xC0, 0xFC, 0x40, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0xF0, 0xF0, 0x03,
  0xF8, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xF8,
  0x0F, 0xF0, 0xF0, 0x03, 0xF8, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE4, 0x00, 0x0F, 0xF3, 0x80, 0x0F, 0xF1, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C,
  0x7E, 0x00, 0x07, 0x87, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x07, 0xE0,
  0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E,
  0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x18, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0xC0, 0x01, 0xFC, 0xF0, 0x03, 0xFC, 0xFF, 0xBF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x20, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x83, 0xF0, 0x07, 0xC7, 0xFE, 0x07, 0xE7, 0xFF, 0x83, 0xF7, 0xFF,
  0xE1, 0xFB, 0xFF, 0xF8, 0xFF, 0xE3, 0xFC, 0x7F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x1F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xF0,
  0x3F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xF1, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF,
  0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0xFC,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83,
  0xF8, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x00,
  0xFF, 0x3F, 0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF,
  0x3F, 0x0F, 0xFE, 0x3F, 0x03, 0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x1F, 0x1F,
  0x9F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7E, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x3F, 0x9F,
  0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F,
  0x87, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xC0, 0xFE, 0x30, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0xE0,
  0x3C, 0x1F, 0x00, 0xFF, 0xF8, 0x3E, 0x3E, 0x01, 0xFF, 0xF8, 0x3E, 0x3E,
  0x03, 0xFF, 0xF8, 0x3E, 0x3E, 0x03, 0xE0, 0xF8, 0x1E, 0x7C, 0x07, 0xC0,
  0xF8, 0x1F, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x7C, 0x0F, 0x81, 0xF0, 0x1F,
  0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x78, 0x0F,
  0x81, 0xF0, 0x1F, 0x78, 0x1F, 0x01, 0xF0, 0x1F, 0x78, 0x1F, 0x01, 0xF0,
  0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0xF8, 0x1F, 0x03, 0xF0, 0x1E,
  0x78, 0x1F, 0x03, 0xF0, 0x3E, 0x78, 0x0F, 0x83, 0xF0, 0x3E, 0x7C, 0x0F,
  0x83, 0xF0, 0x3C, 0x7C, 0x0F, 0x87, 0xF8, 0x7C, 0x7C, 0x07, 0xEF, 0x7C,
  0xFC, 0x7C, 0x07, 0xFF, 0x3F, 0xF8, 0x7C, 0x03, 0xFE, 0x3F, 0xF0, 0x3E,
  0x01, 0xFC, 0x1F, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x04,
  0x00, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0x03, 0xFF, 0x8F, 0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF0,
  0x07, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x7F,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x03,
  0xE0, 0xFF, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x81, 0xFE, 0x00, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x40, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x00,
  0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x01, 0xFF, 0x0F, 0xC0, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x01, 0xFE, 0x00, 0x0E,
  0x07, 0xF0, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xF0,
  0xFF, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFB, 0xF8, 0x01, 0xFE, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFB, 0xE0, 0x00, 0x03, 0xFF, 0xFD, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0xFB, 0xFF, 0xDF, 0x00, 0x00,
  0x7D, 0xFF, 0xEF, 0x80, 0x00, 0x3E, 0xFF, 0xF7, 0xE0, 0x00, 0x3E, 0x7F,
  0xF9, 0xF0, 0x00, 0x1F, 0x3F, 0xFC, 0xF8, 0x00, 0x0F, 0x9F, 0xFE, 0x7E,
  0x00, 0x07, 0xCF, 0xFF, 0x1F, 0x00, 0x07, 0xC7, 0xFF, 0x8F, 0x80, 0x03,
  0xE3, 0xFF, 0xC7, 0xC0, 0x01, 0xF1, 0xFF, 0xE3, 0xF0, 0x01, 0xF0, 0xFF,
  0xF0, 0xF8, 0x00, 0xF8, 0x7F, 0xF8, 0x7C, 0x00, 0x7C, 0x3F, 0xFC, 0x3F,
  0x00, 0x3E, 0x1F, 0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0xFF, 0x07, 0xC0, 0x1F,
  0x07, 0xFF, 0x83, 0xE0, 0x0F, 0x83, 0xFF, 0xC1, 0xF8, 0x0F, 0xC1, 0xFF,
  0xE0, 0x7C, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0xF8, 0x1F,
  0x81, 0xF0, 0x3F, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0xFE, 0x03, 0xE0, 0xF8,
  0x0F, 0xFF, 0x01, 0xF0, 0x7C, 0x07, 0xFF, 0x80, 0xFC, 0x7E, 0x03, 0xFF,
  0xC0, 0x3E, 0x3E, 0x01, 0xFF, 0xE0, 0x1F, 0x1F, 0x00, 0xFF, 0xF0, 0x0F,
  0xCF, 0x80, 0x7F, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xF7, 0xC0,
  0x1F, 0xFE, 0x00, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFD, 0xF8, 0x00, 0x7F, 0xF7, 0xE0, 0x01, 0xFF, 0xCF, 0x80,
  0x07, 0xFF, 0x3F, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x7F, 0xF1, 0xF8, 0x01,
  0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0x0F, 0xC0, 0x1F, 0xFC, 0x3F, 0x00, 0x7F,
  0xF0, 0x7C, 0x01, 0xFF, 0xC1, 0xF8, 0x07, 0xFF, 0x03, 0xE0, 0x1F, 0xFC,
  0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x01,
  0xF8, 0x1F, 0xFC, 0x03, 0xE0, 0x7F, 0xF0, 0x0F, 0xC1, 0xFF, 0xC0, 0x3F,
  0x07, 0xFF, 0x00, 0x7E, 0x1F, 0xFC, 0x01, 0xF8, 0x7F, 0xF0, 0x03, 0xF1,
  0xFF, 0xC0, 0x0F, 0xC7, 0xFF, 0x00, 0x1F, 0x1F, 0xFC, 0x00, 0x7E, 0x7F,
  0xF0, 0x01, 0xF9, 0xFF, 0xC0, 0x03, 0xF7, 0xFF, 0x00, 0x0F, 0xDF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC,
  0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x3F, 0x00, 0xFF, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87,
  0xE0, 0x0F, 0xE0, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xE0, 0xFC, 0x7F, 0x80, 0x1C, 0x7F, 0x00, 0x04, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x80, 0x00, 0xFC, 0xC0,
  0x01, 0xFC, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0x7F,
  0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1E,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF8, 0x0F,
  0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x8F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x7C,
  0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3E,
  0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0x07, 0xE0,
  0xF8, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x00,
  0x3F, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x7D,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0x80,
  0x03, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xF0, 0x3F, 0x81, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFF, 0x07, 0xE7, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x3F, 0xBF, 0x00,
  0x7F, 0x7E, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x1E, 0xF9, 0xFF, 0xFD,
  0xF1, 0xFF, 0xF3, 0xE3, 0xFF, 0xC7, 0xC1, 0xFF, 0x07, 0x80, 0x70, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0xF8, 0x7F, 0xE0, 0x7C, 0x7F, 0xF8, 0x3E, 0x7F, 0xFE, 0x1F,
  0x7F, 0xFF, 0x8F, 0xBE, 0x3F, 0xC7, 0xFC, 0x07, 0xF3, 0xFC, 0x01, 0xF9,
  0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xF8, 0x01, 0xF9, 0xFE, 0x00, 0xFC, 0xFF, 0x80, 0xFE, 0x7D, 0xF1, 0xFE,
  0x3E, 0xFF, 0xFE, 0x1F, 0x3F, 0xFF, 0x0F, 0x8F, 0xFF, 0x07, 0x83, 0xFE,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0x1E, 0x1F, 0xC0, 0x23, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x03, 0x1F, 0xF1, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x3F, 0x03, 0xFF,
  0x0F, 0x83, 0xFF, 0xC7, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF1, 0xFE,
  0x3E, 0xF9, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x8F, 0xF1, 0xF7, 0xC7, 0xFF, 0xFB, 0xE1,
  0xFF, 0xF9, 0xF0, 0x7F, 0xF8, 0xF8, 0x1F, 0xF8, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x02, 0x1F, 0xC0, 0x0C, 0x1F, 0xF0, 0x7C, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0x87, 0xC1, 0xFF, 0xE3, 0xE1, 0xFF, 0xF9, 0xF1, 0xFF, 0xFE,
  0xF8, 0xFF, 0x1F, 0x7C, 0xFE, 0x03, 0xFE, 0x7E, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0x3F, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0xC7, 0xF8, 0xFB, 0xE3, 0xFF,
  0xF9, 0xF0, 0xFF, 0xFC, 0xF8, 0x3F, 0xFC, 0x7C, 0x0F, 0xF8, 0x7E, 0x00,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x40, 0x00, 0x7F, 0x18, 0x00, 0x7F, 0x0F, 0x80, 0xFF,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0xF8, 0x7F, 0xE1, 0xF1, 0xFF, 0xE3, 0xE7, 0xFF, 0xE7, 0xDF,
  0xFF, 0xCF, 0xBE, 0x3F, 0xDF, 0xF0, 0x3F, 0xBF, 0xC0, 0x3F, 0x7F, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE0, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03,
  0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xE8, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFD, 0xF0,
  0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0x80, 0x7F, 0x1F, 0x00,
  0xFC, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7E,
  0x03, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x7E, 0x00, 0x7C, 0xFE, 0x00, 0xFB, 0xFC, 0x01, 0xF7, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0,
  0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x00,
  0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x1F,
  0x81, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xC7, 0xFF, 0x83, 0xFF, 0xC7, 0xCF,
  0xFF, 0x8F, 0xFF, 0xCF, 0xBF, 0xFF, 0xBF, 0xFF, 0x9F, 0xF8, 0xFF, 0x7C,
  0x7F, 0xBF, 0xC0, 0x7F, 0xE0, 0x7F, 0x7F, 0x00, 0xFF, 0x80, 0x7E, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0xFF,
  0xC3, 0xC3, 0xFF, 0xC7, 0xCF, 0xFF, 0xCF, 0xBF, 0xFF, 0x9F, 0xFC, 0x7F,
  0xBF, 0xE0, 0x7F, 0x7F, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x3F, 0x81, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0x00, 0x78, 0x3F, 0xF0, 0x3E, 0x3F, 0xFC, 0x1F, 0x3F, 0xFF, 0x0F, 0xBF,
  0xFF, 0xC7, 0xDE, 0x1F, 0xE3, 0xFE, 0x03, 0xF9, 0xFE, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0xFC, 0xFF, 0x00, 0x7E, 0x7F, 0xC0, 0x7F, 0x3E, 0xF9, 0xFF, 0x1F,
  0x7F, 0xFF, 0x0F, 0x9F, 0xFF, 0x87, 0xC7, 0xFF, 0x83, 0xE1, 0xFF, 0x81,
  0xF0, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x87, 0xC1,
  0xFF, 0xE3, 0xE1, 0xFF, 0xF9, 0xF1, 0xFF, 0xFE, 0xF8, 0xFF, 0x1F, 0x7C,
  0xFE, 0x03, 0xFE, 0x7E, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x7F,
  0x9F, 0xC0, 0x7F, 0xC7, 0xF8, 0xFB, 0xE3, 0xFF, 0xF9, 0xF0, 0xFF, 0xFC,
  0xF8, 0x3F, 0xFC, 0x7C, 0x0F, 0xF8, 0x3E, 0x00, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x1E, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF9, 0xFE, 0xFB, 0xFE,
  0xFB, 0xE2, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0x3C, 0x7E, 0x00, 0xC7,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xC0, 0x07, 0xEF, 0x00, 0xFE, 0xFF, 0x7F, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFB,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7C, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x01,
  0xFF, 0x3F, 0xFF, 0xDF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF,
  0x1F, 0x07, 0xFC, 0x1F, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F,
  0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xF8, 0x01,
  0xF3, 0xF0, 0x07, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0xFC,
  0x01, 0xEF, 0x00, 0x7E, 0x7E, 0x00, 0xF7, 0x80, 0x3E, 0x1F, 0x00, 0xFB,
  0xE0, 0x1F, 0x0F, 0xC0, 0x7D, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x1E, 0x03, 0xE0, 0x7C,
  0x0F, 0x8F, 0x81, 0xF0, 0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x1F, 0x83, 0xE3,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF1, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x78, 0x3E,
  0x01, 0xF0, 0xF8, 0x3E, 0x1F, 0x00, 0xFC, 0x7C, 0x1F, 0x1F, 0x80, 0x7E,
  0x3E, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x03,
  0xE3, 0xE0, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x01, 0xFB, 0xE0, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x3E,
  0xF0, 0x0F, 0xBE, 0x00, 0x1F, 0x78, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x01,
  0xEF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF3, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF7, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x10, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x23, 0xFE, 0x00, 0x04, 0xFF, 0xF0, 0x03, 0xBF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF6, 0x00, 0x3F, 0xFC,
  0x80, 0x01, 0xFE, 0x10, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 52, 17, 5, -51 },
  { 47, 19, 19, 27, 4, -51 },
  { 93, 30, 51, 33, 1, -51 },
  { 285, 25, 58, 30, 3, -54 },
  { 467, 41, 52, 47, 3, -51 },
  { 734, 32, 52, 34, 2, -51 },
  { 942, 7, 19, 15, 4, -51 },
  { 959, 16, 62, 21, 3, -51 },
  { 1083, 15, 62, 21, 2, -51 },
  { 1200, 23, 24, 28, 3, -54 },
  { 1269, 26, 34, 31, 2, -42 },
  { 1380, 9, 17, 16, 3, -8 },
  { 1400, 16, 6, 19, 2, -22 },
  { 1412, 8, 9, 16, 4, -8 },
  { 1421, 24, 51, 26, 1, -51 },
  { 1574, 24, 52, 30, 3, -51 },
  { 1730, 17, 51, 30, 4, -51 },
  { 1839, 25, 51, 30, 2, -51 },
  { 1999, 25, 52, 30, 2, -51 },
  { 2162, 28, 51, 30, 1, -51 },
  { 2341, 24, 52, 30, 3, -51 },
  { 2497, 25, 52, 30, 3, -51 },
  { 2660, 26, 51, 30, 2, -51 },
  { 2826, 26, 52, 30, 2, -51 },
  { 2995, 24, 52, 30, 3, -51 },
  { 3151, 8, 39, 16, 4, -38 },
  { 3190, 9, 47, 16, 3, -38 },
  { 3243, 26, 32, 31, 2, -41 },
  { 3347, 26, 20, 31, 2, -35 },
  { 3412, 26, 32, 31, 2, -41 },
  { 3516, 20, 52, 23, 1, -51 },
  { 3646, 40, 57, 46, 3, -51 },
  { 3931, 32, 51, 32, 0, -51 },
  { 4135, 26, 51, 34, 5, -51 },
  { 4301, 26, 52, 32, 4, -51 },
  { 4470, 28, 51, 37, 5, -51 },
  { 4649, 20, 51, 29, 5, -51 },
  { 4777, 20, 51, 27, 5, -51 },
  { 4905, 31, 52, 39, 4, -51 },
  { 5107, 28, 51, 38, 5, -51 },
  { 5286, 16, 51, 20, 2, -51 },
  { 5388, 14, 65, 16, -3, -51 },
  { 5502, 27, 51, 32, 5, -51 },
  { 5675, 20, 51, 26, 5, -51 },
  { 5803, 41, 51, 51, 5, -51 },
  { 6065, 30, 51, 40, 5, -51 },
  { 6257, 32, 52, 39, 4, -51 },
  { 6465, 24, 51, 31, 5, -51 },
  { 6618, 32, 63, 39, 4, -51 },
  { 6870, 27, 51, 33, 5, -51 },
  { 7043, 24, 52, 29, 3, -51 },
  { 7199, 25, 51, 27, 1, -51 },
  { 7359, 27, 52, 37, 5, -51 },
  { 7535, 31, 51, 31, 0, -51 },
  { 7733, 51, 51, 51, 0, -51 },
  { 8059, 28, 51, 28, 0, -51 },
  { 8238, 28, 51, 28, 0, -51 },
  { 8417, 22, 51, 26, 2, -51 },
  { 8558, 15, 62, 22, 5, -51 },
  { 8675, 24, 51, 26, 1, -51 },
  { 8828, 15, 62, 22, 2, -51 },
  { 8945, 29, 27, 31, 1, -51 },
  { 9043, 31, 4, 31, 0, 6 },
  { 9059, 13, 11, 19, 3, -54 },
  { 9077, 23, 40, 30, 2, -39 },
  { 9192, 25, 55, 33, 5, -54 },
  { 9364, 20, 40, 25, 3, -39 },
  { 9464, 25, 55, 33, 3, -54 },
  { 9636, 24, 40, 30, 3, -39 },
  { 9756, 19, 54, 18, 1, -54 },
  { 9885, 25, 56, 33, 3, -39 },
  { 10060, 23, 54, 32, 5, -54 },
  { 10216, 7, 52, 15, 4, -52 },
  { 10262, 12, 69, 15, -1, -52 },
  { 10366, 23, 54, 28, 5, -54 },
  { 10522, 5, 54, 15, 5, -54 },
  { 10556, 39, 39, 48, 5, -39 },
  { 10747, 23, 39, 32, 5, -39 },
  { 10860, 26, 40, 32, 3, -39 },
  { 10990, 25, 56, 33, 5, -39 },
  { 11165, 25, 56, 33, 3, -39 },
  { 11340, 16, 39, 22, 5, -39 },
  { 11418, 20, 40, 24, 2, -39 },
  { 11518, 16, 48, 18, 1, -47 },
  { 11614, 24, 39, 32, 4, -38 },
  { 11731, 26, 38, 26, 0, -38 },
  { 11855, 41, 38, 43, 1, -38 },
  { 12050, 25, 38, 26, 1, -38 },
  { 12169, 26, 55, 26, 0, -38 },
  { 12348, 18, 38, 22, 2, -38 },
  { 12434, 20, 62, 26, 3, -51 },
  { 12589, 5, 71, 29, 12, -54 },
  { 12634, 20, 62, 26, 3, -51 },
  { 12789, 27, 10, 31, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Regular71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR71PT7B_H_
