#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0xD0, 0x29, 0x4D, 0xF5, 0x2B, 0xEA, 0x50, 0x23,
  0xE8, 0xC6, 0x1C, 0xBE, 0x21, 0x00, 0x44, 0x64, 0xA8, 0xA8, 0x6E, 0x55,
  0x15, 0x25, 0x26, 0x21, 0x45, 0x14, 0x61, 0xA9, 0xA6, 0x7C, 0xF0, 0x5A,
  0xAA, 0xA4, 0x89, 0x12, 0x49, 0x4B, 0x00, 0x2F, 0x25, 0x21, 0x3E, 0x42,
  0x10, 0x58, 0xE0, 0x80, 0x11, 0x12, 0x24, 0x44, 0x80, 0x22, 0x94, 0x9C,
  0xE5, 0x2A, 0x70, 0x2E, 0x92, 0x49, 0x20, 0x66, 0x84, 0x21, 0x10, 0x88,
  0xF8, 0x64, 0x84, 0x26, 0x08, 0x22, 0xF0, 0x11, 0x8C, 0xA5, 0x2B, 0xE2,
  0x10, 0xE8, 0x88, 0xE3, 0x12, 0xE0, 0x68, 0x88, 0xE9, 0x9A, 0xE0, 0xF8,
  0x44, 0x21, 0x10, 0x84, 0x40, 0x32, 0x92, 0xA2, 0x2A, 0x31, 0x70, 0x22,
  0xA5, 0x15, 0xB4, 0x42, 0x60, 0x84, 0x40, 0x16, 0x09, 0xB0, 0xC1, 0x80,
  0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x00, 0x6A, 0x12, 0x24, 0x40, 0x40, 0x31,
  0x28, 0x6D, 0xD7, 0x5D, 0x6A, 0x81, 0xE0, 0x21, 0x8C, 0xA5, 0x3D, 0x31,
  0x88, 0xE9, 0x99, 0xE9, 0x99, 0xF0, 0x7D, 0x88, 0x88, 0x88, 0x70, 0xC5,
  0xA5, 0x38, 0xC6, 0x52, 0xE0, 0xF2, 0x4F, 0x24, 0xE0, 0xF2, 0x4F, 0x24,
  0x80, 0x36, 0x61, 0x09, 0xC6, 0x31, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31,
  0x88, 0xE9, 0x24, 0x92, 0xE0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x99, 0xAA,
  0xCA, 0xA9, 0x90, 0x92, 0x49, 0x24, 0xE0, 0x87, 0x8F, 0x1E, 0x5A, 0xB5,
  0x6A, 0xD9, 0x92, 0x8E, 0x73, 0x9A, 0xD6, 0x73, 0x88, 0x66, 0xA3, 0x18,
  0xC6, 0x33, 0x70, 0xCB, 0x99, 0xBE, 0x88, 0x80, 0x66, 0xA3, 0x18, 0xC6,
  0x33, 0x70, 0x86, 0xCB, 0x99, 0xEA, 0xA9, 0x90, 0x32, 0x90, 0x86, 0x08,
  0x62, 0xF0, 0xF2, 0x22, 0x22, 0x22, 0x20, 0x99, 0x99, 0x99, 0x99, 0xF0,
  0x8C, 0x72, 0x95, 0x29, 0x46, 0x20, 0x88, 0xC4, 0xA6, 0x4B, 0x25, 0x52,
  0xA9, 0x58, 0x4C, 0x22, 0x00, 0x8A, 0x94, 0xC2, 0x31, 0x4A, 0x98, 0x8C,
  0x94, 0xA6, 0x10, 0x84, 0x20, 0xF1, 0x32, 0x24, 0x44, 0xF0, 0xEA, 0xAA,
  0xAC, 0x84, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x21,
  0x14, 0xA8, 0x80, 0xF8, 0xC4, 0x25, 0x17, 0xD9, 0x70, 0x88, 0xAD, 0x99,
  0x99, 0xE0, 0x56, 0x49, 0x38, 0x08, 0x4A, 0xB4, 0xE5, 0x29, 0x78, 0x4A,
  0x9F, 0x88, 0xE0, 0x69, 0xE4, 0x92, 0x40, 0x22, 0xD3, 0x94, 0xA5, 0xE1,
  0x0B, 0x80, 0x88, 0xEB, 0x99, 0x99, 0x90, 0xDF, 0x80, 0x51, 0x55, 0x56,
  0x88, 0x9A, 0xCC, 0xAA, 0xB0, 0xFF, 0x80, 0x6A, 0xD9, 0x65, 0x96, 0x59,
  0x40, 0x6B, 0x99, 0x99, 0x90, 0x22, 0x93, 0x94, 0xA5, 0xC0, 0x69, 0x99,
  0x99, 0xE8, 0x88, 0x22, 0xD3, 0x94, 0xA5, 0xE1, 0x08, 0x40, 0x3A, 0x49,
  0x20, 0x2D, 0x86, 0x31, 0xE0, 0x4F, 0x24, 0x93, 0x99, 0x99, 0x9F, 0x95,
  0x56, 0x62, 0x93, 0x35, 0xAB, 0x66, 0xCC, 0x80, 0xD6, 0x26, 0x59, 0x95,
  0x56, 0x62, 0x24, 0xC0, 0xE5, 0x25, 0xC0, 0x12, 0x22, 0x2C, 0x22, 0x22,
  0x30, 0xFF, 0xF0, 0x86, 0x22, 0x23, 0x22, 0x22, 0xC0, 0xEC, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 5, 9, 6, 0, -9 },
  { 11, 5, 10, 5, 0, -9 },
  { 18, 8, 9, 8, 0, -9 },
  { 27, 6, 9, 6, 0, -9 },
  { 34, 1, 4, 3, 1, -9 },
  { 35, 2, 11, 3, 1, -9 },
  { 38, 3, 11, 3, 0, -9 },
  { 43, 4, 4, 5, 0, -9 },
  { 45, 5, 6, 5, 0, -7 },
  { 49, 2, 3, 3, 0, -1 },
  { 50, 3, 1, 3, 0, -4 },
  { 51, 1, 1, 3, 1, -1 },
  { 52, 4, 9, 4, 0, -9 },
  { 57, 5, 9, 5, 0, -9 },
  { 63, 3, 9, 5, 1, -9 },
  { 67, 5, 9, 5, 0, -9 },
  { 73, 5, 9, 5, 0, -9 },
  { 79, 5, 9, 5, 0, -9 },
  { 85, 4, 9, 5, 1, -9 },
  { 90, 4, 9, 5, 1, -9 },
  { 95, 5, 9, 5, 0, -9 },
  { 101, 5, 9, 5, 0, -9 },
  { 107, 5, 9, 5, 0, -9 },
  { 113, 1, 6, 3, 1, -6 },
  { 114, 2, 8, 3, 0, -6 },
  { 116, 5, 5, 5, 0, -7 },
  { 120, 5, 3, 5, 0, -6 },
  { 122, 5, 5, 5, 0, -7 },
  { 126, 4, 9, 4, 0, -9 },
  { 131, 6, 10, 8, 1, -9 },
  { 139, 5, 9, 5, 0, -9 },
  { 145, 4, 9, 6, 1, -9 },
  { 150, 4, 9, 5, 1, -9 },
  { 155, 5, 9, 6, 1, -9 },
  { 161, 3, 9, 5, 1, -9 },
  { 165, 3, 9, 5, 1, -9 },
  { 169, 5, 9, 7, 1, -9 },
  { 175, 5, 9, 6, 1, -9 },
  { 181, 3, 9, 3, 0, -9 },
  { 185, 3, 11, 3, -1, -9 },
  { 190, 4, 9, 5, 1, -9 },
  { 195, 3, 9, 4, 1, -9 },
  { 199, 7, 9, 9, 1, -9 },
  { 207, 5, 9, 7, 1, -9 },
  { 213, 5, 9, 7, 1, -9 },
  { 219, 4, 9, 5, 1, -9 },
  { 224, 5, 11, 7, 1, -9 },
  { 231, 4, 9, 6, 1, -9 },
  { 236, 5, 9, 5, 0, -9 },
  { 242, 4, 9, 5, 0, -9 },
  { 247, 4, 9, 6, 1, -9 },
  { 252, 5, 9, 5, 0, -9 },
  { 258, 9, 9, 9, 0, -9 },
  { 269, 5, 9, 5, 0, -9 },
  { 275, 5, 9, 5, 0, -9 },
  { 281, 4, 9, 4, 0, -9 },
  { 286, 2, 11, 4, 1, -9 },
  { 289, 4, 9, 4, 0, -9 },
  { 294, 3, 11, 4, 0, -9 },
  { 299, 5, 5, 5, 0, -9 },
  { 303, 5, 1, 5, 0, 1 },
  { 304, 3, 2, 3, 0, -9 },
  { 305, 4, 7, 5, 0, -7 },
  { 309, 4, 9, 6, 1, -9 },
  { 314, 3, 7, 4, 1, -7 },
  { 317, 5, 9, 6, 0, -9 },
  { 323, 4, 7, 5, 1, -7 },
  { 327, 3, 9, 3, 0, -9 },
  { 331, 5, 10, 6, 0, -7 },
  { 338, 4, 9, 5, 1, -9 },
  { 343, 1, 9, 3, 1, -9 },
  { 345, 2, 12, 3, 0, -9 },
  { 348, 4, 9, 5, 1, -9 },
  { 353, 1, 9, 3, 1, -9 },
  { 355, 6, 7, 8, 1, -7 },
  { 361, 4, 7, 5, 1, -7 },
  { 365, 5, 7, 5, 0, -7 },
  { 370, 4, 10, 6, 1, -7 },
  { 375, 5, 10, 6, 0, -7 },
  { 382, 3, 7, 4, 1, -7 },
  { 385, 4, 7, 4, 0, -7 },
  { 389, 3, 8, 3, 0, -8 },
  { 392, 4, 6, 5, 1, -6 },
  { 395, 4, 6, 4, 0, -6 },
  { 398, 7, 6, 7, 0, -6 },
  { 404, 4, 6, 4, 0, -6 },
  { 407, 4, 9, 4, 0, -6 },
  { 412, 3, 6, 4, 0, -6 },
  { 415, 4, 11, 4, 0, -9 },
  { 421, 1, 12, 5, 2, -9 },
  { 423, 4, 11, 4, 0, -9 },
  { 429, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Regular12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR12PT7B_H_
