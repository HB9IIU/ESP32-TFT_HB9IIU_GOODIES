#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF,
  0x7F, 0x7F, 0x7E, 0x08, 0xFE, 0x0F, 0xFF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7E,
  0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF3, 0xE0, 0x7E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0x3C, 0x1C, 0x7C, 0x3C, 0x04, 0xFC, 0x3C,
  0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C,
  0x00, 0x7E, 0x3C, 0x00, 0x7F, 0xBC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3D, 0xFE, 0x00, 0x3C, 0x7E, 0x00, 0x3C,
  0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C,
  0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C,
  0x3F, 0xC0, 0x3C, 0x7E, 0xF0, 0x3C, 0xFE, 0xFF, 0xBF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x03,
  0xE1, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x3C,
  0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x78,
  0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x7C,
  0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0x07, 0xC0,
  0x00, 0x78, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0xF0, 0x1C, 0x07, 0xC0, 0xF8,
  0xF8, 0x3F, 0x83, 0xE0, 0x7C, 0x7C, 0x3F, 0xE1, 0xF0, 0x3C, 0x3C, 0x3F,
  0xF8, 0x78, 0x1E, 0x3E, 0x3F, 0x7E, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x0F, 0x0F, 0x0F, 0x07, 0xC7, 0xFF, 0x8F, 0x8F, 0x83, 0xE3, 0xFF, 0x87,
  0xC7, 0xC1, 0xF0, 0xFF, 0xC3, 0xC3, 0xC0, 0x78, 0x3F, 0xC3, 0xE1, 0xE0,
  0x3C, 0x03, 0x81, 0xF0, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x0F, 0x80,
  0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x00, 0x3C,
  0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x1F, 0x00,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0xFC, 0x1F, 0xDF, 0x80, 0xF8, 0x3F, 0x8F, 0xC0,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0xFC, 0x01, 0xF9, 0xF0, 0xFC, 0x01, 0xFB,
  0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x7F,
  0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0xFF,
  0xE0, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xF1,
  0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x08, 0x07, 0x80, 0xBE, 0x1E, 0x1E, 0xFF, 0x7B, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x3F,
  0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x38, 0x0F, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F,
  0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0x9F, 0xCF, 0xDF,
  0xC7, 0xFF, 0xC3, 0xF3, 0xC1, 0xF8, 0xC0, 0xFC, 0x40, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xF8, 0x07, 0xF0, 0x70,
  0x01, 0xFC, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xE0,
  0xF8, 0x07, 0xF8, 0x70, 0x01, 0xFC, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE4, 0x00,
  0x0F, 0xE3, 0x80, 0x0F, 0xF1, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF7, 0xE0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x3C, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x78, 0x7E, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0,
  0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3E, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0xC0, 0x01, 0xFC, 0xF0, 0x07, 0xF8, 0xFF, 0x3F,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x3F, 0xC0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF,
  0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7F,
  0x01, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xBE, 0x1F, 0xFF, 0x3E, 0x0F, 0xFE, 0x3E, 0x07, 0xFC, 0x3E,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x7E, 0x18, 0x1E, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x3F, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x78, 0x0F, 0xE2, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0xFC, 0x1F, 0x1F, 0x00,
  0xFF, 0xF8, 0x1E, 0x3E, 0x03, 0xFF, 0xF0, 0x3E, 0x7C, 0x07, 0xC3, 0xE0,
  0x7C, 0xF0, 0x1F, 0x07, 0xC0, 0xFB, 0xE0, 0x3E, 0x0F, 0x81, 0xF7, 0xC0,
  0xF8, 0x1F, 0x01, 0xEF, 0x81, 0xF0, 0x3E, 0x03, 0xDF, 0x03, 0xC0, 0x7C,
  0x07, 0xBC, 0x0F, 0x80, 0xF8, 0x0F, 0x78, 0x1F, 0x01, 0xF0, 0x1F, 0xF0,
  0x3E, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07, 0xC0, 0x7F, 0xC0, 0xF8, 0x0F,
  0x80, 0xFF, 0x81, 0xF0, 0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x3E, 0x03, 0xFE,
  0x07, 0xC0, 0xFC, 0x0F, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xE0, 0x7D, 0xE0, 0x7C, 0x0F, 0xC0, 0xF3,
  0xC0, 0x7C, 0x3F, 0x83, 0xE7, 0xC0, 0xF8, 0x77, 0x07, 0xCF, 0x81, 0xF9,
  0xEF, 0x1F, 0x1F, 0x01, 0xFF, 0x9F, 0xFE, 0x3E, 0x03, 0xFF, 0x1F, 0xF8,
  0x7C, 0x03, 0xFC, 0x1F, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x10,
  0x00, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0xFF, 0x8F, 0xC0, 0x0F,
  0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xC0, 0xFF, 0xE3, 0xF0, 0x03, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x01,
  0xFC, 0xFC, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xE0, 0x3F, 0x80, 0x04,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x04, 0x0F, 0xF8, 0x03, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
  0x7F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0xE0, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0x03, 0xFC, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x08, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFB, 0xF0, 0x00, 0xFF, 0xF7, 0xE0,
  0x01, 0xFF, 0xEF, 0xC0, 0x03, 0xFF, 0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x00, 0xFB, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x07, 0xCF, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x3E, 0x3F, 0x80, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0xF8, 0x7F, 0x80, 0x01,
  0xF0, 0x7F, 0x80, 0x03, 0xE0, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xFA, 0x0F,
  0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x02, 0x00, 0xFC,
  0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0x80, 0x0F, 0xF3, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFB, 0xE0, 0x00,
  0x07, 0xFF, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x07, 0xDF,
  0xF9, 0xF0, 0x00, 0x07, 0xDF, 0xFD, 0xF0, 0x00, 0x0F, 0x9F, 0xFD, 0xF0,
  0x00, 0x0F, 0x9F, 0xFD, 0xF8, 0x00, 0x0F, 0x9F, 0xFC, 0xF8, 0x00, 0x1F,
  0x9F, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0xFC,
  0x7C, 0x00, 0x1F, 0x1F, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0xFC, 0x7C, 0x00,
  0x3E, 0x1F, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0xFC, 0x3E, 0x00, 0x7E, 0x1F,
  0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0xFC, 0x1F,
  0x00, 0x7C, 0x1F, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0x00, 0xF8,
  0x1F, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0xFC,
  0x0F, 0x81, 0xF0, 0x1F, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0xFC, 0x07, 0xC1,
  0xF0, 0x1F, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0xFC, 0x07, 0xC3, 0xE0, 0x1F,
  0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0xFC, 0x03,
  0xE7, 0xC0, 0x1F, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xEF, 0x80, 0x03, 0xFF, 0xBF, 0x00, 0x0F, 0xFE, 0xFC, 0x00, 0x3F,
  0xFD, 0xF8, 0x00, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xCF, 0x80, 0x0F, 0xFF,
  0x3F, 0x00, 0x3F, 0xFC, 0x7C, 0x00, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xC7,
  0xE0, 0x0F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0x3F, 0x00, 0xFF, 0xF0, 0x7C,
  0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xFF, 0x03, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF, 0x01, 0xF8, 0x3F,
  0xFC, 0x03, 0xE0, 0xFF, 0xF0, 0x0F, 0xC3, 0xFF, 0xC0, 0x3F, 0x0F, 0xFF,
  0x00, 0x7E, 0x3F, 0xFC, 0x01, 0xF8, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xC0,
  0x0F, 0xCF, 0xFF, 0x00, 0x1F, 0x3F, 0xFC, 0x00, 0x7E, 0xFF, 0xF0, 0x01,
  0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xDF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0xFC, 0x01, 0xFC, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x0F,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F,
  0x3F, 0x80, 0x04, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF4, 0x00, 0x07, 0xEC, 0x00,
  0x1F, 0xDF, 0x00, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xBC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x81, 0xF8, 0x00,
  0xF3, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x80, 0xFC,
  0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x7C, 0x03, 0xF0, 0x07,
  0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x00,
  0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7E,
  0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x3E, 0x07,
  0xE0, 0x03, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x01, 0xF0,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0xC0, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0xBF, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x7F, 0x81, 0xC0, 0x3F,
  0x81, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xF3, 0xF3, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xDF, 0x80, 0x3F,
  0xBF, 0x00, 0xFF, 0x7E, 0x03, 0xFE, 0xFF, 0x0F, 0x7C, 0xFF, 0xFC, 0xF9,
  0xFF, 0xF9, 0xF1, 0xFF, 0xE3, 0xE1, 0xFF, 0x07, 0xC0, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80,
  0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC,
  0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFE, 0xFF, 0x80, 0xFC,
  0xFF, 0xC3, 0xFC, 0xFB, 0xFF, 0xF8, 0xF9, 0xFF, 0xF0, 0xF0, 0xFF, 0xF0,
  0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x04, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x21, 0xFF, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x3F, 0x07, 0xFF,
  0x1F, 0x87, 0xFF, 0xCF, 0xC3, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0xF3, 0xFC,
  0x1F, 0xF9, 0xF8, 0x07, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0,
  0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0x7F,
  0x01, 0xFF, 0x1F, 0xC3, 0xEF, 0x8F, 0xFF, 0xE7, 0xC3, 0xFF, 0xF3, 0xE0,
  0xFF, 0xF1, 0xF0, 0x3F, 0xE0, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFE, 0xFF, 0x83,
  0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC,
  0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x02, 0x1F, 0xC0, 0x0C, 0x3F, 0xE0, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x81, 0xFE, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0x81, 0xFF, 0x87, 0xC3, 0xFF,
  0xE3, 0xE1, 0xFF, 0xF9, 0xF1, 0xFF, 0xFE, 0xF9, 0xFE, 0x0F, 0xFC, 0xFC,
  0x03, 0xFE, 0x7E, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0,
  0x01, 0xFD, 0xF8, 0x01, 0xFE, 0x7E, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x8F,
  0xF1, 0xFF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFF, 0xF3, 0xF0, 0x7F, 0xF9, 0xF8,
  0x1F, 0xF0, 0xFC, 0x01, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x40, 0x00, 0xFC, 0x30, 0x00,
  0xFE, 0x1F, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0xF8, 0xFF, 0xE1, 0xF3, 0xFF, 0xE3,
  0xEF, 0xFF, 0xE7, 0xDF, 0xFF, 0xCF, 0xF8, 0x1F, 0xDF, 0xE0, 0x1F, 0xBF,
  0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xE0, 0x38, 0xFB, 0xF7, 0xFF, 0xFF, 0xDF, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE0, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE9, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x7C, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0xF8, 0x01, 0xF9,
  0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F,
  0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0,
  0x7E, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x3F,
  0x00, 0x3E, 0x7E, 0x00, 0x7D, 0xFE, 0x00, 0xFB, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x07, 0xFB, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x83,
  0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0,
  0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xC3,
  0xFF, 0x03, 0xFF, 0x8F, 0x1F, 0xFE, 0x1F, 0xFF, 0x3C, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFB, 0xFF, 0xF3, 0xFF, 0xFB, 0xFE, 0x0F, 0xFE, 0x0F, 0xEF, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0xF0, 0x3F, 0x81, 0xE1, 0xFF,
  0xC3, 0xC7, 0xFF, 0xC7, 0x9F, 0xFF, 0xCF, 0xBF, 0xFF, 0x9F, 0xF0, 0x7F,
  0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xF1, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xF0,
  0x3F, 0x80, 0xF0, 0xFF, 0xE0, 0xF1, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFB,
  0xFF, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFE, 0xFF,
  0x81, 0xFC, 0xFF, 0xE7, 0xFC, 0xFB, 0xFF, 0xF8, 0xF9, 0xFF, 0xF0, 0xF8,
  0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0xF8, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x81,
  0xFF, 0x87, 0xC3, 0xFF, 0xE3, 0xE1, 0xFF, 0xF9, 0xF1, 0xFF, 0xFE, 0xF9,
  0xFE, 0x0F, 0xFC, 0xFC, 0x03, 0xFE, 0x7E, 0x00, 0xFF, 0x7E, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7,
  0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x01, 0xFE, 0x7E, 0x00, 0xFF,
  0x3F, 0x80, 0xFF, 0x8F, 0xF1, 0xFF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFF, 0xF3,
  0xF0, 0x7F, 0xF1, 0xF8, 0x1F, 0xF0, 0xFC, 0x01, 0xC0, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0xF0, 0x3F, 0xF0, 0xFE, 0xF1, 0xFE, 0xF1, 0xFE, 0xF3, 0xFE, 0xFB, 0xFE,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFE, 0x03, 0x9F, 0x80, 0x17, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xEF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xF3, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x78, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0xFF, 0x7F, 0x03, 0xFE, 0x7F, 0xBF,
  0xFC, 0xFF, 0xFE, 0xF8, 0xFF, 0xF8, 0xF0, 0xFF, 0xE1, 0xE0, 0xFF, 0x83,
  0xC0, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xC0, 0x07, 0xDF,
  0x80, 0x1F, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xFE, 0x00, 0xF8, 0xFC, 0x01, 0xFF, 0x00,
  0x7C, 0x7E, 0x01, 0xFF, 0x80, 0x3E, 0x1F, 0x00, 0xFB, 0xC0, 0x3F, 0x0F,
  0x80, 0x7D, 0xE0, 0x1F, 0x87, 0xE0, 0x3C, 0xF8, 0x0F, 0x83, 0xF0, 0x1E,
  0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x9F, 0x03,
  0xF0, 0x3E, 0x07, 0xC7, 0x81, 0xF0, 0x1F, 0x83, 0xE3, 0xE0, 0xF8, 0x0F,
  0xC1, 0xE1, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0xF8, 0x7E, 0x01, 0xF0, 0xF8,
  0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x0F, 0x8F,
  0x80, 0x3F, 0x1E, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x03, 0xE7, 0xE0, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x3C, 0xF8, 0x00, 0xF9, 0xE0, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x0F, 0xBE,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03,
  0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xC3, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x11, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFA, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x70, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 51, 16, 4, -50 },
  { 52, 19, 18, 27, 4, -50 },
  { 95, 30, 50, 32, 1, -50 },
  { 283, 24, 57, 30, 3, -53 },
  { 454, 41, 52, 46, 3, -51 },
  { 721, 32, 52, 33, 2, -51 },
  { 929, 7, 18, 15, 4, -50 },
  { 945, 15, 61, 20, 3, -50 },
  { 1060, 15, 61, 20, 2, -50 },
  { 1175, 22, 23, 28, 3, -53 },
  { 1239, 26, 33, 30, 2, -41 },
  { 1347, 9, 17, 16, 3, -8 },
  { 1367, 15, 6, 19, 2, -22 },
  { 1379, 8, 9, 16, 4, -8 },
  { 1388, 24, 50, 26, 1, -50 },
  { 1538, 24, 52, 30, 3, -51 },
  { 1694, 17, 50, 30, 4, -50 },
  { 1801, 25, 51, 30, 2, -51 },
  { 1961, 25, 52, 30, 2, -51 },
  { 2124, 28, 50, 30, 1, -50 },
  { 2299, 24, 51, 30, 3, -50 },
  { 2452, 24, 52, 30, 3, -51 },
  { 2608, 26, 50, 30, 2, -50 },
  { 2771, 26, 52, 30, 2, -51 },
  { 2940, 24, 52, 30, 3, -51 },
  { 3096, 8, 39, 16, 4, -38 },
  { 3135, 9, 47, 16, 3, -38 },
  { 3188, 26, 31, 30, 2, -40 },
  { 3289, 26, 20, 30, 2, -35 },
  { 3354, 26, 31, 30, 2, -40 },
  { 3455, 20, 52, 22, 1, -51 },
  { 3585, 39, 56, 46, 3, -50 },
  { 3858, 32, 50, 32, 0, -50 },
  { 4058, 26, 50, 33, 5, -50 },
  { 4221, 27, 52, 31, 3, -51 },
  { 4397, 28, 50, 36, 5, -50 },
  { 4572, 20, 50, 28, 5, -50 },
  { 4697, 20, 50, 27, 5, -50 },
  { 4822, 31, 52, 38, 3, -51 },
  { 5024, 27, 50, 37, 5, -50 },
  { 5193, 15, 50, 20, 2, -50 },
  { 5287, 14, 64, 16, -3, -50 },
  { 5399, 27, 50, 31, 5, -50 },
  { 5568, 20, 50, 26, 5, -50 },
  { 5693, 40, 50, 50, 5, -50 },
  { 5943, 30, 50, 40, 5, -50 },
  { 6131, 32, 52, 39, 3, -51 },
  { 6339, 24, 50, 31, 5, -50 },
  { 6489, 32, 63, 39, 3, -51 },
  { 6741, 26, 50, 32, 5, -50 },
  { 6904, 23, 52, 29, 3, -51 },
  { 7054, 25, 50, 27, 1, -50 },
  { 7211, 27, 51, 37, 5, -50 },
  { 7384, 31, 50, 31, 0, -50 },
  { 7578, 50, 50, 50, 0, -50 },
  { 7891, 28, 50, 28, 0, -50 },
  { 8066, 27, 50, 27, 0, -50 },
  { 8235, 22, 50, 25, 2, -50 },
  { 8373, 15, 61, 22, 5, -50 },
  { 8488, 24, 50, 26, 1, -50 },
  { 8638, 15, 61, 22, 2, -50 },
  { 8753, 29, 27, 31, 1, -50 },
  { 8851, 31, 4, 31, 0, 6 },
  { 8867, 13, 12, 19, 3, -54 },
  { 8887, 23, 39, 29, 2, -38 },
  { 9000, 24, 54, 32, 5, -53 },
  { 9162, 20, 39, 24, 3, -38 },
  { 9260, 25, 54, 32, 3, -53 },
  { 9429, 23, 39, 29, 3, -38 },
  { 9542, 18, 54, 18, 1, -54 },
  { 9664, 25, 55, 32, 3, -38 },
  { 9836, 23, 53, 32, 5, -53 },
  { 9989, 7, 52, 15, 4, -52 },
  { 10035, 12, 69, 15, -1, -52 },
  { 10139, 23, 53, 28, 5, -53 },
  { 10292, 5, 53, 15, 5, -53 },
  { 10326, 38, 38, 48, 5, -38 },
  { 10507, 23, 38, 32, 5, -38 },
  { 10617, 25, 39, 31, 3, -38 },
  { 10739, 24, 55, 32, 5, -38 },
  { 10904, 25, 55, 32, 3, -38 },
  { 11076, 16, 38, 21, 5, -38 },
  { 11152, 19, 39, 24, 2, -38 },
  { 11245, 16, 47, 18, 1, -46 },
  { 11339, 23, 39, 32, 4, -38 },
  { 11452, 26, 38, 26, 0, -38 },
  { 11576, 41, 38, 42, 1, -38 },
  { 11771, 24, 38, 26, 1, -38 },
  { 11885, 26, 55, 26, 0, -38 },
  { 12064, 18, 38, 21, 2, -38 },
  { 12150, 19, 61, 25, 3, -50 },
  { 12295, 5, 70, 28, 12, -53 },
  { 12339, 19, 61, 25, 3, -50 },
  { 12484, 26, 9, 30, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_Regular70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR70PT7B_H_
