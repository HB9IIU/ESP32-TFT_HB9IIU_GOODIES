#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xE7, 0x0F, 0x3F, 0x1C, 0x04, 0xF8, 0x70, 0x03, 0xC1, 0xC0,
  0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F,
  0x87, 0x00, 0x3E, 0x1C, 0x00, 0xFC, 0x70, 0x01, 0xFD, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x77, 0xF0, 0x01, 0xC7, 0xE0, 0x07, 0x0F, 0x80,
  0x1C, 0x3E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xF0, 0x07, 0x07, 0xC0, 0x1C,
  0x1E, 0x00, 0x70, 0x78, 0x01, 0xC3, 0xE8, 0x07, 0x1F, 0xBC, 0x1C, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x03, 0xFF,
  0x00, 0x1E, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x00,
  0xF8, 0x78, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x3C, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x0F, 0x80, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x3C,
  0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x3C, 0x3C, 0x0C, 0x0F, 0x03,
  0xC7, 0x87, 0xF0, 0xF0, 0x3C, 0x78, 0xFF, 0x8F, 0x07, 0x8F, 0x8F, 0xFC,
  0xF8, 0x78, 0xF1, 0xF3, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x7C, 0xF1, 0xF1,
  0xE1, 0xE3, 0xFF, 0x1E, 0x3C, 0x1F, 0x3F, 0xE1, 0xE3, 0xC0, 0xF1, 0xFC,
  0x3E, 0x3C, 0x0F, 0x03, 0x03, 0xC3, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x0F,
  0x00, 0x1E, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0x3C, 0x01,
  0xE1, 0xE0, 0x07, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x01, 0xF3, 0xE0, 0x07,
  0x80, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x7C,
  0x3F, 0x3F, 0x07, 0xC7, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x87, 0xC7, 0xC0,
  0xF8, 0x7C, 0xFC, 0x07, 0xCF, 0x8F, 0x80, 0x7E, 0xF8, 0xF8, 0x03, 0xEF,
  0x8F, 0x80, 0x3F, 0xF0, 0xF8, 0x01, 0xFF, 0x0F, 0x80, 0x1F, 0xF0, 0xF8,
  0x00, 0xFE, 0x0F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0xF0, 0x7E, 0x03, 0xFF, 0x87, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0xCF, 0xC3,
  0xFF, 0xF8, 0x7E, 0x1F, 0xFF, 0x07, 0xE0, 0x7F, 0xC0, 0x3F, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9,
  0xE7, 0x9E, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x01, 0x81, 0xC0, 0xCF, 0x8E, 0x3E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x1F, 0x7C,
  0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x1C,
  0x07, 0x00, 0x20, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0xC7, 0xC3,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC3,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0xFB, 0xF7, 0xEF, 0xFF, 0xBF, 0x3E, 0x10, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x3F, 0x07, 0xE1,
  0xFC, 0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xC7, 0xEF, 0x9F, 0xFF, 0x7F, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFB, 0xC3, 0xF3, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF8, 0x3F, 0xC3, 0x80, 0x3F,
  0x04, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xF8, 0x1F, 0xC3, 0x80, 0x3F, 0x0C, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0xC0, 0x03, 0xFB, 0xE0, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3E, 0x00,
  0x07, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xD8, 0x00, 0xFC, 0xF0, 0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF8, 0x10,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3F, 0xC1, 0xF3, 0xFF,
  0x0F, 0xBF, 0xFC, 0x7D, 0xFF, 0xF3, 0xFE, 0x3F, 0xDF, 0xC0, 0x7E, 0xFE,
  0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0x9F,
  0xC0, 0x7E, 0x1F, 0xC1, 0xF8, 0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F,
  0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xDF,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0x7F, 0x03, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x16,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0x7C,
  0x7E, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0x87, 0xFC, 0x7F,
  0xFD, 0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0x9F, 0x03, 0xF8, 0x7C, 0x01, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x80, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x79, 0xFB, 0xF7, 0xFF, 0xFF, 0xBF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43,
  0xEF, 0xDF, 0xFF, 0xFF, 0xFC, 0xF8, 0x40, 0x1E, 0x1F, 0x8F, 0xC7, 0xF3,
  0xF9, 0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3,
  0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1E, 0x0F, 0xE6, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x0F, 0xE0, 0x7C,
  0x78, 0x07, 0xFF, 0x07, 0x8F, 0x01, 0xFF, 0xE0, 0xF3, 0xE0, 0x7E, 0x7C,
  0x1F, 0x78, 0x1F, 0x07, 0x83, 0xEF, 0x03, 0xE0, 0xF0, 0x3D, 0xE0, 0x78,
  0x3E, 0x07, 0xBC, 0x1F, 0x07, 0xC0, 0xFF, 0x83, 0xC0, 0xF8, 0x1F, 0xE0,
  0x78, 0x1F, 0x03, 0xFC, 0x0F, 0x03, 0xE0, 0x7F, 0x81, 0xE0, 0x7C, 0x0F,
  0xF0, 0x3C, 0x0F, 0x81, 0xFE, 0x07, 0x81, 0xF0, 0x3F, 0xC0, 0xF0, 0x3E,
  0x07, 0xF8, 0x1E, 0x07, 0xC0, 0xFF, 0x03, 0xC0, 0xF8, 0x1F, 0xE0, 0x78,
  0x1E, 0x07, 0xFC, 0x0F, 0x07, 0xC0, 0xF7, 0x81, 0xE0, 0xFC, 0x1E, 0xF8,
  0x3E, 0x1F, 0x87, 0xDF, 0x03, 0xE7, 0x78, 0xF1, 0xE0, 0x7F, 0xEF, 0xFE,
  0x3C, 0x07, 0xF8, 0xFF, 0x87, 0xC0, 0x7F, 0x0F, 0xE0, 0xF8, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x00, 0x0F, 0xE0, 0x03, 0x80,
  0x00, 0xFF, 0x87, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x80,
  0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x00,
  0x7F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F,
  0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xE3,
  0xE0, 0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xF8, 0x07, 0xF1, 0xF0, 0x03, 0xF3, 0xE0,
  0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x7E,
  0x7C, 0x01, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x3C,
  0x0F, 0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x02, 0x07, 0xFC, 0x3C,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x03, 0xF8,
  0xF8, 0x01, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8,
  0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFE, 0x07, 0xF0, 0x01, 0xC0, 0xFE, 0x00, 0x04, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7E, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F,
  0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x0F, 0xF0, 0x01, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF3,
  0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0xF8,
  0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x01, 0xFB, 0xE0,
  0x03, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x78, 0x00, 0x03, 0xFF, 0xF7, 0xC0, 0x00, 0x3D,
  0xFF, 0x7C, 0x00, 0x07, 0xDF, 0xF7, 0xC0, 0x00, 0x7D, 0xFF, 0xBC, 0x00,
  0x07, 0x9F, 0xFB, 0xE0, 0x00, 0x79, 0xFF, 0xBE, 0x00, 0x0F, 0x9F, 0xF9,
  0xE0, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x0F, 0x1F, 0xF9, 0xF0, 0x00, 0xF1,
  0xFF, 0x9F, 0x00, 0x1F, 0x1F, 0xF8, 0xF0, 0x01, 0xE1, 0xFF, 0x8F, 0x80,
  0x1E, 0x1F, 0xF8, 0xF8, 0x03, 0xE1, 0xFF, 0x87, 0x80, 0x3E, 0x1F, 0xF8,
  0x78, 0x03, 0xC1, 0xFF, 0x87, 0xC0, 0x3C, 0x1F, 0xF8, 0x7C, 0x07, 0xC1,
  0xFF, 0x83, 0xC0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0x81, 0xFF, 0x83, 0xE0,
  0xF8, 0x1F, 0xF8, 0x1E, 0x0F, 0x81, 0xFF, 0x81, 0xE0, 0xF0, 0x1F, 0xF8,
  0x1F, 0x0F, 0x01, 0xFF, 0x81, 0xF1, 0xF0, 0x1F, 0xF8, 0x0F, 0x1F, 0x01,
  0xFF, 0x80, 0xF9, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7B,
  0xE0, 0x1F, 0xF8, 0x07, 0xBC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF7, 0xC0, 0x07,
  0xFD, 0xF0, 0x01, 0xFF, 0x7E, 0x00, 0x7F, 0xCF, 0x80, 0x1F, 0xFB, 0xE0,
  0x07, 0xFE, 0x7C, 0x01, 0xFF, 0x9F, 0x00, 0x7F, 0xE3, 0xE0, 0x1F, 0xF8,
  0xF8, 0x07, 0xFE, 0x3E, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F,
  0xF8, 0x3E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0x7C,
  0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x03, 0xE1, 0xFF, 0x80, 0xF8, 0x7F, 0xE0,
  0x1F, 0x1F, 0xF8, 0x07, 0xC7, 0xFE, 0x01, 0xF9, 0xFF, 0x80, 0x3E, 0x7F,
  0xE0, 0x0F, 0x9F, 0xF8, 0x01, 0xF7, 0xFE, 0x00, 0x7D, 0xFF, 0x80, 0x1F,
  0xBF, 0xE0, 0x03, 0xEF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7C, 0x07, 0xF3, 0xE0, 0x1F, 0xDF, 0x00, 0x7E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xE0,
  0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x01, 0xFC, 0x3E, 0x01, 0xFC, 0x7C,
  0x01, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x8F, 0x80, 0x7E, 0x1F, 0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x01,
  0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0x8F, 0xC3, 0xF8, 0x03, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xA0, 0x00, 0xFE, 0xE0, 0x07, 0xF3, 0xF8, 0x7F, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xFC,
  0x00, 0x7E, 0x3E, 0x00, 0x3F, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xEF, 0x00,
  0x1F, 0x0F, 0xC0, 0x0F, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x7B, 0xC0, 0x0F,
  0xC1, 0xF0, 0x03, 0xDF, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xF3, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x9E, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xC7, 0xC0, 0x7E, 0x03, 0xE0,
  0x3E, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0xF0, 0x1F, 0x00, 0xFC, 0x0F,
  0x87, 0x80, 0xF8, 0x03, 0xE0, 0x78, 0x3C, 0x0F, 0xC0, 0x1F, 0x03, 0xC1,
  0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x3C,
  0x1F, 0x00, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x00, 0xF8, 0x78, 0x0F, 0x0F,
  0xC0, 0x07, 0xC3, 0xC0, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x00,
  0x3E, 0x78, 0x03, 0xCF, 0xC0, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x00, 0x0F,
  0x9E, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x03, 0xDF, 0x00, 0x01, 0xEF,
  0x80, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x07,
  0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xFC,
  0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xCF, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x07, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x03, 0xFF, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0E, 0x07, 0xE0, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0x1F, 0x3F, 0x01, 0xF7, 0xE0, 0x1F, 0x7C,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x07, 0xF7, 0xE0, 0xEF,
  0x7F, 0xFE, 0xF3, 0xFF, 0xCF, 0x1F, 0xF8, 0xF0, 0xFF, 0x0F, 0x01, 0x80,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x7C, 0x7F, 0xE0, 0xF9,
  0xFF, 0xE1, 0xF7, 0xFF, 0xE3, 0xFE, 0x1F, 0xC7, 0xF8, 0x0F, 0xCF, 0xE0,
  0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00,
  0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF9, 0xFC,
  0x01, 0xF3, 0xFC, 0x07, 0xE7, 0xFC, 0x1F, 0x8F, 0xBF, 0xFF, 0x1F, 0x7F,
  0xFC, 0x3E, 0x7F, 0xF0, 0x78, 0x3F, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x83, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x61, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x87, 0xC3, 0xFF,
  0x9F, 0x1F, 0xFF, 0x7C, 0xFF, 0xFD, 0xF3, 0xF8, 0x7F, 0xDF, 0x80, 0xFF,
  0x7E, 0x01, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x07,
  0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFC, 0xF0,
  0xFF, 0xE3, 0xC1, 0xFF, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF1,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01,
  0x1F, 0xC0, 0x78, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xE2, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x03, 0xF8, 0x3C, 0x3F, 0xF8, 0xF1, 0xFF, 0xF7,
  0xC7, 0xFF, 0xDF, 0x3F, 0x87, 0xFD, 0xF8, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFC,
  0xFC, 0x1F, 0xF3, 0xFF, 0xF7, 0xC7, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0x1F,
  0xE1, 0xF0, 0x0C, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE4,
  0x00, 0x1F, 0x9C, 0x00, 0xFC, 0x7F, 0x3F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE1, 0xFE, 0x1F, 0x3F,
  0xF8, 0xFB, 0xFF, 0xE7, 0xDF, 0xFF, 0x3F, 0xE1, 0xFD, 0xFE, 0x07, 0xEF,
  0xE0, 0x1F, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0x23, 0xEF, 0xBF, 0xFF, 0xEF, 0x8C, 0x00, 0x00, 0x00, 0x03, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0x80, 0x01, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xDF, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF1, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xE7,
  0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E,
  0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x80, 0x7D, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0x7C, 0x07, 0xF1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x01, 0xFE, 0x1E, 0x3F, 0xF0, 0x7F, 0xE3,
  0xCF, 0xFF, 0x1F, 0xFE, 0x7D, 0xFF, 0xF7, 0xFF, 0xEF, 0xF8, 0x7E, 0xF1,
  0xFD, 0xFC, 0x07, 0xF8, 0x1F, 0xBF, 0x80, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xF0,
  0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F,
  0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80,
  0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07,
  0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0,
  0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0,
  0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03,
  0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0xF0, 0x7F, 0x87, 0x8F,
  0xFE, 0x3C, 0xFF, 0xF9, 0xF7, 0xFF, 0xCF, 0xF8, 0x7F, 0x7F, 0x81, 0xFB,
  0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x87, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xFE, 0x0F,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0xF0, 0x7F, 0x81, 0xE1, 0xFF, 0x83, 0xE7, 0xFF, 0x87,
  0xDF, 0xFF, 0x8F, 0xF8, 0x3F, 0x1F, 0xE0, 0x3F, 0x3F, 0x80, 0x3E, 0x7E,
  0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xF0, 0x07, 0xCF,
  0xF0, 0x1F, 0x9F, 0xF0, 0x7E, 0x3E, 0xFF, 0xFC, 0x7D, 0xFF, 0xF0, 0xF9,
  0xFF, 0xC1, 0xF0, 0xFF, 0x03, 0xE0, 0x70, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x3C, 0x3F, 0xF8, 0xF1, 0xFF, 0xF7, 0xC7, 0xFF, 0xDF, 0x3F,
  0x87, 0xFC, 0xF8, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x00, 0x3F, 0x7C, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7,
  0xC0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFC, 0xFC, 0x1F, 0xF3, 0xFF,
  0xF7, 0xC7, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0x1F, 0xE1, 0xF0, 0x0C, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0xF0, 0x7F, 0xE1, 0xFB, 0xC7, 0xF7, 0x9F, 0xEF, 0xBF,
  0xDF, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFF, 0xE7, 0xE0, 0x77, 0xE0, 0x0B, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC4, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x01, 0xC0,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xF7, 0xC0, 0x7F, 0xBF, 0x07, 0xFD, 0xFF, 0xFB, 0xE7, 0xFF, 0x9F,
  0x1F, 0xFC, 0xF8, 0x7F, 0x87, 0xC0, 0x70, 0x00, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0xC0,
  0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF8, 0x00,
  0xF9, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x7D,
  0xF0, 0x03, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0xC0, 0x1F, 0x3E, 0x01, 0xFE,
  0x01, 0xF1, 0xF0, 0x0F, 0xF0, 0x0F, 0x8F, 0x80, 0x7F, 0x80, 0x7C, 0x7C,
  0x03, 0xFE, 0x03, 0xE1, 0xF0, 0x3E, 0xF0, 0x1F, 0x0F, 0x81, 0xE7, 0x81,
  0xF0, 0x7C, 0x0F, 0x3C, 0x0F, 0x83, 0xE0, 0x79, 0xE0, 0x7C, 0x1F, 0x07,
  0xCF, 0x83, 0xE0, 0x7C, 0x3E, 0x7C, 0x1E, 0x03, 0xE1, 0xE1, 0xE1, 0xF0,
  0x1F, 0x0F, 0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x78, 0x7C, 0x07, 0xC7, 0xC3,
  0xE3, 0xE0, 0x1F, 0x3E, 0x1F, 0x1E, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x07,
  0xCF, 0x03, 0xCF, 0x80, 0x3E, 0x78, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0xF3,
  0xC0, 0x07, 0xBE, 0x07, 0xDE, 0x00, 0x3D, 0xE0, 0x1E, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0xC7, 0xE0,
  0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xC0,
  0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xA0, 0x03, 0xFE, 0x40, 0x00, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 46, 15, 4, -45 },
  { 42, 16, 16, 24, 4, -45 },
  { 74, 27, 45, 29, 1, -45 },
  { 226, 22, 52, 27, 3, -48 },
  { 369, 36, 47, 42, 3, -46 },
  { 581, 28, 47, 30, 2, -46 },
  { 746, 6, 16, 13, 4, -45 },
  { 758, 14, 55, 18, 3, -45 },
  { 855, 13, 55, 18, 2, -45 },
  { 945, 21, 21, 25, 2, -48 },
  { 1001, 23, 30, 27, 2, -37 },
  { 1088, 9, 15, 14, 2, -7 },
  { 1105, 14, 6, 17, 2, -20 },
  { 1116, 7, 9, 14, 4, -8 },
  { 1124, 22, 45, 23, 1, -45 },
  { 1248, 21, 47, 27, 3, -46 },
  { 1372, 15, 45, 27, 4, -45 },
  { 1457, 22, 46, 27, 2, -46 },
  { 1584, 22, 47, 27, 2, -46 },
  { 1714, 25, 45, 27, 1, -45 },
  { 1855, 21, 46, 27, 3, -45 },
  { 1976, 21, 47, 27, 3, -46 },
  { 2100, 23, 45, 27, 2, -45 },
  { 2230, 23, 47, 27, 2, -46 },
  { 2366, 22, 47, 27, 2, -46 },
  { 2496, 7, 35, 14, 4, -34 },
  { 2527, 9, 42, 14, 2, -34 },
  { 2575, 23, 28, 27, 2, -36 },
  { 2656, 23, 18, 27, 2, -31 },
  { 2708, 23, 28, 27, 2, -36 },
  { 2789, 18, 47, 20, 1, -46 },
  { 2895, 35, 50, 41, 3, -45 },
  { 3114, 28, 45, 28, 0, -45 },
  { 3272, 23, 45, 30, 5, -45 },
  { 3402, 24, 47, 28, 3, -46 },
  { 3543, 24, 45, 33, 5, -45 },
  { 3678, 17, 45, 25, 5, -45 },
  { 3774, 17, 45, 24, 5, -45 },
  { 3870, 28, 47, 34, 3, -46 },
  { 4035, 24, 45, 34, 5, -45 },
  { 4170, 14, 45, 18, 2, -45 },
  { 4249, 13, 57, 14, -3, -45 },
  { 4342, 23, 45, 28, 5, -45 },
  { 4472, 17, 45, 23, 5, -45 },
  { 4568, 36, 45, 45, 5, -45 },
  { 4771, 26, 45, 36, 5, -45 },
  { 4918, 29, 47, 35, 3, -46 },
  { 5089, 21, 45, 28, 5, -45 },
  { 5208, 29, 57, 35, 3, -46 },
  { 5415, 23, 45, 29, 5, -45 },
  { 5545, 22, 47, 26, 2, -46 },
  { 5675, 22, 45, 24, 1, -45 },
  { 5799, 25, 46, 33, 4, -45 },
  { 5943, 28, 45, 28, 0, -45 },
  { 6101, 45, 45, 45, 0, -45 },
  { 6355, 25, 45, 25, 0, -45 },
  { 6496, 25, 45, 25, 0, -45 },
  { 6637, 19, 45, 23, 2, -45 },
  { 6744, 13, 55, 20, 5, -45 },
  { 6834, 21, 45, 23, 1, -45 },
  { 6953, 13, 55, 20, 2, -45 },
  { 7043, 26, 24, 28, 1, -45 },
  { 7121, 28, 4, 28, 0, 5 },
  { 7135, 11, 10, 17, 3, -48 },
  { 7149, 20, 35, 26, 2, -34 },
  { 7237, 23, 49, 29, 4, -48 },
  { 7378, 18, 35, 22, 3, -34 },
  { 7457, 22, 49, 29, 3, -48 },
  { 7592, 21, 35, 26, 3, -34 },
  { 7684, 16, 48, 16, 1, -48 },
  { 7780, 22, 49, 29, 3, -34 },
  { 7915, 21, 48, 29, 4, -48 },
  { 8041, 6, 47, 13, 4, -47 },
  { 8077, 11, 62, 13, -1, -47 },
  { 8163, 21, 48, 25, 4, -48 },
  { 8289, 5, 48, 13, 4, -48 },
  { 8319, 35, 34, 43, 4, -34 },
  { 8468, 21, 34, 29, 4, -34 },
  { 8558, 22, 35, 28, 3, -34 },
  { 8655, 23, 49, 29, 4, -34 },
  { 8796, 22, 49, 29, 3, -34 },
  { 8931, 15, 34, 19, 4, -34 },
  { 8995, 17, 35, 21, 2, -34 },
  { 9070, 14, 42, 16, 1, -41 },
  { 9144, 21, 35, 29, 4, -34 },
  { 9236, 23, 34, 23, 0, -34 },
  { 9334, 37, 34, 38, 1, -34 },
  { 9492, 22, 34, 24, 1, -34 },
  { 9586, 23, 49, 23, 0, -34 },
  { 9727, 16, 34, 19, 2, -34 },
  { 9795, 17, 55, 23, 3, -45 },
  { 9912, 5, 63, 26, 10, -48 },
  { 9952, 17, 55, 23, 3, -45 },
  { 10069, 23, 8, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Regular63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR63PT7B_H_
