#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB6, 0xDB, 0x6D, 0x80, 0x1F, 0xF0, 0xCF, 0x9F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x18, 0xC3, 0x18, 0x62, 0x0C, 0x41, 0x88, 0x33,
  0x3F, 0xF8, 0x8C, 0x11, 0x86, 0x30, 0xC6, 0x18, 0x8F, 0xFF, 0xFF, 0xCC,
  0xC1, 0x18, 0x23, 0x0C, 0x61, 0x8C, 0x31, 0x00, 0x0C, 0x03, 0x01, 0xF1,
  0xFF, 0x6C, 0xB3, 0x0C, 0xC3, 0x30, 0xEC, 0x1F, 0x03, 0xE0, 0x3C, 0x0F,
  0x83, 0x30, 0xCC, 0x33, 0x8D, 0xFB, 0xEF, 0xF0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x38, 0x18, 0x36, 0x18, 0x33, 0x0C, 0x18, 0x84, 0x0C, 0x66, 0x06,
  0x33, 0x03, 0x19, 0x01, 0x8D, 0x80, 0xC4, 0xDE, 0x26, 0x4F, 0x9F, 0x6C,
  0xC7, 0x36, 0x60, 0x33, 0x10, 0x19, 0x8C, 0x0C, 0xC4, 0x0C, 0x66, 0x06,
  0x33, 0x03, 0x19, 0x83, 0x07, 0xC1, 0x83, 0xC0, 0x1E, 0x03, 0xF0, 0x73,
  0x07, 0x30, 0x73, 0x07, 0x30, 0x33, 0x03, 0x60, 0x1E, 0x03, 0xC0, 0x7C,
  0x76, 0xE7, 0xE6, 0x6C, 0x36, 0xC3, 0xEC, 0x1C, 0xC1, 0xCE, 0x3E, 0x7F,
  0x63, 0xE7, 0xFF, 0xFC, 0x0C, 0x61, 0x8C, 0x31, 0xC6, 0x18, 0x63, 0x8E,
  0x38, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x0C, 0x30, 0xE1, 0x83, 0xC1, 0x87,
  0x0C, 0x30, 0xE1, 0x86, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0x61,
  0x8E, 0x31, 0xC6, 0x30, 0x1C, 0x06, 0x22, 0x3F, 0xFF, 0xF8, 0xE0, 0xD8,
  0xEE, 0x22, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x77, 0x66, 0x6C, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x00, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0x61, 0xB8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x86,
  0x61, 0x9C, 0xE3, 0xF0, 0x78, 0x0C, 0x73, 0xDB, 0xCD, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x7E, 0x3F, 0xC4, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C,
  0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0F, 0xFF, 0xFF, 0x7E, 0x3F, 0xC4,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x0F, 0x0F, 0x03, 0xF0, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xA0, 0xEF, 0xF3, 0xF8, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xDC, 0x0D, 0xC1, 0x9C, 0x19, 0xC3,
  0x1C, 0x31, 0xC3, 0x1C, 0x61, 0xC6, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x7F, 0x1F, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xA0, 0xEF, 0xF3, 0xF8, 0x0F, 0x87, 0xE3, 0x81, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x98, 0xFF, 0x37, 0xEE, 0x1B, 0x87, 0xE1, 0xF8, 0x3E, 0x0D,
  0x87, 0x61, 0xDC, 0x63, 0xF8, 0x7C, 0xFF, 0xFF, 0xF0, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x3F, 0x1F, 0xE6, 0x1B, 0x87,
  0xE1, 0xD8, 0x76, 0x19, 0xCE, 0x3F, 0x07, 0x83, 0xF1, 0xCE, 0xE1, 0xB0,
  0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x77, 0xF8, 0xFC, 0x3E, 0x1F, 0xC6, 0x3B,
  0x86, 0xE1, 0xB0, 0x6C, 0x1F, 0x07, 0xE1, 0xF8, 0x77, 0x7C, 0xFF, 0x19,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x01, 0xC7, 0xE1, 0xF0, 0xDF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x67, 0x70, 0x00, 0x00, 0x00, 0x00, 0x77, 0x66, 0x6C,
  0xC0, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x1C, 0x1E,
  0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x7E, 0xFF, 0x47, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x38, 0x38,
  0x38, 0x03, 0xE0, 0x0F, 0x78, 0x1C, 0x1C, 0x38, 0x0C, 0x30, 0x06, 0x61,
  0xE6, 0x63, 0xE3, 0x66, 0x63, 0x66, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6,
  0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x66, 0x67, 0xFE, 0x63, 0x9C, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1E, 0x30, 0x0F, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x03, 0x38, 0x18, 0xC0,
  0xC6, 0x0E, 0x30, 0x61, 0xC3, 0xFE, 0x1F, 0xF1, 0xC1, 0x8E, 0x0C, 0x60,
  0x73, 0x01, 0xB8, 0x0D, 0xC0, 0x70, 0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x06, 0xC7, 0xBF, 0x8F, 0xFB, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x7F, 0xFB, 0xFC, 0x0F, 0xE3, 0xF8, 0xE1, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x04, 0x7F, 0x07, 0xE0, 0xFE,
  0x1F, 0xE3, 0x0E, 0x60, 0xEC, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC1, 0xD8, 0x73,
  0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x07, 0xF0, 0xFF, 0xCF, 0x04,
  0x70, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x07, 0xF8,
  0x3F, 0xC1, 0xF6, 0x03, 0xB0, 0x1D, 0x80, 0xEE, 0x07, 0x30, 0x39, 0xC1,
  0xC7, 0xFE, 0x1F, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0xFF, 0xE3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0xBF, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x7F, 0xF0, 0xC0, 0xD8, 0x3B, 0x0E, 0x61, 0x8C, 0x71, 0x8C, 0x33,
  0x86, 0x60, 0xDC, 0x1B, 0x83, 0xF0, 0x77, 0x0C, 0x61, 0x8E, 0x30, 0xC6,
  0x1C, 0xC3, 0x98, 0x33, 0x07, 0x60, 0x70, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xD8,
  0x1B, 0xD8, 0x1B, 0xD8, 0x1B, 0xDC, 0x1B, 0xCC, 0x33, 0xCC, 0x33, 0xCC,
  0x33, 0xC6, 0x73, 0xC6, 0x63, 0xC6, 0x63, 0xC7, 0x63, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC1, 0xC3, 0xC1, 0x83, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xD8, 0x3D, 0x83, 0xDC, 0x3C, 0xC3, 0xCE, 0x3C, 0x63, 0xC6, 0x3C,
  0x73, 0xC3, 0x3C, 0x3B, 0xC1, 0xBC, 0x1B, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0x0F, 0xC0, 0xFF, 0x0E, 0x18, 0xE0, 0xE7, 0x03, 0x30, 0x1D, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x76, 0x03, 0xB0, 0x1D,
  0x80, 0xEE, 0x06, 0x70, 0x71, 0xC7, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x3F,
  0xCC, 0x3B, 0x06, 0xC1, 0xB0, 0x7C, 0x1F, 0x06, 0xC1, 0xB0, 0xEF, 0xF3,
  0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F,
  0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0xE7, 0x03, 0x30, 0x1D, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x76, 0x03, 0xB0, 0x1D, 0x80, 0xEE,
  0x06, 0x70, 0x71, 0xC7, 0x07, 0xF8, 0x1F, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0xFE, 0x1F, 0xE3, 0x0E, 0x60, 0xCC, 0x19, 0x83,
  0xB0, 0x76, 0x0C, 0xC3, 0x98, 0xF3, 0xF8, 0x7F, 0x0C, 0x61, 0x8E, 0x30,
  0xC6, 0x1C, 0xC3, 0x98, 0x33, 0x07, 0x60, 0x70, 0x3F, 0x9F, 0xE7, 0x0B,
  0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x60, 0x1C, 0x06, 0x01, 0xA0, 0xEF, 0xF3, 0xF8, 0xFF, 0xFF, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xCC, 0x39, 0xFF,
  0x1F, 0x80, 0xE0, 0x3E, 0x03, 0x60, 0x76, 0x07, 0x60, 0x67, 0x06, 0x30,
  0xE3, 0x0E, 0x30, 0xC3, 0x8C, 0x19, 0xC1, 0x9C, 0x19, 0x81, 0x98, 0x1D,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0xE0, 0x60, 0x3E, 0x06,
  0x07, 0x60, 0xF0, 0x76, 0x0F, 0x06, 0x60, 0xF0, 0x67, 0x0F, 0x06, 0x70,
  0xF0, 0xE3, 0x19, 0x8E, 0x31, 0x98, 0xC3, 0x19, 0x8C, 0x39, 0x98, 0xC3,
  0x99, 0x9C, 0x1B, 0x0D, 0xC1, 0xB0, 0xD8, 0x1B, 0x0D, 0x81, 0xB0, 0xD8,
  0x0F, 0x0F, 0x80, 0xF0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x60, 0xEE,
  0x18, 0xC7, 0x18, 0xE3, 0x98, 0x37, 0x06, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x81, 0xB0, 0x37, 0x0E, 0x61, 0x8C, 0x31, 0xCE, 0x19, 0x83,
  0x70, 0x70, 0xE0, 0xEC, 0x19, 0x83, 0x38, 0xE3, 0x18, 0x63, 0x0E, 0xE0,
  0xD8, 0x1B, 0x03, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0x7F, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0xE0, 0x60, 0x3F, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18,
  0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0x06, 0x00, 0x70, 0x0F,
  0x00, 0xF8, 0x19, 0x81, 0x98, 0x38, 0xC3, 0x0C, 0x70, 0x66, 0x06, 0xE0,
  0x30, 0xFF, 0xFF, 0xFF, 0xE3, 0x8C, 0x30, 0x3F, 0x3F, 0x80, 0xE0, 0x70,
  0x18, 0x0C, 0x7E, 0xFF, 0xE1, 0xE0, 0xF0, 0x78, 0x7E, 0x3F, 0xED, 0xF6,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xF3, 0xFE, 0xE3, 0xB8,
  0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x3B,
  0xFC, 0xDF, 0x00, 0x1F, 0x3F, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x70, 0x3F, 0x1F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x33, 0xED, 0xFF, 0x71, 0xD8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xD8, 0x76, 0x1D, 0xFF, 0x3E, 0xC0, 0x1E, 0x0F, 0xC6,
  0x19, 0x86, 0xE1, 0xB8, 0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x8F, 0xE1, 0xF8, 0x1F, 0x1E, 0x38, 0x30, 0x30, 0x30, 0x7E, 0xFE,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x3E, 0xDF, 0xF7, 0x1D, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0D, 0x87, 0x61, 0xDF, 0xF3, 0xEC, 0x03, 0x00, 0xC0, 0x30,
  0x1D, 0x8E, 0x7F, 0x07, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x7D, 0xFE, 0xE3, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xBD, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x23,
  0x31, 0x00, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0xEC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0x8E, 0xC6, 0x67,
  0x33, 0x1B, 0x0F, 0x87, 0xE3, 0xB1, 0x9C, 0xC6, 0x63, 0xB0, 0xD8, 0x6C,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDE, 0x3D, 0xFE, 0xFF, 0x8F,
  0x1F, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87,
  0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE1, 0x80,
  0xDF, 0x7F, 0xB8, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0D, 0x87, 0x71, 0x8F, 0xE1, 0xF0,
  0xDF, 0x3F, 0xEE, 0x1B, 0x86, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x86, 0xE3, 0xBF, 0xED, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x3E, 0xDF, 0xF7, 0x1D, 0x87, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0D, 0x87, 0x61, 0xDF, 0xF3, 0xEC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xDF, 0xFF, 0x38, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x7F, 0xFE, 0xC0, 0xC0,
  0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x06, 0x07, 0x07, 0x86, 0xFE, 0xFC, 0x30,
  0x60, 0xC3, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x3E, 0x3C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF8, 0x7E, 0x3F, 0xED, 0xF6, 0xE0, 0xF8, 0x36, 0x1D,
  0x86, 0x61, 0x8C, 0x63, 0x38, 0xCC, 0x33, 0x06, 0xC1, 0xF0, 0x78, 0x1E,
  0x03, 0x80, 0xE0, 0xE1, 0xC3, 0xB0, 0xE1, 0x98, 0x70, 0xCC, 0x68, 0x66,
  0x36, 0x33, 0x9B, 0x30, 0xCD, 0x98, 0x66, 0xCC, 0x36, 0x26, 0x1B, 0x1B,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0x70, 0x70, 0x61,
  0xDC, 0x63, 0x38, 0xCC, 0x1B, 0x07, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0xC3,
  0xB0, 0xCC, 0x31, 0x98, 0x6E, 0x1C, 0xE0, 0xD8, 0x36, 0x1D, 0x86, 0x71,
  0x8C, 0x63, 0x38, 0xCC, 0x3B, 0x06, 0xC1, 0xF0, 0x78, 0x1E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0x82, 0xE0, 0xF0, 0x38, 0x00, 0xFF, 0xFC,
  0x30, 0x61, 0xC3, 0x0E, 0x18, 0x30, 0xE1, 0x87, 0x0C, 0x1F, 0xFF, 0x80,
  0x07, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF0,
  0xE0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1E, 0x0F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0F, 0x07, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x78, 0xF0, 0x80, 0x20, 0x7F, 0x1C,
  0xFE, 0x0E,
};

const GFXglyph NotoSans_ExtraCondensed_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 7, 7, 11, 2, -20 },
  { 16, 11, 20, 13, 1, -20 },
  { 44, 10, 23, 12, 1, -21 },
  { 73, 17, 20, 19, 1, -20 },
  { 116, 12, 20, 13, 1, -20 },
  { 146, 2, 7, 6, 2, -20 },
  { 148, 6, 24, 8, 1, -20 },
  { 166, 6, 24, 8, 1, -20 },
  { 184, 9, 9, 11, 1, -21 },
  { 195, 10, 13, 12, 1, -16 },
  { 212, 4, 7, 6, 1, -3 },
  { 216, 6, 3, 8, 1, -9 },
  { 219, 3, 3, 6, 2, -3 },
  { 221, 9, 20, 10, 1, -20 },
  { 244, 10, 20, 12, 1, -20 },
  { 269, 6, 20, 12, 2, -20 },
  { 284, 10, 20, 12, 1, -20 },
  { 309, 10, 20, 12, 1, -20 },
  { 334, 12, 20, 12, 0, -20 },
  { 364, 10, 20, 12, 1, -20 },
  { 389, 10, 20, 12, 1, -20 },
  { 414, 10, 20, 12, 1, -20 },
  { 439, 10, 20, 12, 1, -20 },
  { 464, 10, 20, 12, 1, -20 },
  { 489, 3, 15, 6, 2, -15 },
  { 495, 4, 19, 6, 1, -15 },
  { 505, 10, 12, 12, 1, -16 },
  { 520, 10, 8, 12, 1, -14 },
  { 530, 10, 12, 12, 1, -16 },
  { 545, 8, 20, 9, 0, -20 },
  { 565, 16, 22, 18, 1, -20 },
  { 609, 13, 20, 13, 0, -20 },
  { 642, 10, 20, 13, 2, -20 },
  { 667, 11, 20, 12, 1, -20 },
  { 695, 11, 20, 14, 2, -20 },
  { 723, 8, 20, 11, 2, -20 },
  { 743, 8, 20, 11, 2, -20 },
  { 763, 13, 20, 15, 1, -20 },
  { 796, 11, 20, 15, 2, -20 },
  { 824, 6, 20, 8, 1, -20 },
  { 839, 5, 25, 6, -1, -20 },
  { 855, 11, 20, 13, 2, -20 },
  { 883, 8, 20, 10, 2, -20 },
  { 903, 16, 20, 20, 2, -20 },
  { 943, 12, 20, 16, 2, -20 },
  { 973, 13, 20, 15, 1, -20 },
  { 1006, 10, 20, 12, 2, -20 },
  { 1031, 13, 25, 15, 1, -20 },
  { 1072, 11, 20, 13, 2, -20 },
  { 1100, 10, 20, 12, 1, -20 },
  { 1125, 10, 20, 11, 0, -20 },
  { 1150, 11, 20, 15, 2, -20 },
  { 1178, 12, 20, 12, 0, -20 },
  { 1208, 20, 20, 20, 0, -20 },
  { 1258, 11, 20, 11, 0, -20 },
  { 1286, 11, 20, 11, 0, -20 },
  { 1314, 9, 20, 10, 1, -20 },
  { 1337, 6, 25, 9, 2, -20 },
  { 1356, 10, 20, 10, 0, -20 },
  { 1381, 6, 25, 9, 1, -20 },
  { 1400, 12, 11, 12, 0, -20 },
  { 1417, 12, 2, 12, 0, 2 },
  { 1420, 5, 4, 7, 1, -21 },
  { 1423, 9, 15, 12, 1, -15 },
  { 1440, 10, 21, 13, 2, -21 },
  { 1467, 8, 15, 10, 1, -15 },
  { 1482, 10, 21, 13, 1, -21 },
  { 1509, 10, 15, 12, 1, -15 },
  { 1528, 8, 21, 7, 0, -21 },
  { 1549, 10, 22, 13, 1, -15 },
  { 1577, 9, 21, 13, 2, -21 },
  { 1601, 2, 21, 6, 2, -21 },
  { 1607, 4, 28, 6, 0, -21 },
  { 1621, 9, 21, 11, 2, -21 },
  { 1645, 2, 21, 6, 2, -21 },
  { 1651, 15, 15, 19, 2, -15 },
  { 1680, 9, 15, 13, 2, -15 },
  { 1697, 10, 15, 12, 1, -15 },
  { 1716, 10, 22, 13, 2, -15 },
  { 1744, 10, 22, 13, 1, -15 },
  { 1772, 6, 15, 9, 2, -15 },
  { 1784, 8, 15, 9, 1, -15 },
  { 1799, 7, 18, 7, 0, -18 },
  { 1815, 9, 15, 13, 2, -15 },
  { 1832, 10, 15, 10, 0, -15 },
  { 1851, 17, 15, 17, 0, -15 },
  { 1883, 10, 15, 10, 0, -15 },
  { 1902, 10, 22, 10, 0, -15 },
  { 1930, 7, 15, 8, 1, -15 },
  { 1944, 8, 25, 10, 1, -20 },
  { 1969, 2, 28, 11, 5, -21 },
  { 1976, 8, 25, 10, 1, -20 },
  { 2001, 10, 4, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Regular28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR28PT7B_H_
