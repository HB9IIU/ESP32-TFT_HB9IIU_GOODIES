#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x66, 0xF6, 0xEA, 0x7B, 0x17, 0x80, 0x56, 0xBA, 0xF3,
  0xAC, 0x4A, 0x4D, 0xAF, 0xC0, 0x5A, 0xA4, 0x95, 0x58, 0x5D, 0x80, 0x4B,
  0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x25, 0x00, 0x56, 0xDA, 0xC0, 0x75, 0x50,
  0xC4, 0xA5, 0xC0, 0xE4, 0xB3, 0xC0, 0x2D, 0xDE, 0x40, 0x73, 0x13, 0xC0,
  0x73, 0x5A, 0xC0, 0xE4, 0xA4, 0x80, 0x75, 0xBA, 0xC0, 0x56, 0xB2, 0x80,
  0x90, 0x98, 0x2B, 0x10, 0xFC, 0x89, 0xC0, 0xD5, 0x10, 0x32, 0x6F, 0xBB,
  0xA0, 0xC0, 0x44, 0x6E, 0xA9, 0xD7, 0x6B, 0x80, 0x6A, 0x48, 0xC0, 0xD6,
  0xDB, 0x80, 0xEB, 0xB0, 0xEB, 0xA0, 0x74, 0x8B, 0x97, 0xB6, 0xFB, 0x40,
  0xD5, 0x70, 0xFF, 0xBA, 0x4D, 0xC0, 0xAA, 0xB0, 0x99, 0xBB, 0xFD, 0xB6,
  0xFB, 0x40, 0x69, 0x99, 0x96, 0xFF, 0xA0, 0x69, 0x99, 0x96, 0x30, 0xDB,
  0x4D, 0xC0, 0x73, 0x13, 0xC0, 0xE9, 0x24, 0x80, 0xB6, 0xDB, 0x80, 0x9A,
  0xA6, 0x64, 0xA6, 0x9B, 0x96, 0x59, 0x20, 0xB5, 0x2B, 0x40, 0xB5, 0x24,
  0x80, 0xE5, 0x29, 0xC0, 0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x4E, 0x80,
  0xF0, 0xC0, 0x6E, 0xF0, 0xAF, 0xF0, 0xF2, 0x30, 0x2E, 0xDA, 0xC0, 0xFE,
  0x30, 0x7A, 0xA0, 0xF6, 0xB2, 0xC0, 0xAF, 0xF0, 0xBC, 0xBF, 0xAE, 0xF0,
  0xFC, 0xFD, 0xDD, 0xFF, 0xF6, 0xB0, 0xFF, 0xA0, 0xF6, 0xB2, 0x40, 0xF0,
  0xE7, 0xEA, 0x40, 0xB6, 0xB0, 0xB5, 0x20, 0xAF, 0x74, 0xA0, 0xA9, 0x50,
  0xB5, 0x25, 0x00, 0xDB, 0x29, 0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 3, 2, 3, 0, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 6, 3, 0, -6 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 2, 0, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 3, 3, 3, 0, -6 },
  { 23, 3, 4, 3, 0, -5 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 6, 3, 0, -6 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 2, 6, 3, 0, -6 },
  { 36, 3, 6, 3, 0, -6 },
  { 39, 3, 6, 3, 0, -6 },
  { 42, 3, 6, 3, 0, -6 },
  { 45, 3, 6, 3, 0, -6 },
  { 48, 3, 6, 3, 0, -6 },
  { 51, 3, 6, 3, 0, -6 },
  { 54, 3, 6, 3, 0, -6 },
  { 57, 3, 6, 3, 0, -6 },
  { 60, 1, 4, 2, 0, -4 },
  { 61, 1, 5, 2, 0, -4 },
  { 62, 3, 4, 3, 0, -5 },
  { 64, 3, 2, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -5 },
  { 67, 2, 6, 3, 0, -6 },
  { 69, 5, 7, 5, 0, -6 },
  { 74, 4, 6, 4, 0, -6 },
  { 77, 3, 6, 4, 1, -6 },
  { 80, 3, 6, 4, 0, -6 },
  { 83, 3, 6, 4, 1, -6 },
  { 86, 2, 6, 3, 1, -6 },
  { 88, 2, 6, 3, 1, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 3, 6, 4, 1, -6 },
  { 96, 2, 6, 2, 0, -6 },
  { 98, 1, 8, 2, 0, -6 },
  { 99, 3, 6, 4, 1, -6 },
  { 102, 2, 6, 3, 1, -6 },
  { 104, 4, 6, 6, 1, -6 },
  { 107, 3, 6, 5, 1, -6 },
  { 110, 4, 6, 4, 0, -6 },
  { 113, 2, 6, 4, 1, -6 },
  { 115, 4, 7, 4, 0, -6 },
  { 119, 3, 6, 4, 1, -6 },
  { 122, 3, 6, 3, 0, -6 },
  { 125, 3, 6, 3, 0, -6 },
  { 128, 3, 6, 4, 1, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 6, 6, 6, 0, -6 },
  { 139, 3, 6, 3, 0, -6 },
  { 142, 3, 6, 3, 0, -6 },
  { 145, 3, 6, 3, 0, -6 },
  { 148, 1, 7, 3, 1, -6 },
  { 149, 3, 6, 3, 0, -6 },
  { 152, 2, 7, 3, 0, -6 },
  { 154, 3, 3, 4, 0, -6 },
  { 156, 4, 1, 4, 0, 0 },
  { 157, 2, 1, 2, 0, -6 },
  { 158, 3, 4, 3, 0, -4 },
  { 160, 2, 6, 4, 1, -6 },
  { 162, 3, 4, 3, 0, -4 },
  { 164, 3, 6, 4, 0, -6 },
  { 167, 3, 4, 3, 0, -4 },
  { 169, 2, 6, 2, 0, -6 },
  { 171, 3, 6, 4, 0, -4 },
  { 174, 2, 6, 4, 1, -6 },
  { 176, 1, 6, 2, 0, -6 },
  { 177, 1, 8, 2, 0, -6 },
  { 178, 2, 6, 3, 1, -6 },
  { 180, 1, 6, 2, 0, -6 },
  { 181, 4, 4, 5, 1, -4 },
  { 183, 2, 4, 4, 1, -4 },
  { 184, 3, 4, 4, 0, -4 },
  { 186, 2, 6, 4, 1, -4 },
  { 188, 3, 6, 4, 0, -4 },
  { 191, 1, 4, 2, 1, -4 },
  { 192, 2, 4, 3, 0, -4 },
  { 193, 2, 5, 2, 0, -5 },
  { 195, 3, 4, 4, 0, -4 },
  { 197, 3, 4, 3, 0, -4 },
  { 199, 5, 4, 5, 0, -4 },
  { 202, 3, 4, 3, 0, -4 },
  { 204, 3, 6, 3, 0, -4 },
  { 207, 2, 4, 2, 0, -4 },
  { 208, 3, 7, 3, 0, -6 },
  { 211, 1, 8, 3, 1, -6 },
  { 212, 3, 7, 3, 0, -6 },
  { 215, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Regular8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR8PT7B_H_
