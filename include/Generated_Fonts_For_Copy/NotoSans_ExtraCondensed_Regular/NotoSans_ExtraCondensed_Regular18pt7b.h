#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x43, 0xC0, 0xDE, 0xF7, 0xB9, 0x80, 0x12, 0x12, 0x12,
  0x16, 0x7F, 0x24, 0x24, 0x24, 0xFF, 0x24, 0x24, 0x2C, 0x68, 0x20, 0x87,
  0xF9, 0xA2, 0x8E, 0x1C, 0x2C, 0x92, 0x6B, 0xF8, 0x82, 0x00, 0x63, 0x2C,
  0x89, 0x22, 0x58, 0x94, 0x25, 0x6B, 0xF5, 0xA9, 0x0A, 0x46, 0x91, 0x24,
  0x4D, 0x21, 0x80, 0x70, 0x58, 0xC8, 0x58, 0x58, 0x70, 0x60, 0xD2, 0x9E,
  0x8E, 0x8C, 0xDE, 0xF3, 0xFF, 0x80, 0x36, 0x44, 0xCC, 0x88, 0x88, 0xCC,
  0x44, 0x23, 0x99, 0x36, 0x49, 0x24, 0xB6, 0xB4, 0x20, 0x8E, 0x9D, 0x53,
  0x60, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0xFA, 0xFF, 0xF0, 0x04,
  0x10, 0xC2, 0x18, 0x41, 0x0C, 0x20, 0x86, 0x10, 0xC0, 0x71, 0x6C, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF2, 0x78, 0x13, 0x59, 0x11, 0x11, 0x11,
  0x11, 0x10, 0x72, 0x60, 0xC3, 0x0C, 0x21, 0x84, 0x31, 0x84, 0x20, 0xFC,
  0x72, 0x60, 0xC3, 0x08, 0x67, 0x06, 0x0C, 0x30, 0xE6, 0xF8, 0x0C, 0x18,
  0x50, 0xA3, 0x44, 0x99, 0x22, 0x45, 0xFC, 0x10, 0x20, 0x40, 0xFB, 0xEC,
  0x20, 0x83, 0xC9, 0x83, 0x0C, 0x30, 0xE6, 0xF0, 0x39, 0x94, 0x30, 0x82,
  0xEC, 0xE3, 0x8E, 0x3C, 0xF2, 0x78, 0xFF, 0xF0, 0xC2, 0x08, 0x61, 0x04,
  0x30, 0x82, 0x18, 0x40, 0x7B, 0x38, 0xE3, 0xCD, 0xE7, 0x36, 0x8E, 0x18,
  0x73, 0x78, 0x73, 0x68, 0xE3, 0x8E, 0x3C, 0xDF, 0x0C, 0x20, 0x86, 0xF0,
  0xF4, 0x00, 0xF0, 0xF4, 0x00, 0xFA, 0x04, 0x66, 0x20, 0xE0, 0xE0, 0xC1,
  0xFC, 0x00, 0x00, 0xFC, 0x81, 0x83, 0x83, 0x19, 0x8C, 0x20, 0xF2, 0xC2,
  0x10, 0x8C, 0xC4, 0x20, 0x00, 0xC6, 0x00, 0x1E, 0x0C, 0x44, 0x09, 0x02,
  0x9E, 0x64, 0x99, 0x26, 0x49, 0x96, 0x65, 0xA9, 0xDB, 0x00, 0x40, 0x0F,
  0x80, 0x80, 0x18, 0x18, 0x1C, 0x3C, 0x24, 0x24, 0x24, 0x66, 0x7E, 0x42,
  0x42, 0xC3, 0xC3, 0xF9, 0x9B, 0x1E, 0x3C, 0x59, 0xBE, 0x63, 0xC7, 0x8F,
  0x1E, 0x6F, 0x80, 0x3E, 0xC9, 0x06, 0x0C, 0x18, 0x20, 0x40, 0xC1, 0x81,
  0x03, 0x13, 0xC0, 0xF9, 0xFB, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x8F,
  0x1E, 0x6F, 0x80, 0xFF, 0xF1, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0x8F, 0x80,
  0xFF, 0xF1, 0x8C, 0x63, 0xFF, 0xC6, 0x31, 0x8C, 0x00, 0x1F, 0x72, 0x40,
  0xC0, 0xC0, 0xC0, 0x87, 0xC7, 0xC3, 0xC3, 0x43, 0x63, 0x3F, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x7F, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x20, 0xE9, 0x24,
  0x92, 0x49, 0x2E, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC7,
  0x8B, 0x36, 0xCD, 0x9E, 0x3C, 0x6C, 0xD9, 0x93, 0x36, 0x2C, 0x60, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0x80, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0x1F, 0xA2, 0xF4, 0x5E, 0xDB, 0xCA, 0x79, 0x4F, 0x29, 0xE7,
  0x3C, 0x46, 0xC3, 0xE3, 0xE3, 0xF3, 0xD3, 0xD3, 0xDB, 0xCB, 0xCD, 0xC5,
  0xC7, 0xC7, 0xC3, 0x3C, 0x66, 0xC2, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0xC3,
  0xC3, 0xC2, 0x66, 0x3C, 0xFB, 0x7C, 0x71, 0xC7, 0x1C, 0xFE, 0xC3, 0x0C,
  0x30, 0xC0, 0x3C, 0x66, 0xC2, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0xC3, 0xC3,
  0xC2, 0x66, 0x3C, 0x0C, 0x06, 0x03, 0xF9, 0xFB, 0x16, 0x2C, 0x58, 0xBF,
  0x7C, 0xD9, 0x93, 0x36, 0x2C, 0x60, 0x7F, 0x28, 0x20, 0xC3, 0x87, 0x06,
  0x0C, 0x30, 0xE6, 0xF0, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x00, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x1B, 0x37, 0xC0, 0xC3, 0xC3, 0x42, 0x42, 0x66, 0x66, 0x24, 0x24,
  0x2C, 0x3C, 0x38, 0x18, 0x18, 0xC2, 0x1E, 0x10, 0xD1, 0x44, 0x8A, 0x24,
  0x53, 0x32, 0x99, 0xB4, 0xC5, 0xB4, 0x28, 0xA1, 0x45, 0x0E, 0x38, 0x71,
  0xC1, 0x8C, 0x00, 0xC6, 0x89, 0x91, 0x63, 0x83, 0x06, 0x1C, 0x28, 0x59,
  0x92, 0x3C, 0x60, 0xC7, 0x8D, 0x13, 0x62, 0xC5, 0x0E, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x00, 0x7D, 0xF0, 0xC2, 0x18, 0x43, 0x0C, 0x21, 0x84, 0x10,
  0xFC, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xC1, 0x06, 0x08,
  0x20, 0xC1, 0x04, 0x18, 0x20, 0x83, 0x04, 0xE4, 0x92, 0x49, 0x24, 0x92,
  0x4F, 0x18, 0x18, 0x3C, 0x24, 0x64, 0x42, 0xC3, 0xFF, 0xFF, 0xC9, 0x80,
  0x76, 0xC2, 0x17, 0xE6, 0x31, 0x9F, 0x40, 0xC1, 0x83, 0x06, 0x0D, 0x9D,
  0xB1, 0x62, 0xC7, 0x8F, 0x1E, 0x2C, 0xD7, 0x00, 0x3B, 0x71, 0x08, 0x42,
  0x18, 0xCB, 0xC0, 0x04, 0x10, 0x41, 0x77, 0xFC, 0xE1, 0x86, 0x18, 0x63,
  0xCD, 0xD0, 0x31, 0x6C, 0xE3, 0xFE, 0x08, 0x30, 0xC5, 0xE0, 0x39, 0xD8,
  0xC7, 0x79, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x77, 0xFC, 0xE1, 0x86, 0x18,
  0x63, 0xCD, 0xD0, 0x41, 0x8F, 0xE0, 0xC3, 0x0C, 0x30, 0xDB, 0xBC, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x10, 0xF3, 0xFF, 0xFF, 0xC0, 0x6C, 0x36, 0xDB,
  0x6D, 0xB6, 0xDB, 0xC0, 0xC3, 0x0C, 0x30, 0xCF, 0x2D, 0xBC, 0xF3, 0x4D,
  0xB2, 0xCB, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0xB9, 0xAB, 0xBC, 0xC7, 0x31,
  0xCC, 0x73, 0x1C, 0xC7, 0x31, 0xCC, 0x73, 0x10, 0x9A, 0xBC, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x10, 0x31, 0xEC, 0xE1, 0x86, 0x18, 0x71, 0xCD, 0xE0,
  0x99, 0xDB, 0x16, 0x2C, 0x78, 0xF1, 0xE2, 0xCD, 0xF3, 0x06, 0x0C, 0x18,
  0x00, 0x77, 0xFC, 0xE1, 0x86, 0x18, 0x63, 0xCD, 0xD0, 0x41, 0x04, 0x10,
  0x9B, 0xCC, 0xCC, 0xCC, 0xCC, 0x7E, 0xA1, 0x0E, 0x38, 0x43, 0x97, 0x80,
  0x26, 0x7F, 0x66, 0x66, 0x66, 0x63, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73,
  0xCD, 0xD0, 0xC7, 0x89, 0x12, 0x66, 0xCD, 0x0A, 0x1C, 0x38, 0x60, 0xC4,
  0x79, 0xC9, 0x29, 0x25, 0x24, 0xAC, 0xD5, 0x9E, 0xA1, 0x9C, 0x31, 0x86,
  0x30, 0xC5, 0x36, 0x8A, 0x38, 0xC3, 0x9A, 0x4F, 0x10, 0xC7, 0x89, 0x12,
  0x66, 0xCD, 0x0A, 0x1C, 0x38, 0x20, 0xC1, 0x82, 0x1C, 0x00, 0x7B, 0xC6,
  0x23, 0x11, 0x8C, 0x47, 0xC0, 0x19, 0x88, 0x42, 0x11, 0x98, 0xC3, 0x08,
  0x42, 0x10, 0xC3, 0xFF, 0xFF, 0xC0, 0xC3, 0x18, 0x42, 0x10, 0x87, 0x39,
  0x08, 0x42, 0x31, 0x98, 0x07, 0xD9, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 5, 5, 7, 1, -13 },
  { 9, 8, 13, 8, 0, -13 },
  { 22, 6, 15, 8, 1, -14 },
  { 34, 10, 13, 12, 1, -13 },
  { 51, 8, 13, 9, 1, -13 },
  { 64, 2, 5, 4, 1, -13 },
  { 66, 4, 16, 5, 1, -13 },
  { 74, 3, 16, 5, 1, -13 },
  { 80, 6, 6, 7, 1, -14 },
  { 85, 6, 9, 8, 1, -11 },
  { 92, 2, 4, 4, 1, -2 },
  { 93, 4, 2, 5, 0, -6 },
  { 94, 2, 2, 4, 1, -2 },
  { 95, 6, 13, 7, 0, -13 },
  { 105, 6, 13, 8, 1, -13 },
  { 115, 4, 13, 8, 1, -13 },
  { 122, 6, 13, 8, 1, -13 },
  { 132, 6, 13, 8, 1, -13 },
  { 142, 7, 13, 8, 0, -13 },
  { 154, 6, 13, 8, 1, -13 },
  { 164, 6, 13, 8, 1, -13 },
  { 174, 6, 13, 8, 1, -13 },
  { 184, 6, 13, 8, 1, -13 },
  { 194, 6, 13, 8, 1, -13 },
  { 204, 2, 10, 4, 1, -10 },
  { 207, 2, 12, 4, 1, -10 },
  { 210, 6, 8, 8, 1, -10 },
  { 216, 6, 5, 8, 1, -9 },
  { 220, 6, 8, 8, 1, -10 },
  { 226, 5, 13, 6, 0, -13 },
  { 235, 10, 15, 12, 1, -13 },
  { 254, 8, 13, 8, 0, -13 },
  { 267, 7, 13, 9, 1, -13 },
  { 279, 7, 13, 8, 1, -13 },
  { 291, 7, 13, 9, 1, -13 },
  { 303, 5, 13, 7, 1, -13 },
  { 312, 5, 13, 7, 1, -13 },
  { 321, 8, 13, 10, 1, -13 },
  { 334, 7, 13, 10, 1, -13 },
  { 346, 3, 13, 5, 1, -13 },
  { 351, 4, 16, 4, -1, -13 },
  { 359, 7, 13, 8, 1, -13 },
  { 371, 5, 13, 7, 1, -13 },
  { 380, 11, 13, 13, 1, -13 },
  { 398, 8, 13, 10, 1, -13 },
  { 411, 8, 13, 10, 1, -13 },
  { 424, 6, 13, 8, 1, -13 },
  { 434, 8, 16, 10, 1, -13 },
  { 450, 7, 13, 8, 1, -13 },
  { 462, 6, 13, 7, 1, -13 },
  { 472, 7, 13, 7, 0, -13 },
  { 484, 7, 13, 9, 1, -13 },
  { 496, 8, 13, 8, 0, -13 },
  { 509, 13, 13, 13, 0, -13 },
  { 531, 7, 13, 7, 0, -13 },
  { 543, 7, 13, 7, 0, -13 },
  { 555, 6, 13, 7, 0, -13 },
  { 565, 4, 16, 6, 1, -13 },
  { 573, 6, 13, 7, 0, -13 },
  { 583, 3, 16, 6, 1, -13 },
  { 589, 8, 7, 8, 0, -13 },
  { 596, 8, 2, 8, 0, 1 },
  { 598, 3, 3, 5, 1, -14 },
  { 600, 5, 10, 7, 1, -10 },
  { 607, 7, 14, 8, 1, -14 },
  { 620, 5, 10, 6, 1, -10 },
  { 627, 6, 14, 8, 1, -14 },
  { 638, 6, 10, 8, 1, -10 },
  { 646, 5, 14, 5, 0, -14 },
  { 655, 6, 14, 8, 1, -10 },
  { 666, 6, 14, 8, 1, -14 },
  { 677, 2, 13, 4, 1, -13 },
  { 681, 3, 17, 4, 0, -13 },
  { 688, 6, 14, 7, 1, -14 },
  { 699, 2, 14, 4, 1, -14 },
  { 703, 10, 10, 12, 1, -10 },
  { 716, 6, 10, 8, 1, -10 },
  { 724, 6, 10, 8, 1, -10 },
  { 732, 7, 14, 8, 1, -10 },
  { 745, 6, 14, 8, 1, -10 },
  { 756, 4, 10, 5, 1, -10 },
  { 761, 5, 10, 6, 1, -10 },
  { 768, 4, 12, 5, 0, -12 },
  { 774, 6, 10, 8, 1, -10 },
  { 782, 7, 10, 7, 0, -10 },
  { 791, 11, 10, 11, 0, -10 },
  { 805, 6, 10, 7, 0, -10 },
  { 813, 7, 14, 7, 0, -10 },
  { 826, 5, 10, 5, 0, -10 },
  { 833, 5, 16, 7, 1, -13 },
  { 843, 1, 18, 7, 3, -14 },
  { 846, 5, 16, 7, 1, -13 },
  { 856, 6, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Regular18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR18PT7B_H_
