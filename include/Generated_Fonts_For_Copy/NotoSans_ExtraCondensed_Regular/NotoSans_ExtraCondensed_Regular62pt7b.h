#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0x7F,
  0xFF, 0xFF, 0xF3, 0xE3, 0x00, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0xC0, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFE, 0xEF, 0xE3, 0xE3, 0x83, 0x1F, 0x0E, 0x00, 0x78, 0x38, 0x01,
  0xE0, 0xE0, 0x0F, 0x83, 0x80, 0x3E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0,
  0xE0, 0x07, 0xC3, 0x80, 0x1F, 0x8E, 0x00, 0x3F, 0x38, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x39, 0xF8, 0x00, 0xE3, 0xF0, 0x03,
  0x87, 0xC0, 0x0E, 0x1F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x83,
  0xC0, 0x0E, 0x1F, 0x00, 0x38, 0x7D, 0x00, 0xE3, 0xE7, 0x03, 0x9F, 0x9F,
  0xEF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x7F,
  0xF0, 0x03, 0xC0, 0x03, 0xC7, 0x80, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0xF0,
  0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x78, 0x3E,
  0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x3C, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x07,
  0x80, 0x03, 0xE0, 0x78, 0x7C, 0x00, 0x1F, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xF1, 0xE0, 0x00, 0x1E, 0x0F, 0x8F, 0x07,
  0xC0, 0xF0, 0x78, 0x78, 0xFF, 0x87, 0x83, 0xC7, 0x87, 0xFC, 0x3C, 0x1E,
  0x3C, 0x7F, 0xF0, 0xF0, 0xF1, 0xE3, 0xC7, 0x87, 0x8F, 0x1E, 0x3C, 0x1E,
  0x3F, 0xF8, 0xF1, 0xE0, 0xF0, 0xFF, 0x87, 0x8F, 0x07, 0x83, 0xF8, 0x78,
  0x78, 0x3C, 0x07, 0x83, 0xC7, 0xC1, 0xF0, 0x00, 0x3E, 0x3E, 0x0F, 0x80,
  0x01, 0xE1, 0xE0, 0x7C, 0x00, 0x0F, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x78,
  0x1F, 0x00, 0x07, 0x83, 0xC0, 0xF8, 0x00, 0x3C, 0x1E, 0x07, 0xC0, 0x03,
  0xE0, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x1E, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x03, 0xC0,
  0x3C, 0x1E, 0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE0, 0x07, 0xDF, 0x00,
  0x0F, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x07, 0xC3, 0xF3, 0xE0,
  0x7C, 0x3E, 0x3F, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x7C, 0x0F, 0x8F, 0x8F,
  0xC0, 0xFC, 0xF8, 0xF8, 0x07, 0xCF, 0x8F, 0x80, 0x7F, 0xF0, 0xF8, 0x03,
  0xFF, 0x0F, 0x80, 0x1F, 0xF0, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0x0F, 0xE0,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x07, 0xE0,
  0x3F, 0xF0, 0x7F, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0xF8, 0x3F, 0xFF, 0x8F,
  0xC1, 0xFF, 0xF0, 0x7E, 0x0F, 0xFC, 0x07, 0xF0, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xEE, 0x00, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x70, 0xF0, 0x77, 0xE7, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x07, 0xDF, 0x00, 0xF8,
  0xF0, 0x1F, 0x8F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x60, 0x30, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F,
  0x87, 0x83, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0xC8, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0xFC,
  0x3F, 0x8F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07,
  0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xDF, 0x7E, 0x7F, 0xF1, 0xF7, 0x87, 0xCC,
  0x1F, 0x20, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF0,
  0x1F, 0xC3, 0x80, 0x3F, 0x04, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC3, 0x00, 0x3F, 0x08, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xB0, 0x00, 0xFC, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0B, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x78,
  0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1C, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF3, 0x00, 0x3F, 0x9E,
  0x03, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC3, 0xF0, 0x3E, 0x7F, 0xE1, 0xF7, 0xFF, 0x8F, 0xBF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F,
  0xBE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xE0,
  0x7C, 0x3F, 0x87, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x07, 0xE0, 0x7F, 0x0F,
  0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x3F,
  0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x3F, 0x00,
  0x7C, 0x3F, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x3F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF,
  0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xF3, 0xE0, 0x3F, 0xCF, 0xC1,
  0xFF, 0x3F, 0xFF, 0x78, 0x7F, 0xF9, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0x3E,
  0x00, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x20, 0x3F, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0x84, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x40, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1,
  0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xE0,
  0xF0, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3,
  0x81, 0xFD, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x02, 0x00, 0x78,
  0x78, 0x07, 0xFF, 0x0F, 0x0F, 0x01, 0xFF, 0xE1, 0xF3, 0xE0, 0x7F, 0xFC,
  0x1E, 0x78, 0x0F, 0x0F, 0x83, 0xCF, 0x03, 0xE1, 0xF0, 0x79, 0xE0, 0x78,
  0x3C, 0x0F, 0x3C, 0x1F, 0x07, 0x81, 0xEF, 0x83, 0xC0, 0xF0, 0x3F, 0xE0,
  0x78, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x78, 0x1F,
  0xF0, 0x7C, 0x0F, 0x03, 0xFE, 0x0F, 0x81, 0xE0, 0x7B, 0xC1, 0xF0, 0x3C,
  0x0F, 0x78, 0x3E, 0x07, 0x81, 0xEF, 0x07, 0xC1, 0xF0, 0x3D, 0xE0, 0x78,
  0x3E, 0x07, 0xBC, 0x0F, 0x07, 0xC0, 0xF7, 0x81, 0xE0, 0xF8, 0x3C, 0xF0,
  0x3C, 0x1B, 0x07, 0x9F, 0x07, 0xC7, 0x71, 0xF1, 0xE0, 0x7F, 0xEF, 0xFC,
  0x3C, 0x0F, 0xF9, 0xFF, 0x87, 0x80, 0xFE, 0x1F, 0xE0, 0xF8, 0x07, 0x81,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x0F, 0xE0, 0x03, 0x00,
  0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xF8, 0x1F, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE,
  0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x81, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3E, 0x03, 0xFC, 0xF8, 0x03,
  0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xEF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFE, 0x03, 0x83, 0xF0,
  0x01, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x02,
  0x07, 0xF8, 0x1C, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0xF0, 0xF8, 0x07, 0xF0,
  0xF8, 0x03, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0,
  0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0x83, 0xF8,
  0x00, 0x20, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x9F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F,
  0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0,
  0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0,
  0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF8, 0xF8, 0x03,
  0xE1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0,
  0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x03,
  0xF7, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xBC, 0x00, 0x03,
  0xFF, 0xF7, 0x80, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0x0F, 0x7F, 0xDF, 0x00,
  0x01, 0xEF, 0xF9, 0xE0, 0x00, 0x7D, 0xFF, 0x3E, 0x00, 0x0F, 0xBF, 0xE7,
  0xC0, 0x01, 0xE7, 0xFC, 0x78, 0x00, 0x7C, 0xFF, 0x8F, 0x00, 0x0F, 0x9F,
  0xF1, 0xF0, 0x01, 0xE3, 0xFE, 0x3E, 0x00, 0x3C, 0x7F, 0xC3, 0xC0, 0x0F,
  0x8F, 0xF8, 0x7C, 0x01, 0xF1, 0xFF, 0x0F, 0x80, 0x3C, 0x3F, 0xE0, 0xF0,
  0x0F, 0x87, 0xFC, 0x1E, 0x01, 0xF0, 0xFF, 0x83, 0xE0, 0x3C, 0x1F, 0xF0,
  0x7C, 0x07, 0x83, 0xFE, 0x07, 0x81, 0xF0, 0x7F, 0xC0, 0xF8, 0x3E, 0x0F,
  0xF8, 0x1F, 0x07, 0x81, 0xFF, 0x01, 0xE1, 0xF0, 0x3F, 0xE0, 0x3C, 0x3E,
  0x07, 0xFC, 0x07, 0xC7, 0x80, 0xFF, 0x80, 0xF8, 0xF0, 0x1F, 0xF0, 0x0F,
  0x3E, 0x03, 0xFE, 0x01, 0xF7, 0xC0, 0x7F, 0xC0, 0x3E, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF7, 0xC0, 0x07, 0xFD, 0xF0, 0x01, 0xFF,
  0x7C, 0x00, 0x7F, 0xCF, 0x80, 0x1F, 0xF3, 0xE0, 0x07, 0xFC, 0x7C, 0x01,
  0xFF, 0x1F, 0x00, 0x7F, 0xC3, 0xE0, 0x1F, 0xF0, 0xF8, 0x07, 0xFC, 0x3E,
  0x01, 0xFF, 0x07, 0xC0, 0x7F, 0xC1, 0xF0, 0x1F, 0xF0, 0x3E, 0x07, 0xFC,
  0x0F, 0x81, 0xFF, 0x03, 0xF0, 0x7F, 0xC0, 0x7C, 0x1F, 0xF0, 0x1F, 0x07,
  0xFC, 0x03, 0xE1, 0xFF, 0x00, 0xF8, 0x7F, 0xC0, 0x1F, 0x1F, 0xF0, 0x07,
  0xC7, 0xFC, 0x01, 0xF9, 0xFF, 0x00, 0x3E, 0x7F, 0xC0, 0x0F, 0x9F, 0xF0,
  0x01, 0xF7, 0xFC, 0x00, 0x7D, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x83, 0xFE, 0x7C, 0x07, 0xF3, 0xE0,
  0x1F, 0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x7E, 0x7C, 0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x8F, 0xFE, 0x1F, 0x01, 0xFC,
  0x3E, 0x01, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3F, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0,
  0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x87,
  0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xE0, 0xF8, 0xFC, 0x00, 0x8F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xDC, 0x00, 0xFE, 0xFE,
  0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01,
  0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xDE, 0x00, 0x7C, 0x3F, 0x00, 0x3D, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xDE, 0x00, 0x7C, 0x1F, 0x00, 0x7D, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0x9F, 0x00, 0xFC, 0x1F, 0x00, 0x79, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0x9F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x8F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0xF0, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x07, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x00, 0x7C, 0x1F, 0x07, 0xC3, 0xF0,
  0x07, 0xC1, 0xE0, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x07, 0xC3, 0xE0, 0x03,
  0xE3, 0xE0, 0x3C, 0x3E, 0x00, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x03, 0xE3,
  0xE0, 0x3C, 0x7E, 0x00, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xC0,
  0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x1E,
  0x7C, 0x00, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x1E, 0xF8,
  0x00, 0x0F, 0x78, 0x01, 0xFF, 0x80, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x7E, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x03,
  0xE3, 0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x00,
  0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xF7, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xF3, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x07,
  0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F,
  0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01,
  0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC0,
  0xF0, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0x0F, 0xE0, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0x7C, 0x07, 0xF7, 0xE0, 0xFF, 0x7F, 0xBF, 0xF3, 0xFF, 0xCF, 0x1F, 0xF8,
  0xF0, 0xFF, 0x0F, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x0F, 0x8F, 0xF8, 0x3E,
  0x7F, 0xF0, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0x3F, 0x80,
  0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFE, 0x01, 0xFB, 0xF8,
  0x07, 0xCF, 0xF8, 0x3F, 0x3E, 0xFF, 0xF8, 0xFB, 0xFF, 0xE3, 0xC7, 0xFF,
  0x0F, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xF1, 0xF8, 0x09, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x0C, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC1, 0xF0,
  0x7F, 0xC7, 0xC3, 0xFF, 0x9F, 0x1F, 0xFF, 0x7C, 0xFF, 0xFD, 0xF3, 0xF0,
  0x7F, 0xDF, 0x80, 0xFF, 0x7C, 0x01, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C,
  0x01, 0xFD, 0xF8, 0x0F, 0xF3, 0xF0, 0x7F, 0xCF, 0xFF, 0xDF, 0x1F, 0xFE,
  0x7C, 0x3F, 0xF9, 0xF0, 0x7F, 0x83, 0xC0, 0x38, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x8F, 0xC3, 0xE0, 0x7E,
  0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x23, 0xF8, 0x0E,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xC2, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xFF,
  0x7C, 0xFC, 0x1F, 0xF7, 0xE0, 0x3F, 0xDF, 0x00, 0x7F, 0x7C, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0,
  0x1F, 0xDF, 0x00, 0x7F, 0x7E, 0x03, 0xFC, 0xFC, 0x1F, 0xF3, 0xFF, 0xF7,
  0xC7, 0xFF, 0x9F, 0x0F, 0xFC, 0x7C, 0x1F, 0xE1, 0xF0, 0x0C, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE4, 0x00, 0x1F, 0x1C, 0x01, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0xF8, 0xFF, 0x8F, 0x9F, 0xFC, 0xFB, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0,
  0x77, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x3F, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0x78, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF0,
  0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8,
  0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xF7, 0xC0, 0xFE, 0x7C, 0x0F, 0xC3, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x3C, 0x3F, 0xC0, 0xFF, 0x8F, 0x1F,
  0xF8, 0x7F, 0xF3, 0xCF, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF,
  0xC1, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F,
  0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0x00,
  0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x7C,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x01,
  0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0,
  0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x07,
  0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xC0,
  0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F,
  0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x0F, 0xF8, 0xF1, 0xFF, 0xCF, 0x3F,
  0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F,
  0x00, 0x7E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x3E, 0x03, 0xF0,
  0xFC, 0x1F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xC3, 0xFE, 0x0F, 0x1F,
  0xFC, 0x3E, 0xFF, 0xF8, 0xFF, 0xEF, 0xF3, 0xFC, 0x0F, 0xCF, 0xE0, 0x1F,
  0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x80, 0x7E, 0xFE, 0x01,
  0xF3, 0xFE, 0x0F, 0xCF, 0xBF, 0xFE, 0x3E, 0xFF, 0xF8, 0xF9, 0xFF, 0xC3,
  0xE3, 0xFE, 0x0F, 0x81, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xFF, 0x7C, 0xFC, 0x1F,
  0xF7, 0xE0, 0x3F, 0xDF, 0x00, 0x7F, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0xDF, 0x00,
  0x7F, 0x7E, 0x03, 0xFC, 0xFC, 0x1F, 0xF3, 0xFF, 0xF7, 0xC7, 0xFF, 0x9F,
  0x0F, 0xFC, 0x7C, 0x1F, 0xE1, 0xF0, 0x0C, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xE7, 0xF9, 0xF3, 0xE0, 0x13,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01,
  0xFF, 0x81, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFC, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x03, 0xFC, 0x03, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF7,
  0xC0, 0x7F, 0x7E, 0x0F, 0xF7, 0xFF, 0xEF, 0x3F, 0xFC, 0xF1, 0xFF, 0x8F,
  0x0F, 0xF0, 0xF0, 0x1C, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80,
  0x1F, 0xF8, 0x03, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x80, 0x3E, 0x7C, 0x03,
  0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x3E, 0x7C, 0x03, 0xFC, 0x03, 0xC7,
  0xC0, 0x7B, 0xC0, 0x7C, 0x7C, 0x07, 0xBC, 0x07, 0xC3, 0xE0, 0x7B, 0xE0,
  0x7C, 0x3E, 0x07, 0x9E, 0x07, 0xC3, 0xE0, 0x79, 0xE0, 0x78, 0x3E, 0x0F,
  0x9E, 0x0F, 0x81, 0xE0, 0xF1, 0xE0, 0xF8, 0x1F, 0x0F, 0x1F, 0x0F, 0x81,
  0xF0, 0xF1, 0xF0, 0xF8, 0x1F, 0x0F, 0x0F, 0x0F, 0x01, 0xF1, 0xF0, 0xF1,
  0xF0, 0x0F, 0x1E, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0xF9, 0xF0, 0x0F, 0x9E,
  0x0F, 0x9E, 0x00, 0xF9, 0xE0, 0x79, 0xE0, 0x0F, 0xBE, 0x07, 0xBE, 0x00,
  0x7B, 0xC0, 0x7B, 0xE0, 0x07, 0xBC, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x7B,
  0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFB,
  0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0x7E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01,
  0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0x83,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0xFF, 0xBF, 0xFF, 0xFC, 0x0F, 0xFF, 0xA0, 0x07, 0xFE, 0x40, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 45, 15, 4, -44 },
  { 41, 16, 16, 24, 4, -44 },
  { 73, 26, 44, 29, 1, -44 },
  { 216, 22, 51, 27, 2, -47 },
  { 357, 37, 46, 41, 2, -45 },
  { 570, 28, 46, 30, 2, -45 },
  { 731, 5, 16, 13, 4, -44 },
  { 741, 13, 55, 18, 3, -45 },
  { 831, 13, 55, 18, 2, -45 },
  { 921, 20, 20, 25, 2, -47 },
  { 971, 23, 29, 27, 2, -36 },
  { 1055, 9, 15, 14, 2, -7 },
  { 1072, 13, 5, 17, 2, -19 },
  { 1081, 6, 8, 14, 4, -7 },
  { 1087, 21, 44, 23, 1, -44 },
  { 1203, 21, 46, 27, 3, -45 },
  { 1324, 14, 44, 27, 4, -44 },
  { 1401, 22, 45, 27, 2, -45 },
  { 1525, 22, 46, 27, 2, -45 },
  { 1652, 25, 45, 27, 1, -45 },
  { 1793, 21, 45, 27, 3, -44 },
  { 1912, 21, 46, 27, 3, -45 },
  { 2033, 22, 44, 27, 2, -44 },
  { 2154, 23, 46, 27, 2, -45 },
  { 2287, 22, 46, 27, 2, -45 },
  { 2414, 6, 34, 14, 4, -33 },
  { 2440, 9, 41, 14, 2, -33 },
  { 2487, 23, 28, 27, 2, -36 },
  { 2568, 23, 18, 27, 2, -31 },
  { 2620, 23, 28, 27, 2, -36 },
  { 2701, 17, 46, 20, 1, -45 },
  { 2799, 35, 50, 40, 3, -45 },
  { 3018, 28, 44, 28, 0, -44 },
  { 3172, 22, 44, 30, 5, -44 },
  { 3293, 23, 46, 28, 3, -45 },
  { 3426, 24, 44, 32, 5, -44 },
  { 3558, 17, 44, 25, 5, -44 },
  { 3652, 17, 44, 24, 5, -44 },
  { 3746, 27, 46, 34, 3, -45 },
  { 3902, 24, 44, 33, 5, -44 },
  { 4034, 13, 44, 18, 2, -44 },
  { 4106, 13, 56, 14, -3, -44 },
  { 4197, 23, 44, 28, 5, -44 },
  { 4324, 17, 44, 23, 5, -44 },
  { 4418, 35, 44, 45, 5, -44 },
  { 4611, 26, 44, 35, 5, -44 },
  { 4754, 28, 46, 34, 3, -45 },
  { 4915, 21, 44, 27, 5, -44 },
  { 5031, 28, 56, 34, 3, -45 },
  { 5227, 23, 44, 29, 5, -44 },
  { 5354, 21, 46, 26, 2, -45 },
  { 5475, 22, 44, 24, 1, -44 },
  { 5596, 24, 45, 32, 4, -44 },
  { 5731, 27, 44, 27, 0, -44 },
  { 5880, 44, 44, 45, 0, -44 },
  { 6122, 24, 44, 25, 0, -44 },
  { 6254, 24, 44, 24, 0, -44 },
  { 6386, 19, 44, 22, 2, -44 },
  { 6491, 13, 55, 19, 4, -45 },
  { 6581, 21, 44, 23, 1, -44 },
  { 6697, 13, 55, 19, 2, -45 },
  { 6787, 26, 23, 27, 1, -44 },
  { 6862, 27, 4, 27, 0, 5 },
  { 6876, 12, 9, 16, 2, -47 },
  { 6890, 20, 35, 26, 2, -34 },
  { 6978, 22, 48, 29, 4, -47 },
  { 7110, 17, 35, 22, 3, -34 },
  { 7185, 22, 48, 29, 3, -47 },
  { 7317, 20, 35, 26, 3, -34 },
  { 7405, 16, 47, 16, 1, -47 },
  { 7499, 22, 49, 29, 3, -34 },
  { 7634, 20, 47, 28, 4, -47 },
  { 7752, 5, 46, 13, 4, -46 },
  { 7781, 10, 61, 13, -1, -46 },
  { 7858, 20, 47, 25, 4, -47 },
  { 7976, 5, 47, 13, 4, -47 },
  { 8006, 34, 34, 42, 4, -34 },
  { 8151, 20, 34, 28, 4, -34 },
  { 8236, 22, 35, 28, 3, -34 },
  { 8333, 22, 49, 29, 4, -34 },
  { 8468, 22, 49, 29, 3, -34 },
  { 8603, 14, 34, 19, 4, -34 },
  { 8663, 17, 35, 21, 2, -34 },
  { 8738, 14, 42, 16, 1, -41 },
  { 8812, 20, 34, 28, 4, -33 },
  { 8897, 23, 33, 23, 0, -33 },
  { 8992, 36, 33, 38, 1, -33 },
  { 9141, 21, 33, 23, 1, -33 },
  { 9228, 23, 48, 23, 0, -33 },
  { 9366, 15, 33, 19, 2, -33 },
  { 9428, 17, 54, 22, 3, -44 },
  { 9543, 5, 62, 25, 10, -47 },
  { 9582, 17, 54, 22, 3, -44 },
  { 9697, 23, 8, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Regular62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR62PT7B_H_
