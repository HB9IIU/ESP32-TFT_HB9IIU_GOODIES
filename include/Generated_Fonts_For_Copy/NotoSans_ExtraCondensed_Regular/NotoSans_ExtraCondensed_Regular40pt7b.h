#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0,
  0x00, 0x6F, 0xFF, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xB8, 0xF7, 0x1E, 0xE3,
  0xDC, 0x3B, 0x86, 0x70, 0xCE, 0x19, 0x83, 0x00, 0x07, 0x0C, 0x03, 0x86,
  0x01, 0xC3, 0x00, 0xE1, 0x80, 0x71, 0xC0, 0x30, 0xE0, 0x18, 0x70, 0x0C,
  0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xC3, 0x00, 0xE3, 0x80,
  0x61, 0xC0, 0x30, 0xE0, 0x18, 0x70, 0x0C, 0x30, 0x0E, 0x18, 0x3F, 0xFF,
  0xDF, 0xFF, 0xE1, 0xC7, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x30, 0xE0, 0x18,
  0x70, 0x1C, 0x30, 0x0E, 0x18, 0x07, 0x0C, 0x03, 0x8E, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x07, 0xF8, 0x3F, 0xF9, 0xFF, 0xEF, 0x31, 0x38, 0xC0,
  0xE3, 0x03, 0x0C, 0x0E, 0x30, 0x38, 0xC0, 0xF3, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x37, 0x80, 0xCE, 0x03, 0x1C, 0x0C,
  0x70, 0x31, 0xA0, 0xCE, 0xC3, 0x7B, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3C, 0x01, 0xC0, 0xFC, 0x03, 0x01,
  0xFC, 0x0E, 0x07, 0x38, 0x1C, 0x0E, 0x30, 0x70, 0x18, 0x70, 0xE0, 0x38,
  0xE1, 0x80, 0x61, 0xC7, 0x00, 0xC3, 0x8E, 0x01, 0x87, 0x18, 0x03, 0x0E,
  0x70, 0x06, 0x1C, 0xE1, 0x0C, 0x39, 0x8F, 0x9C, 0x67, 0x3F, 0xB9, 0xCE,
  0xE7, 0x3F, 0x99, 0xC6, 0x7E, 0x73, 0x8E, 0x78, 0xE6, 0x1C, 0x01, 0x8C,
  0x38, 0x07, 0x18, 0x70, 0x0E, 0x30, 0xE0, 0x18, 0x61, 0xC0, 0x70, 0xC3,
  0x80, 0xE1, 0x87, 0x03, 0x83, 0x8E, 0x07, 0x07, 0x18, 0x0C, 0x06, 0x70,
  0x38, 0x0F, 0xE0, 0x70, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x00, 0xF1, 0xC0,
  0x3C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x0E, 0x39, 0xC3, 0x9E, 0x78, 0xE7, 0x0E,
  0x7B, 0xC3, 0xDC, 0xF0, 0x77, 0x38, 0x0F, 0xCF, 0x03, 0xE3, 0xC0, 0x78,
  0xF0, 0x3E, 0x1E, 0x1F, 0xC7, 0xFF, 0x78, 0xFF, 0x9E, 0x1F, 0xC3, 0xC0,
  0xFF, 0xF7, 0x77, 0x77, 0x77, 0x60, 0x07, 0x07, 0x0E, 0x1E, 0x1C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38,
  0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x78, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x00, 0x07, 0x80, 0x38,
  0x00, 0xC0, 0x86, 0x17, 0xB7, 0xBF, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0xC0,
  0xE7, 0x0F, 0x3C, 0x70, 0xE0, 0x84, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0xF3, 0xCE, 0x39, 0xE7,
  0x1C, 0x73, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x73, 0xBF, 0xF7, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x38, 0x3B, 0xC1, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC1,
  0xFE, 0x0F, 0x70, 0x73, 0xC7, 0x8F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x01,
  0xC0, 0xF0, 0x7C, 0x3F, 0x1F, 0xCF, 0x7F, 0xBD, 0xCF, 0x23, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1C, 0x3E, 0x20, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0x1C, 0x1E, 0x20, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3D, 0x01,
  0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0x78, 0x07, 0x78,
  0x06, 0x78, 0x0E, 0x78, 0x0C, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x38, 0x78,
  0x38, 0x78, 0x70, 0x78, 0x70, 0x78, 0xE0, 0x78, 0xE0, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xCC, 0x0F,
  0xFC, 0x7F, 0xF1, 0x8F, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0xBF, 0xFD,
  0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x39,
  0xF0, 0xEF, 0xE3, 0xFF, 0xCF, 0x87, 0xBC, 0x1E, 0xF0, 0x3B, 0x80, 0xEE,
  0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xEF, 0x03, 0x9C, 0x0E, 0x70, 0x79,
  0xE1, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x83, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0x70, 0x78, 0xE0, 0xE0, 0xE3,
  0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x3C, 0xF8, 0xF0, 0x79,
  0xC0, 0xF3, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x70,
  0x1C, 0xF0, 0x78, 0xFB, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xC0, 0x7F,
  0x83, 0xFF, 0x0F, 0x1E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0xDC, 0x07, 0xF0,
  0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x83, 0xCF,
  0xBF, 0x3F, 0xDC, 0x7E, 0x70, 0x21, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x80,
  0x23, 0xBF, 0xF7, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9F,
  0xFF, 0xB8, 0x10, 0xE7, 0xDF, 0x38, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF3, 0xCF, 0x38, 0xE7, 0x9C, 0x71, 0xCE, 0x00, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0x78, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x1F, 0x0F, 0xFC, 0x7F, 0xE6, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xC0,
  0x78, 0x1E, 0x00, 0xF0, 0x70, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x70, 0x3E, 0x19, 0xC3, 0xFC, 0x76, 0x1E, 0x71, 0xF8, 0x71, 0xC7, 0xE1,
  0x87, 0x1F, 0x8E, 0x1C, 0x3E, 0x38, 0x70, 0xF8, 0xE1, 0xC3, 0xE3, 0x87,
  0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0xE1, 0xF8, 0xE3, 0x87, 0xE3, 0x8F, 0x1B,
  0x87, 0x2C, 0xEE, 0x1F, 0xBF, 0x98, 0x3C, 0x7C, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x0C,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x1C, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xF0, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x78, 0x78, 0x1C, 0x0E, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3C, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x1E,
  0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xC0,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0x0F, 0xCE, 0x07, 0xDC, 0x07, 0xB8,
  0x0F, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xE7, 0x03, 0xCE, 0x1F,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFC, 0xE0, 0x7D, 0xC0, 0x7B, 0x80, 0x77,
  0x00, 0xEE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0,
  0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0xF8, 0x63, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x08, 0x7F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xE3, 0xF8, 0xE0, 0x7C,
  0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E,
  0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7C, 0x0E, 0x3E, 0x01, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3C,
  0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03,
  0xFF, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0xFF, 0xFF, 0xDF,
  0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x9F, 0xFF, 0xF8, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0F, 0x9F, 0xFE, 0xFC, 0x70, 0xE0, 0x1F, 0xC0, 0x7B, 0x80,
  0xF7, 0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xE1, 0xC1,
  0xC7, 0x83, 0x8E, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFB, 0x81, 0xE7, 0x83, 0x87, 0x07, 0x0F, 0x0E, 0x1E, 0x1C, 0x1E,
  0x38, 0x3C, 0x70, 0x38, 0xE0, 0x79, 0xC0, 0x73, 0x80, 0xF7, 0x00, 0xEE,
  0x01, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3B, 0xF7, 0x00, 0x77, 0xEE, 0x00, 0xEF, 0xDC, 0x03, 0x9F, 0x9C,
  0x07, 0x3F, 0x38, 0x0E, 0x7E, 0x70, 0x1C, 0xFC, 0xE0, 0x71, 0xF8, 0xE0,
  0xE3, 0xF1, 0xC1, 0xC7, 0xE3, 0x87, 0x0F, 0xC3, 0x8E, 0x1F, 0x87, 0x1C,
  0x3F, 0x0E, 0x38, 0x7E, 0x1C, 0xE0, 0xFC, 0x1D, 0xC1, 0xF8, 0x3B, 0x83,
  0xF0, 0x76, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xC0, 0x7E, 0x03, 0x80, 0xE0, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xDC, 0x07, 0xEE,
  0x03, 0xF3, 0x81, 0xF9, 0xC0, 0xFC, 0xF0, 0x7E, 0x38, 0x3F, 0x1E, 0x1F,
  0x87, 0x0F, 0xC3, 0x87, 0xE0, 0xE3, 0xF0, 0x71, 0xF8, 0x3C, 0xFC, 0x0E,
  0x7E, 0x07, 0xBF, 0x01, 0xDF, 0x80, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x78, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xF8, 0x78, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x79,
  0xC0, 0x0E, 0x70, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xE7, 0x80, 0x79,
  0xE0, 0x1E, 0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xFE, 0x3F, 0xF9, 0xC7, 0xEE, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x87, 0xDF, 0xFC, 0xFF, 0xC7, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C,
  0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x79, 0xC0, 0x0E, 0x70, 0x03, 0xBC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70,
  0x03, 0xDC, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x0F, 0x0F, 0x87,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x87, 0x3F, 0x8E, 0x07, 0x9C, 0x0F, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x3D, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9C,
  0x1E, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0x81, 0xC7, 0x83, 0x87, 0x07, 0x0F,
  0x0E, 0x0E, 0x1C, 0x1E, 0x38, 0x3C, 0x70, 0x38, 0xE0, 0x79, 0xC0, 0x73,
  0x80, 0xF7, 0x00, 0xEE, 0x01, 0xE0, 0x0F, 0xC1, 0xFF, 0xDF, 0xFC, 0xF8,
  0xEF, 0x01, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x74, 0x07,
  0xBF, 0xF9, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1E,
  0xF0, 0x79, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x00,
  0xEF, 0x00, 0x39, 0xC0, 0x1E, 0x70, 0x07, 0x9E, 0x01, 0xC7, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x1E, 0x07, 0x07, 0x01, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8F,
  0x00, 0xF3, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xDE, 0x00, 0x77, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0x80, 0x38, 0x03, 0x9C, 0x03, 0xC0,
  0x1C, 0xE0, 0x1F, 0x00, 0xE7, 0x00, 0xF8, 0x0F, 0x3C, 0x07, 0xC0, 0x79,
  0xE0, 0x36, 0x03, 0x87, 0x03, 0xB0, 0x1C, 0x38, 0x1D, 0xC0, 0xE1, 0xC0,
  0xEE, 0x0F, 0x0F, 0x07, 0x70, 0x78, 0x78, 0x33, 0x83, 0x81, 0xC3, 0x8C,
  0x1C, 0x0E, 0x1C, 0x70, 0xE0, 0x70, 0xE3, 0x8F, 0x03, 0xC7, 0x1C, 0x78,
  0x1E, 0x30, 0xE3, 0x80, 0x73, 0x83, 0x1C, 0x03, 0x9C, 0x1C, 0xE0, 0x1C,
  0xE0, 0xEF, 0x00, 0xE7, 0x07, 0x78, 0x03, 0xB0, 0x3B, 0x80, 0x1F, 0x80,
  0xDC, 0x00, 0xFC, 0x06, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x78, 0x0E, 0x78, 0x0E, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x3C, 0x3C,
  0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C,
  0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFC, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70,
  0x1E, 0x70, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF1, 0xE1, 0xE1, 0xC1, 0xC1, 0x81, 0x80, 0x07, 0xC1, 0xFF,
  0x0F, 0xFC, 0x20, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x3F, 0xC7, 0xFE, 0x7E, 0x77, 0x83, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xDC, 0x1E, 0xF3, 0xF3, 0xFB, 0x9F, 0x8C, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE3,
  0xC3, 0xBF, 0x8F, 0xFF, 0x3E, 0x3C, 0xF0, 0x7B, 0xC0, 0xEE, 0x03, 0xB8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0xC0, 0xEF, 0x07, 0xBF, 0xBC, 0xEF, 0xF3,
  0x1F, 0x80, 0x07, 0xC3, 0xFC, 0xFF, 0xBC, 0x27, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3F, 0x73, 0xFE, 0x3F, 0x80, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x0F,
  0x1C, 0xFE, 0x73, 0xFD, 0xDE, 0x3F, 0x70, 0x7F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x07, 0xDF, 0x7F, 0x3F, 0xDC,
  0x7E, 0x70, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x02, 0x7C, 0xE3, 0xFF,
  0x07, 0xF8, 0x01, 0x80, 0xFC, 0x3F, 0x8F, 0x21, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x83, 0xFF, 0x7F, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x0F, 0x00, 0xFE,
  0x73, 0xFD, 0xDE, 0x3F, 0x70, 0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x07, 0xDF, 0x77, 0x3F, 0xDC, 0x7E, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xA0, 0x1E, 0x71, 0xF1,
  0xFF, 0xC7, 0xFC, 0x01, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE3, 0xC7, 0x7F, 0x3F, 0xFD, 0xF1,
  0xEF, 0x07, 0x78, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3C, 0x27, 0xFF, 0x70, 0x00, 0x07, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x04, 0x1C, 0x78,
  0xF0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0xF9, 0xDF, 0xBE, 0x30, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x07,
  0xB8, 0x39, 0xC3, 0xCE, 0x1C, 0x71, 0xC3, 0x9E, 0x1C, 0xE0, 0xEE, 0x07,
  0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0x78, 0x71, 0xC3, 0x8F, 0x1C, 0x38, 0xE1,
  0xC7, 0x0F, 0x38, 0x39, 0xC1, 0xEE, 0x07, 0x70, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x81, 0xE3,
  0x3F, 0x9F, 0xCD, 0xFE, 0xFF, 0xBE, 0x3F, 0x1E, 0xF0, 0x78, 0x3B, 0x81,
  0xE0, 0xFE, 0x07, 0x83, 0xF8, 0x1C, 0x0F, 0xE0, 0x70, 0x1F, 0x81, 0xC0,
  0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x7E,
  0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x07,
  0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x70, 0x03, 0x86,
  0x7F, 0x37, 0xFD, 0xF1, 0xEF, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3C, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x0F, 0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x8F, 0xFC, 0x3F, 0xF0, 0x3F,
  0x00, 0x03, 0xC3, 0x3F, 0x8F, 0xFF, 0x3E, 0x1E, 0xF0, 0x7B, 0xC0, 0xEE,
  0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0xC0, 0xEF, 0x07, 0xBF, 0x7C,
  0xEF, 0xF3, 0x9F, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0xFE,
  0x73, 0xFD, 0xDE, 0x3F, 0x70, 0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x07, 0xDF, 0x77, 0x3F, 0xDC, 0x7E, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x07, 0xE7, 0xF3, 0xFB, 0xEF, 0x87, 0x83,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x0F, 0x87, 0xFD, 0xFF, 0xB8, 0x2F,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x87, 0xFF, 0xFE, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x7F, 0x3F, 0x8F, 0xC0, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x87,
  0xFF, 0xEE, 0xFF, 0x73, 0xF3, 0x80, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0x73,
  0x81, 0xE7, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x3C, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x0E, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x3C,
  0x0F, 0x70, 0x3C, 0x0E, 0x70, 0x3E, 0x0E, 0x70, 0x7E, 0x0E, 0x78, 0x7E,
  0x0E, 0x38, 0x7E, 0x1E, 0x38, 0x76, 0x1C, 0x38, 0x67, 0x1C, 0x38, 0xE7,
  0x1C, 0x3C, 0xE7, 0x1C, 0x1C, 0xE7, 0x38, 0x1C, 0xE3, 0x38, 0x1C, 0xC3,
  0xB8, 0x1D, 0xC3, 0xB8, 0x0D, 0xC3, 0xB8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xE0, 0xF0, 0x7B, 0x83, 0x9E, 0x1C, 0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x77,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0E, 0xE0,
  0x77, 0x07, 0x1C, 0x38, 0xE3, 0x87, 0x9C, 0x1D, 0xE0, 0xFE, 0x03, 0x80,
  0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xE7, 0x83, 0x87, 0x07, 0x0E,
  0x0E, 0x1C, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x80, 0xEE,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x06, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x04, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x60, 0x7C, 0x1F, 0x87, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x7C, 0x1E, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x80,
  0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0xC0, 0x7C, 0x0F, 0x87, 0xC0, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x00, 0x18, 0x02, 0xFE, 0x07, 0xFF,
  0xBF, 0x1F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 29, 9, 3, -29 },
  { 16, 11, 11, 15, 2, -29 },
  { 32, 17, 29, 18, 1, -29 },
  { 94, 14, 32, 17, 2, -30 },
  { 150, 23, 29, 27, 2, -29 },
  { 234, 18, 29, 19, 1, -29 },
  { 300, 4, 11, 8, 2, -29 },
  { 306, 8, 35, 12, 2, -29 },
  { 341, 9, 35, 12, 1, -29 },
  { 381, 13, 13, 16, 1, -30 },
  { 403, 15, 19, 17, 1, -24 },
  { 439, 6, 10, 9, 1, -5 },
  { 447, 9, 3, 11, 1, -12 },
  { 451, 5, 5, 9, 2, -5 },
  { 455, 13, 29, 15, 1, -29 },
  { 503, 13, 29, 17, 2, -29 },
  { 551, 10, 29, 17, 2, -29 },
  { 588, 14, 29, 17, 1, -29 },
  { 639, 14, 29, 17, 1, -29 },
  { 690, 16, 29, 17, 1, -29 },
  { 748, 13, 29, 17, 2, -29 },
  { 796, 14, 29, 17, 2, -29 },
  { 847, 15, 29, 17, 1, -29 },
  { 902, 15, 29, 17, 1, -29 },
  { 957, 14, 29, 17, 1, -29 },
  { 1008, 5, 22, 9, 2, -22 },
  { 1022, 6, 27, 9, 1, -22 },
  { 1043, 15, 18, 17, 1, -23 },
  { 1077, 15, 12, 17, 1, -20 },
  { 1100, 15, 18, 17, 1, -23 },
  { 1134, 12, 29, 13, 0, -29 },
  { 1178, 22, 32, 26, 2, -29 },
  { 1266, 18, 29, 18, 0, -29 },
  { 1332, 15, 29, 19, 3, -29 },
  { 1387, 15, 29, 18, 2, -29 },
  { 1442, 16, 29, 21, 3, -29 },
  { 1500, 11, 29, 16, 3, -29 },
  { 1540, 11, 29, 15, 3, -29 },
  { 1580, 18, 29, 22, 2, -29 },
  { 1646, 15, 29, 21, 3, -29 },
  { 1701, 9, 29, 11, 1, -29 },
  { 1734, 8, 37, 9, -2, -29 },
  { 1771, 15, 29, 18, 3, -29 },
  { 1826, 11, 29, 15, 3, -29 },
  { 1866, 23, 29, 29, 3, -29 },
  { 1950, 17, 29, 23, 3, -29 },
  { 2012, 18, 29, 22, 2, -29 },
  { 2078, 13, 29, 18, 3, -29 },
  { 2126, 18, 36, 22, 2, -29 },
  { 2207, 15, 29, 18, 3, -29 },
  { 2262, 13, 29, 17, 2, -29 },
  { 2310, 15, 29, 15, 0, -29 },
  { 2365, 15, 29, 21, 3, -29 },
  { 2420, 18, 29, 18, 0, -29 },
  { 2486, 29, 29, 29, 0, -29 },
  { 2592, 16, 29, 16, 0, -29 },
  { 2650, 16, 29, 16, 0, -29 },
  { 2708, 13, 29, 14, 1, -29 },
  { 2756, 8, 35, 12, 3, -29 },
  { 2791, 13, 29, 15, 1, -29 },
  { 2839, 9, 35, 12, 1, -29 },
  { 2879, 16, 16, 18, 1, -29 },
  { 2911, 18, 3, 17, 0, 3 },
  { 2918, 7, 7, 11, 2, -31 },
  { 2925, 13, 22, 17, 1, -22 },
  { 2961, 14, 30, 18, 3, -30 },
  { 3014, 11, 22, 14, 2, -22 },
  { 3045, 14, 30, 18, 2, -30 },
  { 3098, 13, 22, 17, 2, -22 },
  { 3134, 11, 31, 10, 0, -31 },
  { 3177, 14, 32, 18, 2, -22 },
  { 3233, 13, 30, 18, 3, -30 },
  { 3282, 4, 30, 8, 2, -30 },
  { 3297, 7, 40, 8, -1, -30 },
  { 3332, 13, 30, 16, 3, -30 },
  { 3381, 3, 30, 8, 3, -30 },
  { 3393, 22, 22, 27, 3, -22 },
  { 3454, 13, 22, 18, 3, -22 },
  { 3490, 14, 22, 18, 2, -22 },
  { 3529, 14, 32, 18, 3, -22 },
  { 3585, 14, 32, 18, 2, -22 },
  { 3641, 9, 22, 12, 3, -22 },
  { 3666, 11, 22, 14, 1, -22 },
  { 3697, 9, 26, 10, 1, -26 },
  { 3727, 13, 21, 18, 3, -21 },
  { 3762, 15, 21, 15, 0, -21 },
  { 3802, 24, 21, 24, 0, -21 },
  { 3865, 13, 21, 15, 1, -21 },
  { 3900, 15, 31, 15, 0, -21 },
  { 3959, 10, 21, 12, 1, -21 },
  { 3986, 11, 35, 14, 2, -29 },
  { 4035, 3, 40, 16, 7, -31 },
  { 4050, 11, 35, 14, 2, -29 },
  { 4099, 15, 5, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Regular40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR40PT7B_H_
