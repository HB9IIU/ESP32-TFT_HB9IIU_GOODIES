#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xDF, 0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xE7, 0x81, 0xF3, 0xC0,
  0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7,
  0xF7, 0x1F, 0x1F, 0x1C, 0x0C, 0xF8, 0x70, 0x03, 0xE1, 0xC0, 0x0F, 0x07,
  0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x00,
  0x3E, 0x1C, 0x00, 0xFC, 0x70, 0x01, 0xF9, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xCF, 0xC0, 0x07, 0x1F, 0x80, 0x1C, 0x3E,
  0x00, 0x70, 0x7C, 0x01, 0xC1, 0xF0, 0x07, 0x07, 0xC0, 0x1C, 0x1F, 0x00,
  0x70, 0x7C, 0x01, 0xC1, 0xF0, 0x07, 0x0F, 0xA0, 0x1C, 0x3E, 0xF0, 0x73,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x00,
  0xFF, 0xF0, 0x03, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x00, 0x3C, 0x3C, 0x01,
  0xE0, 0x03, 0xC1, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x78, 0x00, 0xF0,
  0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x03, 0xE0,
  0x01, 0xE0, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x3C, 0x3E, 0x00, 0x07, 0x81, 0xE1, 0xE0, 0x00, 0x3C, 0x0F, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0xF8, 0xFF, 0x8F, 0x03, 0xC7, 0x87, 0xFC, 0x78,
  0x3E, 0x3C, 0x7F, 0xF1, 0xE1, 0xE3, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E, 0x3C,
  0x3E, 0x7F, 0xF8, 0xF1, 0xE0, 0xF1, 0xFF, 0x8F, 0x0F, 0x07, 0x87, 0xF8,
  0x78, 0xF8, 0x3E, 0x1F, 0x83, 0xC7, 0xC1, 0xF0, 0x00, 0x3C, 0x3C, 0x0F,
  0x80, 0x01, 0xE1, 0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0x01, 0xE0, 0x00, 0xF0,
  0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x78, 0x00, 0x7C, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E,
  0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x07,
  0xC0, 0x3C, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x0F, 0x8F,
  0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0x80,
  0x07, 0xFC, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x03, 0xE0, 0xFD, 0xF0, 0x3F, 0x0F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xE3,
  0xE3, 0xF0, 0x1F, 0x1F, 0x1F, 0x00, 0xFD, 0xF8, 0xF8, 0x03, 0xFF, 0x87,
  0xC0, 0x0F, 0xFC, 0x3E, 0x00, 0x7F, 0xC1, 0xF0, 0x01, 0xFE, 0x0F, 0x80,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xFC, 0x1F, 0x80, 0x3F,
  0xE0, 0x7E, 0x03, 0xFF, 0x83, 0xFC, 0x7F, 0x7E, 0x0F, 0xFF, 0xFB, 0xF0,
  0x7F, 0xFF, 0x8F, 0xC1, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0x79, 0xE7, 0x9E, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x01, 0x01, 0xE0, 0x4F, 0x0F, 0x1E, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0x7C, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0x80, 0x60, 0x30, 0x01, 0x01, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x1F, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0xFF, 0x3E, 0x10,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3E, 0x0F, 0x80, 0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3F, 0x07, 0xE0,
  0xFE, 0x3F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xDF, 0x3F, 0x3E, 0xFC, 0x7F,
  0xF0, 0xFB, 0xC1, 0xF3, 0x03, 0xE4, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xF0, 0x0F,
  0xC3, 0x00, 0x1F, 0x84, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0x9F, 0xF1, 0xF0, 0x0F, 0xE3, 0x00, 0x1F, 0x88, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xC0, 0x03, 0xFB, 0xF0, 0x3F, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F,
  0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF7, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x20, 0x00, 0xFC, 0xC0, 0x07, 0xF3,
  0xE0, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x0F, 0x8F, 0xF8, 0x3E, 0x7F, 0xF0,
  0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0x3F, 0x80, 0x7E, 0xFE,
  0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x3F,
  0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F,
  0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC3, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x0F,
  0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0xCF,
  0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF, 0xF7, 0xC1, 0xFF,
  0x9F, 0x03, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0xC0, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0xFF,
  0x3E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87, 0xDF, 0xBF, 0xFF, 0xFF, 0xF9,
  0xF0, 0x80, 0x04, 0x0F, 0x8F, 0xC7, 0xF3, 0xF9, 0xFC, 0xFC, 0x3E, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78,
  0x3C, 0x3E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFC, 0x7E, 0x7F, 0x9C, 0x07, 0xE4, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x10, 0x03,
  0xC3, 0xE0, 0x1F, 0xF8, 0x3E, 0x3C, 0x03, 0xFF, 0xC3, 0xE3, 0xC0, 0x7F,
  0xF8, 0x1E, 0x7C, 0x0F, 0x87, 0x81, 0xE7, 0x81, 0xF0, 0x78, 0x1E, 0x78,
  0x1F, 0x07, 0x81, 0xF7, 0x81, 0xE0, 0x78, 0x1F, 0x78, 0x3E, 0x07, 0x81,
  0xFF, 0x83, 0xE0, 0x78, 0x1F, 0xF8, 0x3C, 0x07, 0x81, 0xFF, 0x03, 0xC0,
  0x78, 0x1F, 0xF0, 0x3C, 0x07, 0x81, 0xFF, 0x03, 0xC0, 0xF8, 0x1F, 0xF0,
  0x3C, 0x0F, 0x81, 0xFF, 0x03, 0xC0, 0xF8, 0x1F, 0xF0, 0x3C, 0x0F, 0x81,
  0xEF, 0x03, 0xC0, 0xF8, 0x1E, 0xF0, 0x3C, 0x0F, 0x81, 0xEF, 0x83, 0xC0,
  0xF8, 0x1E, 0xF8, 0x3E, 0x1F, 0x83, 0xEF, 0x81, 0xE1, 0xF8, 0x3C, 0x78,
  0x1F, 0x3D, 0xC7, 0xC7, 0x81, 0xFF, 0x9F, 0xF8, 0x78, 0x0F, 0xF9, 0xFF,
  0x07, 0xC0, 0x7F, 0x0F, 0xE0, 0x7C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x02, 0x00, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xF0,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E,
  0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x00, 0xFF, 0x3E, 0x00, 0x7E, 0x7C,
  0x00, 0xFE, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00,
  0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x7F,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0xF8, 0x1F, 0xF1, 0xF0, 0x07, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0xFE, 0xF8, 0x03,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0xFE, 0x07, 0xF0, 0x0E, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x02, 0x07, 0xFC, 0x3E, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x7F, 0xC3, 0xE0, 0x0F, 0xE1, 0xF0,
  0x03, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3,
  0xE0, 0x07, 0xF1, 0xF0, 0x07, 0xF0, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0xE0, 0x7F,
  0x80, 0x1E, 0x0F, 0xE0, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0xC0, 0x01, 0xF0, 0xFE, 0x00,
  0x1F, 0x07, 0xF0, 0x01, 0xF0, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x1F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0xFB, 0xF0,
  0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0x7C, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF7, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3D, 0xFF, 0xBC, 0x00, 0x03, 0xDF, 0xFB, 0xE0, 0x00, 0x7D, 0xFF, 0xBE,
  0x00, 0x07, 0xDF, 0xF9, 0xE0, 0x00, 0x79, 0xFF, 0x9F, 0x00, 0x0F, 0x9F,
  0xF9, 0xF0, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x0F, 0x1F, 0xF8, 0xF0, 0x00,
  0xF1, 0xFF, 0x8F, 0x80, 0x1F, 0x1F, 0xF8, 0xF8, 0x01, 0xF1, 0xFF, 0x87,
  0x80, 0x1E, 0x1F, 0xF8, 0x7C, 0x03, 0xE1, 0xFF, 0x87, 0xC0, 0x3E, 0x1F,
  0xF8, 0x7C, 0x03, 0xC1, 0xFF, 0x83, 0xC0, 0x3C, 0x1F, 0xF8, 0x3E, 0x07,
  0xC1, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF8, 0x1E, 0x07, 0x81, 0xFF, 0x81,
  0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0xF0, 0x1F,
  0xF8, 0x0F, 0x0F, 0x01, 0xFF, 0x80, 0xF9, 0xF0, 0x1F, 0xF8, 0x0F, 0x9F,
  0x01, 0xFF, 0x80, 0x79, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFD, 0xF0, 0x01, 0xFF, 0xBE, 0x00, 0x3F, 0xF3,
  0xE0, 0x07, 0xFE, 0x7C, 0x00, 0xFF, 0xCF, 0xC0, 0x1F, 0xF8, 0xF8, 0x03,
  0xFF, 0x1F, 0x80, 0x7F, 0xE1, 0xF0, 0x0F, 0xFC, 0x3E, 0x01, 0xFF, 0x83,
  0xE0, 0x3F, 0xF0, 0x7C, 0x07, 0xFE, 0x0F, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F,
  0xF8, 0x1F, 0x83, 0xFF, 0x01, 0xF0, 0x7F, 0xE0, 0x3E, 0x0F, 0xFC, 0x03,
  0xE1, 0xFF, 0x80, 0x7C, 0x3F, 0xF0, 0x0F, 0xC7, 0xFE, 0x00, 0xF8, 0xFF,
  0xC0, 0x1F, 0x1F, 0xF8, 0x01, 0xF3, 0xFF, 0x00, 0x3E, 0x7F, 0xE0, 0x07,
  0xEF, 0xFC, 0x00, 0x7D, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0x7E,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x7C, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC7, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7C, 0x0F, 0xFB, 0xE0, 0x1F,
  0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x3F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xF8, 0x1F, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x03, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x01, 0xC3, 0xF0, 0x01, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xA0, 0x00, 0x7E, 0xF0, 0x03, 0xF3, 0xFE, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F,
  0xF0, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE3, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3C, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0xF3, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xCF, 0x00,
  0x3E, 0x07, 0xE0, 0x1F, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0xF8, 0x07,
  0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x87, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC0,
  0x1F, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x01,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x80, 0x1F,
  0x87, 0xC0, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x1E, 0x1F, 0x00, 0x0F, 0x87,
  0x80, 0x78, 0x7C, 0x00, 0x1F, 0x3E, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00,
  0x3C, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC3, 0xE0, 0x07,
  0xE1, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0x80, 0x01,
  0xE7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x7E,
  0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F,
  0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x00,
  0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xF8, 0xFE, 0x06, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0,
  0x1F, 0xBE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xBE, 0x03,
  0xFD, 0xF8, 0x3F, 0xEF, 0xFF, 0xDF, 0x3F, 0xFC, 0xF8, 0xFF, 0xC7, 0xC3,
  0xFC, 0x1E, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x7C, 0x7F, 0xE0, 0xF9, 0xFF, 0xE1, 0xF7, 0xFF, 0xE3, 0xEF, 0xFF, 0xC7,
  0xFC, 0x1F, 0xCF, 0xF0, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xE7, 0xF8, 0x0F, 0xCF,
  0xF8, 0x3F, 0x9F, 0x7F, 0xFE, 0x3E, 0x7F, 0xF8, 0x7C, 0x7F, 0xF0, 0xF0,
  0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0x43, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x13, 0xF8, 0x18, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x07, 0xC1, 0xFF, 0x1F, 0x0F, 0xFE,
  0x7C, 0x7F, 0xFD, 0xF3, 0xFF, 0xFF, 0xCF, 0xC0, 0xFF, 0x7E, 0x01, 0xFD,
  0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x7F, 0x3F, 0x83, 0xFC, 0xFF, 0xFE, 0xF1, 0xFF, 0xF3, 0xC3,
  0xFF, 0x8F, 0x07, 0xFC, 0x3C, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF8, 0xFE, 0x1F, 0x81, 0xF0,
  0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x08, 0x7E, 0x01, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0xF0, 0xFF, 0xE3,
  0xC7, 0xFF, 0xCF, 0x3F, 0xFF, 0xBC, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF,
  0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x01, 0xFD,
  0xF8, 0x07, 0xF3, 0xF8, 0x7B, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0x7C, 0x3F,
  0xF9, 0xF0, 0x7F, 0xC7, 0xC0, 0x38, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x90, 0x00, 0x7E, 0x70, 0x03, 0xF9, 0xF8, 0x3F, 0xC7, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0xFC, 0x1F, 0x1F, 0xF8, 0xF9, 0xFF, 0xE7, 0xDF, 0xFF, 0x3E, 0xFF, 0xFD,
  0xFF, 0x07, 0xEF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x7B, 0xFF, 0xFF, 0xFF, 0xE7,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x03, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xD3, 0xFB, 0xFE, 0x7F, 0xCF, 0xF1, 0xFC, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0,
  0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0,
  0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F,
  0x80, 0x7D, 0xFC, 0x03, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x7C, 0x07,
  0xFB, 0xF0, 0x3F, 0x8F, 0x81, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x0F, 0x0F, 0xF8, 0x1F, 0xF0, 0xF9, 0xFF,
  0xC3, 0xFF, 0x8F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFB, 0xFF, 0xEF, 0xFF, 0xCF,
  0xF0, 0x7F, 0xE0, 0x7E, 0xFE, 0x03, 0xFC, 0x07, 0xEF, 0xE0, 0x1F, 0xC0,
  0x3E, 0xFC, 0x01, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00,
  0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00,
  0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00,
  0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0x87, 0xFE, 0x3E, 0x7F, 0xF9, 0xF7,
  0xFF, 0xCF, 0xBF, 0xFF, 0x7F, 0xC1, 0xFB, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8,
  0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x87, 0xE0,
  0x3F, 0x0F, 0xE0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x01, 0xF1, 0xFF,
  0x83, 0xE7, 0xFF, 0x87, 0xDF, 0xFF, 0x8F, 0xBF, 0xFF, 0x1F, 0xF0, 0x3F,
  0x3F, 0xC0, 0x3E, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01,
  0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0x9F, 0xE0, 0x3F, 0x3F, 0xE0, 0xFE,
  0x7D, 0xFF, 0xF8, 0xF9, 0xFF, 0xE1, 0xF1, 0xFF, 0x83, 0xE1, 0xFE, 0x07,
  0xC0, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0xF0, 0xFF, 0xE3, 0xC7, 0xFF, 0xCF, 0x3F, 0xFF, 0xBC, 0xFC, 0x0F, 0xF7,
  0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F,
  0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF3, 0xF8, 0x7B, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x7F, 0xC7, 0xC0, 0x38, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0xCF, 0xEF, 0xBF, 0xDF, 0x7C,
  0xBF, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x9F, 0x9F, 0x00, 0xCF, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xB0, 0x07, 0xEF, 0x03, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x83,
  0xFF, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3F, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x43, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01,
  0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E,
  0xF8, 0x07, 0xF7, 0xE0, 0x7F, 0xBF, 0x87, 0xFC, 0xFF, 0xFB, 0xE7, 0xFF,
  0xCF, 0x1F, 0xFC, 0x78, 0x7F, 0xC3, 0xC0, 0x70, 0x00, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xDF, 0x00,
  0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0xF8, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x1F, 0x3E, 0x01,
  0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x78, 0x07, 0xCF, 0x80, 0x7B, 0xC0, 0x7C,
  0x7E, 0x03, 0xDE, 0x03, 0xE1, 0xF0, 0x3E, 0xF0, 0x1F, 0x0F, 0x81, 0xF7,
  0x80, 0xF8, 0x7C, 0x0F, 0x3E, 0x07, 0xC3, 0xE0, 0x79, 0xF0, 0x7C, 0x0F,
  0x83, 0xC7, 0x83, 0xE0, 0x7C, 0x3E, 0x3C, 0x1F, 0x03, 0xE1, 0xF1, 0xE0,
  0xF8, 0x1F, 0x0F, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x7C, 0x7C, 0x03, 0xE3,
  0xC1, 0xE3, 0xE0, 0x1F, 0x3E, 0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0x78, 0xF8,
  0x07, 0xCF, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x1F, 0x7C, 0x00, 0xF3, 0xC0,
  0x7B, 0xE0, 0x07, 0xDE, 0x03, 0xDF, 0x00, 0x3F, 0xF0, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C,
  0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x3E, 0x1F,
  0x01, 0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xC7,
  0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x04, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x03,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x01, 0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFE, 0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xF8, 0x80, 0x00,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 47, 15, 4, -46 },
  { 43, 17, 17, 24, 4, -46 },
  { 80, 27, 46, 29, 1, -46 },
  { 236, 22, 53, 27, 3, -49 },
  { 382, 37, 47, 43, 3, -46 },
  { 600, 29, 47, 31, 2, -46 },
  { 771, 6, 17, 13, 4, -46 },
  { 784, 14, 56, 19, 3, -46 },
  { 882, 13, 56, 19, 2, -46 },
  { 973, 21, 22, 25, 2, -49 },
  { 1031, 23, 30, 28, 2, -38 },
  { 1118, 9, 15, 14, 2, -7 },
  { 1135, 14, 5, 18, 2, -20 },
  { 1144, 7, 9, 14, 4, -8 },
  { 1152, 22, 46, 24, 1, -46 },
  { 1279, 22, 47, 27, 3, -46 },
  { 1409, 15, 46, 27, 4, -46 },
  { 1496, 22, 46, 27, 2, -46 },
  { 1623, 22, 47, 27, 2, -46 },
  { 1753, 26, 46, 27, 1, -46 },
  { 1903, 22, 47, 27, 3, -46 },
  { 2033, 22, 47, 27, 3, -46 },
  { 2163, 23, 46, 27, 2, -46 },
  { 2296, 23, 47, 27, 2, -46 },
  { 2432, 22, 47, 27, 2, -46 },
  { 2562, 7, 36, 15, 4, -35 },
  { 2594, 9, 43, 15, 2, -35 },
  { 2643, 24, 29, 28, 2, -37 },
  { 2730, 23, 19, 28, 2, -32 },
  { 2785, 24, 29, 28, 2, -37 },
  { 2872, 18, 47, 20, 1, -46 },
  { 2978, 36, 51, 42, 3, -46 },
  { 3208, 29, 46, 29, 0, -46 },
  { 3375, 23, 46, 31, 5, -46 },
  { 3508, 24, 47, 29, 3, -46 },
  { 3649, 25, 46, 33, 5, -46 },
  { 3793, 18, 46, 26, 5, -46 },
  { 3897, 18, 46, 24, 5, -46 },
  { 4001, 28, 47, 35, 3, -46 },
  { 4166, 25, 46, 34, 5, -46 },
  { 4310, 14, 46, 18, 2, -46 },
  { 4391, 13, 58, 14, -3, -46 },
  { 4486, 24, 46, 29, 5, -46 },
  { 4624, 18, 46, 24, 5, -46 },
  { 4728, 36, 46, 46, 5, -46 },
  { 4935, 27, 46, 36, 5, -46 },
  { 5091, 29, 47, 35, 3, -46 },
  { 5262, 21, 46, 28, 5, -46 },
  { 5383, 29, 57, 35, 3, -46 },
  { 5590, 24, 46, 30, 5, -46 },
  { 5728, 22, 47, 26, 2, -46 },
  { 5858, 23, 46, 24, 1, -46 },
  { 5991, 25, 47, 33, 4, -46 },
  { 6138, 28, 46, 28, 0, -46 },
  { 6299, 46, 46, 46, 0, -46 },
  { 6564, 25, 46, 26, 0, -46 },
  { 6708, 25, 46, 25, 0, -46 },
  { 6852, 20, 46, 23, 2, -46 },
  { 6967, 13, 56, 20, 5, -46 },
  { 7058, 22, 46, 24, 1, -46 },
  { 7185, 13, 56, 20, 2, -46 },
  { 7276, 26, 25, 28, 1, -46 },
  { 7358, 28, 4, 28, 0, 5 },
  { 7372, 11, 10, 17, 3, -49 },
  { 7386, 21, 36, 27, 2, -35 },
  { 7481, 23, 50, 30, 4, -49 },
  { 7625, 18, 36, 22, 3, -35 },
  { 7706, 22, 50, 30, 3, -49 },
  { 7844, 21, 36, 27, 3, -35 },
  { 7939, 17, 49, 16, 1, -49 },
  { 8044, 22, 50, 30, 3, -35 },
  { 8182, 21, 49, 29, 4, -49 },
  { 8311, 6, 47, 14, 4, -47 },
  { 8347, 11, 62, 14, -1, -47 },
  { 8433, 21, 49, 26, 4, -49 },
  { 8562, 5, 49, 13, 4, -49 },
  { 8593, 36, 35, 44, 4, -35 },
  { 8751, 21, 35, 29, 4, -35 },
  { 8843, 23, 36, 28, 3, -35 },
  { 8947, 23, 50, 30, 4, -35 },
  { 9091, 22, 50, 30, 3, -35 },
  { 9229, 15, 35, 19, 4, -35 },
  { 9295, 18, 36, 22, 2, -35 },
  { 9376, 15, 43, 17, 1, -42 },
  { 9457, 21, 35, 29, 4, -34 },
  { 9549, 23, 34, 24, 0, -34 },
  { 9647, 37, 34, 39, 1, -34 },
  { 9805, 22, 34, 24, 1, -34 },
  { 9899, 23, 49, 24, 0, -34 },
  { 10040, 16, 34, 19, 2, -34 },
  { 10108, 17, 56, 23, 3, -46 },
  { 10227, 4, 64, 26, 11, -49 },
  { 10259, 17, 56, 23, 3, -46 },
  { 10378, 24, 9, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Regular64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR64PT7B_H_
