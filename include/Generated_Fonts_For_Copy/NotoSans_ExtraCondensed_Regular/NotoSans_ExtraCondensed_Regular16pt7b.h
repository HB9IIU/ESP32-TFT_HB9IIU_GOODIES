#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xAA, 0x3C, 0x99, 0x99, 0x34, 0x48, 0x93, 0xF2, 0x45, 0x3F,
  0xFF, 0x48, 0x91, 0x20, 0x23, 0xEB, 0x4A, 0x70, 0xC5, 0x2D, 0x7C, 0x42,
  0x00, 0x40, 0x53, 0x29, 0x14, 0x8A, 0x85, 0x5A, 0xAA, 0xA9, 0x14, 0x8A,
  0x49, 0xA4, 0x60, 0x10, 0x38, 0x68, 0x68, 0x28, 0x30, 0x70, 0x5A, 0x4A,
  0xC4, 0x4E, 0x7B, 0xF0, 0x2D, 0x69, 0x24, 0x92, 0x64, 0xC8, 0xC4, 0x22,
  0x33, 0x11, 0x13, 0x32, 0x24, 0xC0, 0x25, 0x7E, 0xCD, 0x00, 0x10, 0x41,
  0x3F, 0x10, 0x41, 0x00, 0xEA, 0xF0, 0xF0, 0x0C, 0x21, 0x84, 0x10, 0xC2,
  0x08, 0x41, 0x0C, 0x00, 0x23, 0xA7, 0x18, 0xC6, 0x31, 0x8C, 0x76, 0xE0,
  0x37, 0xB3, 0x33, 0x33, 0x33, 0x30, 0x67, 0x86, 0x11, 0x88, 0x44, 0x62,
  0x21, 0xF0, 0x67, 0x86, 0x11, 0x99, 0xC3, 0x08, 0x67, 0xE0, 0x08, 0x10,
  0x60, 0xC2, 0x85, 0x12, 0x24, 0xFF, 0xFC, 0x20, 0x40, 0xFC, 0x21, 0x0F,
  0x0C, 0x21, 0x0C, 0xFC, 0x13, 0xF1, 0x08, 0x7A, 0x71, 0x8C, 0x76, 0xE0,
  0xFC, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x30, 0x86, 0x00, 0x27, 0xE3, 0x19,
  0xB9, 0xD3, 0x8C, 0x63, 0xE0, 0x27, 0xA7, 0x18, 0xC7, 0x6D, 0x08, 0xC5,
  0xC0, 0xB0, 0x03, 0xC0, 0xB0, 0x03, 0xA8, 0x04, 0x67, 0x30, 0x30, 0x30,
  0x40, 0xFC, 0x00, 0x00, 0xFC, 0xC1, 0xC1, 0xC1, 0x19, 0x88, 0x00, 0x27,
  0x86, 0x31, 0x88, 0x84, 0x20, 0x18, 0xC0, 0x08, 0x1B, 0x10, 0x58, 0x29,
  0xDD, 0xA6, 0x93, 0x49, 0xA5, 0x4D, 0xA0, 0x08, 0x03, 0xC0, 0x18, 0x50,
  0xA1, 0x42, 0xCC, 0x9F, 0x22, 0x47, 0x8F, 0x08, 0xFB, 0x3C, 0xF3, 0xFB,
  0xEC, 0xF1, 0xC7, 0x3F, 0x80, 0x19, 0xF4, 0x30, 0x82, 0x08, 0x20, 0x83,
  0x06, 0x0E, 0xFB, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x2F, 0x00, 0xFE,
  0x31, 0x8F, 0xFF, 0x18, 0xC6, 0x3E, 0xFE, 0x31, 0x8C, 0x7F, 0x18, 0xC6,
  0x30, 0x18, 0xFD, 0x06, 0x08, 0x10, 0x23, 0xC1, 0x83, 0x85, 0x89, 0xF0,
  0xC7, 0x1C, 0x71, 0xFF, 0xFC, 0x71, 0xC7, 0x1C, 0x40, 0xE9, 0x24, 0x92,
  0x4B, 0x80, 0x24, 0x92, 0x49, 0x24, 0x93, 0xC0, 0xCF, 0x2D, 0x3C, 0xE3,
  0xCD, 0x36, 0xCB, 0x3C, 0xC0, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3E,
  0xC1, 0xF0, 0xE8, 0x74, 0x5A, 0x2C, 0x96, 0x5B, 0x29, 0x9C, 0xC6, 0x62,
  0x20, 0xC3, 0xC6, 0x8D, 0x19, 0x32, 0x66, 0xC5, 0x8F, 0x0E, 0x18, 0x10,
  0xFB, 0x14, 0x38, 0x70, 0x60, 0xC1, 0x87, 0x8D, 0x13, 0xC0, 0xFB, 0x2C,
  0xF3, 0xCB, 0xEE, 0x30, 0xC3, 0x0C, 0x00, 0x10, 0xFB, 0x14, 0x38, 0x70,
  0x60, 0xC1, 0x87, 0x8D, 0x13, 0xC0, 0x81, 0x81, 0x80, 0xFB, 0x2C, 0xF3,
  0xCB, 0xED, 0x36, 0xCB, 0x2C, 0xC0, 0x27, 0xE1, 0x08, 0x70, 0xC3, 0x08,
  0x67, 0xE0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0xC7, 0x37, 0x80, 0xC7, 0x8D, 0x12, 0x26,
  0x4D, 0x8A, 0x14, 0x28, 0x70, 0x40, 0xC6, 0x38, 0xC5, 0x18, 0xA5, 0x34,
  0xA4, 0xD6, 0x8A, 0x51, 0x4A, 0x31, 0xC6, 0x30, 0xC6, 0x00, 0xCD, 0x22,
  0x8E, 0x30, 0xC3, 0x8A, 0x49, 0x3C, 0x40, 0xC5, 0x34, 0x9A, 0x38, 0xC3,
  0x0C, 0x30, 0xC3, 0x00, 0xF8, 0x46, 0x23, 0x10, 0x8C, 0x42, 0x3E, 0xFF,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xF0, 0xC1, 0x06, 0x08, 0x20, 0xC1,
  0x04, 0x08, 0x20, 0xC0, 0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0,
  0x10, 0x50, 0xA2, 0x24, 0x58, 0xC0, 0xFE, 0xCC, 0x74, 0x86, 0x3F, 0xCE,
  0x73, 0xE8, 0x82, 0x08, 0x2C, 0xDB, 0x38, 0xE3, 0x8E, 0x3C, 0xAE, 0x7D,
  0x88, 0x88, 0x8C, 0x70, 0x08, 0x42, 0xDD, 0xC6, 0x31, 0x8C, 0x72, 0xF0,
  0x66, 0xA3, 0x1F, 0xC2, 0x19, 0x78, 0x36, 0x47, 0xF4, 0x44, 0x44, 0x44,
  0x6E, 0xE3, 0x18, 0xC6, 0x39, 0x78, 0x43, 0x3F, 0x00, 0x84, 0x21, 0x6D,
  0xE6, 0x31, 0x8C, 0x63, 0x10, 0xDF, 0xF0, 0x51, 0x55, 0x55, 0x57, 0x84,
  0x21, 0x19, 0x4A, 0x9C, 0xD4, 0xA7, 0x10, 0xFF, 0xF0, 0xB3, 0x6E, 0xF2,
  0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0xB6, 0xF3, 0x18, 0xC6,
  0x31, 0x88, 0x76, 0xE3, 0x18, 0xC6, 0x39, 0x70, 0xB3, 0x6C, 0xE3, 0x8E,
  0x38, 0xF2, 0xBA, 0x08, 0x20, 0x80, 0x6E, 0xE3, 0x18, 0xC6, 0x39, 0x78,
  0x42, 0x10, 0x80, 0xBF, 0xC8, 0x88, 0x88, 0x80, 0x69, 0x88, 0xE3, 0x1B,
  0xE0, 0x44, 0x7F, 0x44, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xC6, 0x3B,
  0x78, 0x87, 0x34, 0x92, 0x49, 0xE3, 0x0C, 0x30, 0x8C, 0xF3, 0x24, 0xC9,
  0x72, 0x55, 0x95, 0xC7, 0x30, 0xCC, 0x33, 0x00, 0xCD, 0x27, 0x8C, 0x30,
  0xC7, 0x92, 0xCC, 0x87, 0x34, 0x92, 0x49, 0xE3, 0x0C, 0x30, 0xC2, 0x18,
  0xC0, 0x73, 0x84, 0x62, 0x31, 0x08, 0xF8, 0x36, 0x66, 0x64, 0x84, 0x66,
  0x66, 0x31, 0xFF, 0xFF, 0xC4, 0x66, 0x66, 0x16, 0x66, 0x64, 0xC8, 0x67,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 7, 11, 7, 0, -11 },
  { 16, 5, 13, 7, 1, -12 },
  { 25, 9, 12, 11, 1, -12 },
  { 39, 8, 12, 8, 0, -12 },
  { 51, 1, 4, 3, 1, -11 },
  { 52, 3, 15, 5, 1, -12 },
  { 58, 4, 15, 5, 0, -12 },
  { 66, 5, 5, 6, 1, -12 },
  { 70, 6, 7, 7, 0, -9 },
  { 76, 2, 4, 4, 1, -2 },
  { 77, 4, 1, 4, 0, -5 },
  { 78, 2, 2, 4, 1, -2 },
  { 79, 6, 11, 6, 0, -11 },
  { 88, 5, 12, 7, 1, -12 },
  { 96, 4, 11, 7, 1, -11 },
  { 102, 5, 12, 7, 1, -12 },
  { 110, 5, 12, 7, 1, -12 },
  { 118, 7, 12, 7, 0, -12 },
  { 129, 5, 11, 7, 1, -11 },
  { 136, 5, 12, 7, 1, -12 },
  { 144, 6, 11, 7, 0, -11 },
  { 153, 5, 12, 7, 1, -12 },
  { 161, 5, 12, 7, 1, -12 },
  { 169, 2, 9, 4, 1, -9 },
  { 172, 2, 11, 4, 1, -9 },
  { 175, 6, 7, 7, 0, -9 },
  { 181, 6, 5, 7, 0, -8 },
  { 185, 6, 7, 7, 0, -9 },
  { 191, 5, 12, 5, 0, -12 },
  { 199, 9, 13, 10, 1, -12 },
  { 214, 7, 11, 7, 0, -11 },
  { 224, 6, 11, 8, 1, -11 },
  { 233, 6, 12, 7, 1, -12 },
  { 242, 6, 11, 8, 1, -11 },
  { 251, 5, 11, 6, 1, -11 },
  { 258, 5, 11, 6, 1, -11 },
  { 265, 7, 12, 9, 1, -12 },
  { 276, 6, 11, 9, 1, -11 },
  { 285, 3, 11, 5, 1, -11 },
  { 290, 3, 14, 4, -1, -11 },
  { 296, 6, 11, 7, 1, -11 },
  { 305, 5, 11, 6, 1, -11 },
  { 312, 9, 11, 11, 1, -11 },
  { 325, 7, 11, 9, 1, -11 },
  { 335, 7, 12, 9, 1, -12 },
  { 346, 6, 11, 7, 1, -11 },
  { 355, 7, 15, 9, 1, -12 },
  { 369, 6, 11, 7, 1, -11 },
  { 378, 5, 12, 7, 1, -12 },
  { 386, 6, 11, 6, 0, -11 },
  { 395, 6, 11, 8, 1, -11 },
  { 404, 7, 11, 7, 0, -11 },
  { 414, 11, 11, 12, 0, -11 },
  { 430, 6, 11, 6, 0, -11 },
  { 439, 6, 11, 6, 0, -11 },
  { 448, 5, 11, 6, 0, -11 },
  { 455, 4, 15, 5, 1, -12 },
  { 463, 6, 11, 6, 0, -11 },
  { 472, 4, 15, 5, 0, -12 },
  { 480, 7, 6, 7, 0, -11 },
  { 486, 7, 1, 7, 0, 1 },
  { 487, 3, 2, 4, 1, -12 },
  { 488, 5, 9, 7, 1, -9 },
  { 494, 6, 12, 7, 1, -12 },
  { 503, 4, 9, 6, 1, -9 },
  { 508, 5, 12, 7, 1, -12 },
  { 516, 5, 9, 7, 1, -9 },
  { 522, 4, 12, 4, 0, -12 },
  { 528, 5, 13, 7, 1, -9 },
  { 537, 5, 12, 7, 1, -12 },
  { 545, 1, 12, 3, 1, -12 },
  { 547, 2, 16, 3, 0, -12 },
  { 551, 5, 12, 6, 1, -12 },
  { 559, 1, 12, 3, 1, -12 },
  { 561, 9, 9, 11, 1, -9 },
  { 572, 5, 9, 7, 1, -9 },
  { 578, 5, 9, 7, 1, -9 },
  { 584, 6, 13, 7, 1, -9 },
  { 594, 5, 13, 7, 1, -9 },
  { 603, 4, 9, 5, 1, -9 },
  { 608, 4, 9, 5, 1, -9 },
  { 613, 4, 11, 4, 0, -11 },
  { 619, 5, 9, 7, 1, -9 },
  { 625, 6, 9, 6, 0, -9 },
  { 632, 10, 9, 10, 0, -9 },
  { 644, 6, 9, 6, 0, -9 },
  { 651, 6, 13, 6, 0, -9 },
  { 661, 5, 9, 5, 0, -9 },
  { 667, 4, 14, 6, 1, -11 },
  { 674, 1, 16, 6, 3, -12 },
  { 676, 4, 14, 6, 1, -11 },
  { 683, 6, 2, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Regular16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR16PT7B_H_
