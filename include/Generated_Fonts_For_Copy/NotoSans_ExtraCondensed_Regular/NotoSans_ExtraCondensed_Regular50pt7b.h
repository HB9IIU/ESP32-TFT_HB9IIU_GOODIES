#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC0, 0x00, 0x00, 0x07,
  0xBE, 0xFF, 0xFF, 0x9E, 0xF8, 0xFF, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0x83, 0xDC, 0x1C, 0xE0, 0xE7,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x83,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x78, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFC, 0x79, 0xC3, 0x3C, 0x70, 0x0F,
  0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xE7,
  0x00, 0x7D, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0x3E, 0x01, 0xC7, 0x80, 0x70, 0xE0,
  0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x71, 0xE8, 0x1C, 0x7B, 0xC7,
  0x7C, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x1C, 0x01, 0xFC, 0x00, 0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0xE3, 0x80, 0x70,
  0x07, 0x0E, 0x03, 0x80, 0x78, 0x70, 0x3C, 0x03, 0xC3, 0x81, 0xC0, 0x1C,
  0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0xF0, 0x07, 0x07, 0x87, 0x00, 0x38, 0x3C,
  0x38, 0x01, 0xC1, 0xE3, 0xC0, 0x0E, 0x0F, 0x1C, 0x00, 0x70, 0x78, 0xE0,
  0x03, 0x83, 0x8E, 0x1E, 0x1E, 0x1C, 0x71, 0xFC, 0x70, 0xE7, 0x9F, 0xE3,
  0x87, 0x38, 0xE7, 0x9E, 0x71, 0xCF, 0x1C, 0x7F, 0x9E, 0x70, 0xF3, 0xF8,
  0xE3, 0x87, 0x8F, 0x87, 0x1C, 0x1C, 0x00, 0x78, 0xE0, 0xE0, 0x03, 0x87,
  0x07, 0x00, 0x1C, 0x38, 0x38, 0x01, 0xE1, 0xC1, 0xC0, 0x0E, 0x0E, 0x0E,
  0x00, 0x70, 0x70, 0x70, 0x07, 0x83, 0x83, 0x80, 0x38, 0x1C, 0x1C, 0x01,
  0xC0, 0xE1, 0xE0, 0x1E, 0x07, 0x8F, 0x00, 0xE0, 0x1C, 0x70, 0x07, 0x00,
  0xFF, 0x80, 0x70, 0x03, 0xF8, 0x03, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xE7,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xE3, 0xE7, 0x87, 0x87, 0x8F, 0x8F,
  0x1E, 0x0F, 0x1E, 0x3C, 0x1F, 0x3C, 0x78, 0x1E, 0xF9, 0xF0, 0x1F, 0xE3,
  0xE0, 0x3F, 0xC7, 0xC0, 0x3F, 0x07, 0x80, 0x7E, 0x0F, 0x00, 0xFC, 0x1E,
  0x01, 0xF8, 0x3E, 0x07, 0xF8, 0x7F, 0x3F, 0xF8, 0x7F, 0xFC, 0xF0, 0x7F,
  0xF1, 0xF0, 0x7F, 0x81, 0xF0, 0x10, 0x00, 0x00, 0xFF, 0xFD, 0xEF, 0x7B,
  0xDE, 0xF3, 0x9C, 0xE7, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE3, 0x8E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xF0, 0x1E, 0x78, 0x3C, 0x7C, 0x3C,
  0x3C, 0x18, 0x38, 0x08, 0x20, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x3C, 0x7C, 0xF1, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0xBC, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC3, 0xE1, 0xE1, 0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0xBC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE,
  0x01, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xF0, 0x3C, 0x78, 0x3C,
  0x3F, 0x7E, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x08, 0x00, 0x00,
  0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x3E, 0xF7, 0xCF, 0xF8,
  0xF7, 0x0F, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x1F,
  0xFF, 0xC7, 0x03, 0xF1, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFE, 0x3F, 0xFF, 0x9F, 0xDF, 0xC7, 0x01, 0xF2, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3D, 0x00, 0x3E, 0xF0, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF,
  0x0F, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0E,
  0xF0, 0x00, 0xEF, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x38, 0xF0, 0x03,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01,
  0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7D, 0x80, 0x7E, 0xF0, 0x7E, 0x7F, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFE, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xE1, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x81, 0x03,
  0xC7, 0xF1, 0xE7, 0xFC, 0xF7, 0xFE, 0x7F, 0x0F, 0xBF, 0x03, 0xDF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3C, 0xF0, 0x3E,
  0x7C, 0x1E, 0x3F, 0x3F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x1E, 0x03, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x3C, 0x7C, 0x0F, 0x0F, 0x87, 0xC1, 0xF3, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0x3E, 0x1F, 0x07, 0xC7,
  0x80, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0x7C, 0x1F,
  0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xE3, 0xC0, 0xFB, 0xE0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBC, 0x0F,
  0xDF, 0x07, 0xE7, 0xFF, 0xF3, 0xFF, 0x78, 0xFF, 0x3C, 0x1E, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x61, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x40, 0x00, 0x77, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xDE, 0x38, 0xF9,
  0xF3, 0xE7, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x9E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8F,
  0x1C, 0x78, 0xE1, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1F, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x40, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0E, 0x3C, 0x0F, 0xF0, 0xE3, 0x81, 0xFF, 0x0F, 0x78, 0x3F, 0xF0,
  0xF7, 0x87, 0x87, 0x07, 0x70, 0x78, 0x70, 0x77, 0x07, 0x07, 0x07, 0x70,
  0xF0, 0x70, 0x77, 0x0F, 0x0F, 0x07, 0xF0, 0xF0, 0xF0, 0x7F, 0x0E, 0x0F,
  0x07, 0xF0, 0xE0, 0xF0, 0x7F, 0x0E, 0x0F, 0x07, 0xF0, 0xE0, 0xF0, 0x7F,
  0x0E, 0x0F, 0x07, 0xF0, 0xF0, 0xF0, 0xF7, 0x0F, 0x0F, 0x0E, 0x70, 0x71,
  0xB1, 0xE7, 0x07, 0xFB, 0xFC, 0x78, 0x3F, 0x9F, 0xC7, 0x81, 0xF1, 0xF8,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x07, 0xC0, 0x38,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3C,
  0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x87, 0x80,
  0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF0, 0x00,
  0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xF0, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x3F, 0x3C, 0x03, 0xEF, 0x00, 0xFB, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F,
  0xBC, 0x03, 0xCF, 0x01, 0xF3, 0xC3, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xF8, 0x0C, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0x0F, 0xF3, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x80, 0xFF, 0xC0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x03, 0xF1, 0xE0, 0x3F, 0x3C, 0x03,
  0xE7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x81, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x03, 0x83, 0xF0, 0x01, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFB, 0xC0,
  0x3F, 0xF7, 0x80, 0x7F, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x01,
  0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0xF0, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0xA3, 0xEF, 0xFB, 0xFC, 0xFE, 0x1E, 0x00,
  0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1,
  0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x1F, 0x03,
  0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07,
  0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xDE, 0x01, 0xF3, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x3E, 0x3C,
  0x07, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1F, 0x78,
  0x01, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xEE, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0xFF, 0xEF, 0x00, 0x0F,
  0xFF, 0x70, 0x00, 0xEF, 0xF7, 0x80, 0x1E, 0xFF, 0x78, 0x01, 0xEF, 0xF7,
  0x80, 0x1C, 0xFF, 0x38, 0x01, 0xCF, 0xF3, 0xC0, 0x3C, 0xFF, 0x3C, 0x03,
  0xCF, 0xF1, 0xC0, 0x38, 0xFF, 0x1E, 0x07, 0x8F, 0xF1, 0xE0, 0x78, 0xFF,
  0x1E, 0x07, 0x0F, 0xF0, 0xE0, 0x70, 0xFF, 0x0F, 0x0F, 0x0F, 0xF0, 0xF0,
  0xF0, 0xFF, 0x07, 0x0E, 0x0F, 0xF0, 0x79, 0xE0, 0xFF, 0x07, 0x9E, 0x0F,
  0xF0, 0x79, 0xE0, 0xFF, 0x03, 0x9C, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80,
  0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFD, 0xE0, 0x0F, 0xEF, 0x00, 0x7F, 0xBC,
  0x03, 0xFD, 0xE0, 0x1F, 0xEF, 0x80, 0xFF, 0x3C, 0x07, 0xF9, 0xE0, 0x3F,
  0xC7, 0x81, 0xFE, 0x3C, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3E,
  0x1F, 0xE0, 0xF0, 0xFF, 0x07, 0x87, 0xF8, 0x1E, 0x3F, 0xC0, 0xF1, 0xFE,
  0x07, 0xCF, 0xF0, 0x1E, 0x7F, 0x80, 0xF3, 0xFC, 0x03, 0xDF, 0xE0, 0x1E,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xF8, 0x1F,
  0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x7C,
  0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF,
  0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x79, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x0F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x07, 0xE7, 0x80, 0xFB, 0xC0, 0x7D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x1F, 0x3F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFE, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x1E, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xC0, 0x01,
  0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78,
  0x00, 0x3E, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0,
  0x07, 0xC7, 0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0xE7,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x7E, 0x3C,
  0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00,
  0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C,
  0xF0, 0x3E, 0x3C, 0x7F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03,
  0xC3, 0xC0, 0xF8, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0x07, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x63, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7D, 0x80, 0x7E, 0xFE, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F,
  0xFE, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xE7,
  0xE0, 0x3E, 0x3F, 0x9F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE,
  0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0x00, 0x1F, 0x78, 0x00, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x80, 0x1E,
  0x78, 0x01, 0xF8, 0x01, 0xE7, 0x80, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8,
  0x03, 0xE3, 0xC0, 0x1F, 0x80, 0x3C, 0x3C, 0x03, 0xFC, 0x03, 0xC3, 0xC0,
  0x3F, 0xC0, 0x3C, 0x3C, 0x03, 0x9C, 0x07, 0xC1, 0xE0, 0x39, 0xC0, 0x7C,
  0x1E, 0x03, 0x9C, 0x07, 0x81, 0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x07, 0x9E,
  0x07, 0x81, 0xE0, 0x79, 0xE0, 0xF8, 0x0F, 0x07, 0x0E, 0x0F, 0x00, 0xF0,
  0x70, 0xE0, 0xF0, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0xF0, 0xF0,
  0x0F, 0x0F, 0x0F, 0x1F, 0x00, 0x78, 0xE0, 0x71, 0xE0, 0x07, 0x8E, 0x07,
  0x1E, 0x00, 0x79, 0xE0, 0x79, 0xE0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x79,
  0xE0, 0x79, 0xE0, 0x03, 0xDC, 0x03, 0xBC, 0x00, 0x3D, 0xC0, 0x3B, 0xC0,
  0x03, 0xDC, 0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x7C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C, 0x1E, 0x07,
  0xC1, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0x78,
  0xF0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0,
  0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x78,
  0x03, 0xE7, 0x80, 0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x3E, 0x10, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x7F, 0x7F, 0xEF, 0x7F, 0xCF, 0x3F, 0x8F, 0x04, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC7, 0xE0,
  0xF3, 0xFE, 0x3D, 0xFF, 0xCF, 0xF1, 0xF3, 0xF0, 0x3E, 0xFC, 0x07, 0xBE,
  0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0xFC, 0x07, 0xBF,
  0x03, 0xEF, 0xE1, 0xF3, 0xDF, 0xFC, 0xF3, 0xFE, 0x3C, 0x7F, 0x00, 0x02,
  0x00, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xC6, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xC3, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F,
  0x80, 0x30, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x1F, 0x8F, 0x1F, 0xF3, 0xC7, 0xFE, 0xF3, 0xF3, 0xFC,
  0xF0, 0x3F, 0x7C, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x7D,
  0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03, 0xF3, 0xE1, 0xFC, 0xFF, 0xEF, 0x1F,
  0xF3, 0xC3, 0xF8, 0x70, 0x10, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xC7, 0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x0F, 0x70,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x04, 0x7E, 0x0E, 0x1F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0x08, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xF2, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0xE3, 0xC7, 0xFC, 0xF1, 0xFF, 0xBC, 0xFC, 0xFF, 0x7C, 0x0F,
  0xDF, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07,
  0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xF8, 0x7F, 0x3F, 0xFB, 0xC7, 0xFC, 0xF0,
  0xFE, 0x3C, 0x04, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE6, 0x01, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x3F, 0x0F, 0x3F, 0xE7, 0xBF, 0xF3, 0xFC,
  0xFD, 0xF8, 0x1E, 0xFC, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3C, 0x77, 0xBF, 0xFF, 0x38, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x00, 0x07, 0x07, 0x83, 0xE1, 0xF0, 0xF0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF7, 0xFB, 0xF9, 0xFC, 0xF8, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xEF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF,
  0xC0, 0xFF, 0xE0, 0x7E, 0xF0, 0x3F, 0x3C, 0x1F, 0x1E, 0x0F, 0x07, 0x87,
  0x83, 0xC3, 0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0x3F, 0x8F, 0x3F, 0xC7, 0xFC, 0xF7, 0xFE, 0xFF,
  0xEF, 0xE3, 0xEE, 0x7E, 0xFC, 0x1F, 0xC1, 0xEF, 0x80, 0xF8, 0x1F, 0xF8,
  0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xF0, 0xF1, 0xF8, 0x79, 0xFF, 0x3D, 0xFF, 0x9F, 0xE7, 0xEF, 0xC0, 0xF7,
  0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0x7C, 0x3C, 0x0F, 0x9F, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0x9F, 0x01,
  0xE3, 0xC0, 0xF8, 0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x01, 0x00, 0xF1, 0xFC, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFC, 0x7C, 0xFC,
  0x0F, 0xBF, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xBF, 0x01, 0xEF, 0xC0, 0xFB, 0xF8, 0x7C, 0xF7, 0xFF, 0x3C, 0xFF,
  0x8F, 0x1F, 0xC3, 0xC0, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE3, 0xC7, 0xFC, 0xF1, 0xFF,
  0xBC, 0xFC, 0xFF, 0x3C, 0x0F, 0xDF, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xF8, 0x7F,
  0x3F, 0xFB, 0xC7, 0xFC, 0xF0, 0xFE, 0x3C, 0x04, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0xE1, 0xFF,
  0x3F, 0xF7, 0xEF, 0x7E, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0xDF, 0xFF, 0xF0, 0xEF, 0x01, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xFC, 0x3F, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x08,
  0x00, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x47, 0xF8, 0xFF, 0x0F, 0xE0, 0x20,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFD, 0xE0,
  0x7E, 0xF8, 0xFF, 0x7F, 0xF7, 0x9F, 0xF3, 0xC7, 0xF1, 0xE0, 0x40, 0x00,
  0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x1E, 0x1E, 0x03, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0x70,
  0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1E, 0xE0, 0x07, 0xB8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3D, 0xE0, 0x1F, 0x00, 0xF7, 0x80, 0xFC, 0x07,
  0x9E, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x78, 0xF0, 0x3F, 0x01, 0xE3,
  0xC0, 0xFE, 0x07, 0x0F, 0x07, 0xB8, 0x3C, 0x3C, 0x1E, 0xE0, 0xF0, 0xF0,
  0x73, 0x83, 0xC1, 0xE1, 0xCE, 0x0F, 0x07, 0x87, 0x3C, 0x78, 0x1E, 0x3C,
  0xF1, 0xE0, 0x78, 0xF1, 0xC7, 0x80, 0xE3, 0x87, 0x1E, 0x03, 0xCE, 0x1C,
  0x70, 0x0F, 0x38, 0x7B, 0xC0, 0x3D, 0xE1, 0xEF, 0x00, 0xF7, 0x83, 0xBC,
  0x01, 0xDC, 0x0E, 0xF0, 0x07, 0x70, 0x3B, 0x80, 0x1F, 0xC0, 0xEE, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xBC, 0x07, 0x9E,
  0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0,
  0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x03,
  0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x0F,
  0x7C, 0x07, 0xBC, 0x03, 0xE0, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0x7B, 0xC0,
  0x1E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x7F, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x27, 0xF8, 0x05, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x20, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 36, 12, 3, -36 },
  { 28, 13, 13, 19, 3, -36 },
  { 50, 21, 36, 23, 1, -36 },
  { 145, 18, 41, 21, 2, -38 },
  { 238, 29, 36, 33, 2, -36 },
  { 369, 23, 37, 24, 1, -36 },
  { 476, 5, 13, 10, 3, -36 },
  { 485, 11, 44, 15, 2, -36 },
  { 546, 11, 44, 15, 1, -36 },
  { 607, 16, 17, 20, 2, -38 },
  { 641, 19, 23, 22, 1, -29 },
  { 696, 7, 13, 11, 2, -6 },
  { 708, 11, 5, 14, 1, -16 },
  { 715, 5, 6, 11, 3, -6 },
  { 719, 17, 36, 19, 1, -36 },
  { 796, 17, 37, 21, 2, -36 },
  { 875, 12, 36, 21, 3, -36 },
  { 929, 17, 36, 21, 2, -36 },
  { 1006, 17, 37, 21, 2, -36 },
  { 1085, 20, 36, 21, 1, -36 },
  { 1175, 17, 37, 21, 2, -36 },
  { 1254, 17, 37, 21, 2, -36 },
  { 1333, 18, 36, 21, 2, -36 },
  { 1414, 18, 37, 21, 2, -36 },
  { 1498, 17, 37, 21, 2, -36 },
  { 1577, 5, 27, 11, 3, -27 },
  { 1594, 7, 34, 11, 2, -27 },
  { 1624, 19, 22, 22, 1, -29 },
  { 1677, 19, 14, 22, 1, -25 },
  { 1711, 19, 22, 22, 1, -29 },
  { 1764, 14, 36, 16, 1, -36 },
  { 1827, 28, 40, 33, 2, -36 },
  { 1967, 23, 36, 23, 0, -36 },
  { 2071, 18, 36, 24, 4, -36 },
  { 2152, 19, 37, 22, 2, -36 },
  { 2240, 19, 36, 26, 4, -36 },
  { 2326, 14, 36, 20, 4, -36 },
  { 2389, 14, 36, 19, 4, -36 },
  { 2452, 23, 37, 27, 2, -36 },
  { 2559, 19, 36, 27, 4, -36 },
  { 2645, 10, 36, 14, 2, -36 },
  { 2690, 10, 46, 11, -2, -36 },
  { 2748, 19, 36, 22, 4, -36 },
  { 2834, 14, 36, 19, 4, -36 },
  { 2897, 28, 36, 36, 4, -36 },
  { 3023, 21, 36, 28, 4, -36 },
  { 3118, 23, 37, 28, 2, -36 },
  { 3225, 17, 36, 22, 4, -36 },
  { 3302, 23, 45, 28, 2, -36 },
  { 3432, 18, 36, 23, 4, -36 },
  { 3513, 17, 37, 21, 2, -36 },
  { 3592, 19, 36, 19, 0, -36 },
  { 3678, 20, 37, 26, 3, -36 },
  { 3771, 22, 36, 22, 0, -36 },
  { 3870, 36, 36, 36, 0, -36 },
  { 4032, 20, 36, 20, 0, -36 },
  { 4122, 20, 36, 20, 0, -36 },
  { 4212, 16, 36, 18, 1, -36 },
  { 4284, 10, 44, 16, 4, -36 },
  { 4339, 17, 36, 19, 1, -36 },
  { 4416, 10, 44, 16, 2, -36 },
  { 4471, 20, 19, 22, 1, -36 },
  { 4519, 22, 3, 22, 0, 4 },
  { 4528, 9, 8, 13, 2, -38 },
  { 4537, 16, 28, 21, 2, -27 },
  { 4593, 18, 39, 23, 3, -38 },
  { 4681, 14, 28, 17, 2, -27 },
  { 4730, 18, 39, 23, 2, -38 },
  { 4818, 17, 28, 21, 2, -27 },
  { 4878, 14, 38, 13, 0, -38 },
  { 4945, 18, 39, 23, 2, -27 },
  { 5033, 17, 38, 23, 3, -38 },
  { 5114, 5, 37, 11, 3, -37 },
  { 5138, 9, 49, 11, -1, -37 },
  { 5194, 17, 38, 20, 3, -38 },
  { 5275, 4, 38, 11, 3, -38 },
  { 5294, 28, 27, 34, 3, -27 },
  { 5389, 17, 27, 23, 3, -27 },
  { 5447, 18, 28, 22, 2, -27 },
  { 5510, 18, 39, 23, 3, -27 },
  { 5598, 18, 39, 23, 2, -27 },
  { 5686, 12, 27, 15, 3, -27 },
  { 5727, 13, 28, 17, 2, -27 },
  { 5773, 11, 34, 13, 1, -33 },
  { 5820, 17, 28, 23, 3, -27 },
  { 5880, 18, 27, 19, 0, -27 },
  { 5941, 30, 27, 30, 0, -27 },
  { 6043, 17, 27, 19, 1, -27 },
  { 6101, 18, 39, 19, 0, -27 },
  { 6189, 13, 27, 15, 1, -27 },
  { 6233, 14, 44, 18, 2, -36 },
  { 6310, 4, 50, 20, 8, -38 },
  { 6335, 14, 44, 18, 2, -36 },
  { 6412, 19, 7, 22, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Regular50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR50PT7B_H_
