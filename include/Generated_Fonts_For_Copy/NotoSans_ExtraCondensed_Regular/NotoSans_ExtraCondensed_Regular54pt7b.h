#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0xFF, 0xFD, 0xF7, 0xC0, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0,
  0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x01,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x03, 0x83,
  0xC0, 0x07, 0x07, 0x83, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x81, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80,
  0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x78, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x81,
  0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C,
  0x00, 0x70, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0xE7, 0xCF, 0x9C,
  0x11, 0xE3, 0x80, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38,
  0x07, 0x87, 0x00, 0x78, 0xE0, 0x0F, 0x9C, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xEF,
  0xC0, 0x1C, 0xF8, 0x03, 0x8F, 0x80, 0x70, 0xF0, 0x0E, 0x1E, 0x01, 0xC3,
  0xC0, 0x38, 0x78, 0x07, 0x0F, 0x80, 0xE3, 0xDC, 0x1C, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x07, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0x0F, 0x00, 0x79, 0xE0,
  0x0E, 0x00, 0x78, 0xF0, 0x1E, 0x00, 0x70, 0xF0, 0x1E, 0x00, 0x70, 0x70,
  0x1C, 0x00, 0xF0, 0x70, 0x3C, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x38, 0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78,
  0x70, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x78,
  0xE0, 0xE0, 0xF0, 0x71, 0xE3, 0xF8, 0x70, 0x71, 0xC7, 0xFC, 0x70, 0xF1,
  0xC7, 0xFC, 0x78, 0xF3, 0xCF, 0x1E, 0x3D, 0xE3, 0x8E, 0x1E, 0x3F, 0xE7,
  0x8E, 0x0E, 0x1F, 0xC7, 0x9E, 0x0E, 0x0F, 0x87, 0x1E, 0x0F, 0x00, 0x0F,
  0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x0E, 0x1E, 0x0F, 0x00, 0x1E,
  0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x1C, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x0E, 0x00, 0x38, 0x0E, 0x0E, 0x00, 0x78,
  0x0E, 0x0E, 0x00, 0x78, 0x0F, 0x1E, 0x00, 0x70, 0x0F, 0x1C, 0x00, 0xF0,
  0x07, 0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x0F,
  0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x3E, 0xF8, 0x3C, 0x7C, 0xF8, 0x3C, 0x78, 0x7C, 0x3C, 0xF8, 0x3C,
  0x7C, 0xF8, 0x3E, 0x7C, 0xF0, 0x1F, 0x78, 0xF0, 0x0F, 0xF8, 0xF0, 0x0F,
  0xF8, 0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x03, 0xE0, 0xF8, 0x07,
  0xF0, 0xF8, 0x0F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFE,
  0x7C, 0x3F, 0xFC, 0x3E, 0x1F, 0xF0, 0x3F, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0x38, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x10, 0x70, 0x6F, 0xDC, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x83, 0xFE, 0x10, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x78,
  0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0x7C, 0x1C, 0x1C, 0x01, 0x02, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3C, 0x78, 0xF1, 0xC7,
  0x8F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x81, 0xF1, 0xF0, 0x7C, 0x1F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3D, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x3C,
  0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07,
  0xF0, 0x7F, 0x87, 0xFC, 0x7D, 0xE7, 0xCF, 0xFC, 0xFB, 0xC7, 0xCC, 0x3E,
  0x41, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0x81, 0xF8, 0x60, 0x1F,
  0x08, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0x81, 0xF8, 0xC0, 0x1F, 0x08, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xD0, 0x01, 0xFB, 0x00, 0x7E, 0x7E, 0x3F, 0xCF, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00, 0x39, 0xE0, 0x03,
  0xCF, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x00, 0xF0, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCF,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xC1, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0xA0, 0x07, 0xCC, 0x03, 0xF3, 0xE7, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFC, 0x08, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC7, 0xE0, 0x7B, 0xFF, 0x0F,
  0x7F, 0xF3, 0xFF, 0xFE, 0x7F, 0x07, 0xEF, 0xC0, 0x7D, 0xF8, 0x07, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC,
  0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0xC0, 0xF8, 0xFC, 0x3E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x0F,
  0x8F, 0x83, 0xE0, 0xF8, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x3E, 0x7E, 0x0F, 0x87, 0xE3, 0xE0, 0x7E,
  0x7C, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7D,
  0xF0, 0x1F, 0x3F, 0x8F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00,
  0x02, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83,
  0xE1, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFD, 0xF0, 0x1F, 0xBE,
  0x07, 0xF7, 0xF1, 0xFC, 0x7F, 0xFF, 0x87, 0xFE, 0xF0, 0x7F, 0x9E, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x1D, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x60,
  0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0x3C,
  0xFD, 0xFB, 0xF7, 0xE7, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x7C, 0xF9, 0xE3,
  0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xE7, 0x07, 0xC8, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x1E, 0x03, 0xFE, 0x1E, 0x78, 0x1F, 0xF8, 0x79,
  0xC0, 0xFF, 0xE0, 0xE7, 0x07, 0xC7, 0x83, 0xBC, 0x1E, 0x1E, 0x0E, 0xF0,
  0x70, 0x78, 0x3F, 0xC3, 0xC1, 0xE0, 0xFE, 0x0F, 0x07, 0x83, 0xF8, 0x3C,
  0x1E, 0x0F, 0xE0, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xE0, 0xFE, 0x0E, 0x07,
  0x83, 0xF8, 0x38, 0x1E, 0x0F, 0xE0, 0xE0, 0x78, 0x3B, 0x83, 0xC3, 0xE0,
  0xEE, 0x0F, 0x0F, 0x87, 0xB8, 0x3C, 0x3E, 0x1E, 0xF0, 0xF0, 0xF8, 0x73,
  0xC1, 0xF7, 0x77, 0xCF, 0x07, 0xF9, 0xFE, 0x3C, 0x0F, 0xE3, 0xF0, 0x78,
  0x0E, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x40, 0x03, 0xF0, 0x07, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xF0, 0x3F, 0xCF, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x1F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0x00, 0xFC,
  0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7E, 0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xC0, 0xE1, 0xF8, 0x02, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x20, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x78, 0x07, 0xE3, 0xC0, 0x1F, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xF7, 0x80,
  0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x7C, 0xF0,
  0x07, 0xE7, 0x80, 0x7E, 0x3C, 0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0x3C, 0x1F, 0x80, 0x0C, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0xC0, 0x1F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x7F, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3E,
  0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x0F,
  0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x07,
  0xC0, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3,
  0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xE0, 0x0F, 0x7E, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0x7C, 0x0F, 0x07, 0xC0,
  0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x1F,
  0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xEF, 0xF7, 0x80, 0x03, 0xDF, 0xEF, 0x00,
  0x07, 0xBF, 0xDE, 0x00, 0x0E, 0x7F, 0x9E, 0x00, 0x3C, 0xFF, 0x3C, 0x00,
  0x79, 0xFE, 0x78, 0x00, 0xF3, 0xFC, 0xF0, 0x03, 0xC7, 0xF8, 0xF0, 0x07,
  0x8F, 0xF1, 0xE0, 0x0F, 0x1F, 0xE3, 0xC0, 0x1E, 0x3F, 0xC3, 0xC0, 0x78,
  0x7F, 0x87, 0x80, 0xF0, 0xFF, 0x0F, 0x01, 0xE1, 0xFE, 0x1E, 0x07, 0x83,
  0xFC, 0x1E, 0x0F, 0x07, 0xF8, 0x3C, 0x1E, 0x0F, 0xF0, 0x78, 0x3C, 0x1F,
  0xE0, 0xF0, 0xF0, 0x3F, 0xC0, 0xF1, 0xE0, 0x7F, 0x81, 0xE3, 0xC0, 0xFF,
  0x03, 0xCF, 0x01, 0xFE, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0xF8,
  0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0x7C, 0x01, 0xFE, 0x00,
  0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xF7, 0x80, 0x1F, 0xEF, 0x00, 0x3F,
  0xDF, 0x00, 0x7F, 0x9E, 0x00, 0xFF, 0x3E, 0x01, 0xFE, 0x3C, 0x03, 0xFC,
  0x78, 0x07, 0xF8, 0xF8, 0x0F, 0xF0, 0xF0, 0x1F, 0xE1, 0xF0, 0x3F, 0xC1,
  0xE0, 0x7F, 0x83, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x0F,
  0x87, 0xF8, 0x0F, 0x0F, 0xF0, 0x1F, 0x1F, 0xE0, 0x1E, 0x3F, 0xC0, 0x3E,
  0x7F, 0x80, 0x7C, 0xFF, 0x00, 0x79, 0xFE, 0x00, 0xFB, 0xFC, 0x00, 0xF7,
  0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF1, 0xFF, 0x3C,
  0x07, 0xEF, 0x00, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x17, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x01, 0xF8, 0xF0, 0x0F, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00,
  0xF8, 0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F,
  0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8,
  0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03,
  0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0x07, 0x9F, 0x80, 0x27, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xEE, 0x01,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF3,
  0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0x83, 0xE0,
  0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80,
  0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00,
  0x79, 0xE0, 0x01, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x80,
  0x1E, 0x1E, 0x00, 0x77, 0x00, 0x3C, 0x3C, 0x00, 0xEE, 0x00, 0xF8, 0x7C,
  0x03, 0xDC, 0x01, 0xF0, 0xF8, 0x07, 0xBC, 0x03, 0xE0, 0xF0, 0x0F, 0x78,
  0x07, 0x81, 0xE0, 0x1E, 0xF0, 0x0F, 0x03, 0xC0, 0x3D, 0xE0, 0x3E, 0x07,
  0xC0, 0xF3, 0xC0, 0x7C, 0x0F, 0x81, 0xE3, 0xC0, 0xF8, 0x0F, 0x03, 0xC7,
  0x81, 0xE0, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x3C, 0x0F, 0x1E, 0x0F, 0x80,
  0x7C, 0x3C, 0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x3C, 0x3E, 0x00, 0xF0, 0xF0,
  0x78, 0x78, 0x01, 0xE1, 0xE0, 0xF0, 0xF0, 0x03, 0xC3, 0xC1, 0xE3, 0xE0,
  0x07, 0xCF, 0x03, 0xC7, 0xC0, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0x0F, 0x3C,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x1E, 0x78,
  0x00, 0x79, 0xC0, 0x3D, 0xF0, 0x00, 0xFF, 0x80, 0x3B, 0xE0, 0x00, 0xFF,
  0x00, 0x77, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x80, 0x7C, 0x3C, 0x03,
  0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F,
  0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF0,
  0x01, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1E, 0x78, 0x01, 0xF3,
  0xC0, 0x0F, 0x1F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xE0, 0x3C, 0x0F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x78, 0x03,
  0xE7, 0xC0, 0x0F, 0x3E, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1E, 0x00,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C,
  0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3E, 0x00, 0x78,
  0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x1E,
  0x0F, 0x80, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x9E,
  0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0x40, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1,
  0xC1, 0xF0, 0x80, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFF, 0x7E, 0x07, 0xBE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xDF, 0x0F,
  0xEF, 0xFE, 0xF3, 0xFE, 0x78, 0xFE, 0x1C, 0x08, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x1F, 0xC1, 0xE7, 0xFC, 0x3D, 0xFF, 0xC7, 0xF9, 0xFC, 0xFC,
  0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1E, 0xF0, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0,
  0xF9, 0xFE, 0x3F, 0x39, 0xFF, 0xC7, 0x1F, 0xF0, 0xE1, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xDE, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x01, 0x3F, 0x8E, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x40, 0xF0, 0x7F, 0x1E, 0x1F, 0xF3,
  0xC7, 0xFF, 0x79, 0xFC, 0xFF, 0x3E, 0x07, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0xBC, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x7E, 0x7E, 0x3F, 0xC7, 0xFF, 0x38,
  0x7F, 0xE7, 0x07, 0xF0, 0xE0, 0x10, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0x7C, 0x7C, 0x3E, 0x0F, 0x8F, 0x01, 0xE7, 0xC0, 0x3D, 0xE0,
  0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x87, 0xE1, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x08, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x03, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x80, 0x00, 0xFE,
  0x1C, 0x3F, 0xE3, 0x8F, 0xFE, 0xF3, 0xF9, 0xFE, 0x7C, 0x0F, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0xFC, 0xFE, 0x7F,
  0x8F, 0xFE, 0xF0, 0xFF, 0x9E, 0x0F, 0xE3, 0xC0, 0x30, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x40, 0x0F, 0x8E, 0x03, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x04, 0x0F, 0x1F, 0xC7, 0xBF, 0xF3, 0xDF, 0xFD, 0xFF,
  0x7E, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x77, 0xFF, 0xFF, 0xBC, 0x00,
  0x00, 0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x07, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x7F, 0xBF, 0xDF, 0xCF, 0x80, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF,
  0x80, 0xFB, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3E,
  0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xBE, 0x0F, 0x8F, 0x07, 0xC7, 0x83,
  0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x9E, 0x07,
  0xCF, 0x01, 0xE7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x02,
  0x07, 0x1F, 0xE0, 0xFE, 0x39, 0xFF, 0x8F, 0xF9, 0xDF, 0xFC, 0xFF, 0xEE,
  0xF3, 0xFF, 0x3F, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0x01,
  0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xFC, 0x03, 0xE0,
  0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x3F,
  0xC0, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x80,
  0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0xF8,
  0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x0F,
  0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xE0,
  0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x20,
  0x70, 0xFE, 0x39, 0xFF, 0x9C, 0xFF, 0xEE, 0xF3, 0xF7, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3C, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0x9F, 0x83, 0xE0, 0x7C, 0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x01, 0xE7,
  0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0x9F, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x20, 0x1C, 0x3F,
  0x83, 0x8F, 0xF8, 0x73, 0xFF, 0x8F, 0xF1, 0xF9, 0xF8, 0x1F, 0x3E, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07,
  0xBE, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x81, 0xF3, 0xFC, 0xFE,
  0x7B, 0xFF, 0x8F, 0x3F, 0xE1, 0xE3, 0xF8, 0x3C, 0x18, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x1C, 0x3F, 0xE3, 0x8F, 0xFE,
  0xF3, 0xF9, 0xFE, 0x7C, 0x0F, 0xCF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xE7, 0xC0, 0xFC, 0xFE, 0x7F, 0x8F, 0xFE, 0xF0, 0xFF, 0x9E,
  0x0F, 0xE3, 0xC0, 0x20, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x4E,
  0x1F, 0xE3, 0xFE, 0x7F, 0xEF, 0xEE, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0x00, 0x3F, 0xF0, 0xFF,
  0xFB, 0xFF, 0xE7, 0xC3, 0xDF, 0x01, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3D, 0x80, 0xFB, 0xE7, 0xF7, 0xFF, 0xCF,
  0xFF, 0x0F, 0xFC, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x91, 0xFF, 0x0F, 0xF0, 0x7F,
  0x00, 0x80, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0xDF,
  0xF3, 0xFF, 0xBC, 0x7F, 0xCF, 0x0F, 0xE1, 0xC0, 0xC0, 0x00, 0xF8, 0x01,
  0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x3B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x78, 0x03, 0xE0, 0x0F, 0x78, 0x07, 0xE0, 0x1F, 0x7C,
  0x07, 0xF0, 0x1E, 0x7C, 0x07, 0xF0, 0x1E, 0x3C, 0x07, 0xF0, 0x1E, 0x3C,
  0x07, 0x70, 0x1E, 0x3C, 0x0F, 0x70, 0x3E, 0x3E, 0x0F, 0x78, 0x3C, 0x1E,
  0x0F, 0x78, 0x3C, 0x1E, 0x0E, 0x78, 0x3C, 0x1E, 0x0E, 0x78, 0x3C, 0x1E,
  0x1E, 0x38, 0x78, 0x1F, 0x1E, 0x3C, 0x78, 0x0F, 0x1E, 0x3C, 0x78, 0x0F,
  0x1C, 0x3C, 0x78, 0x0F, 0x1C, 0x3C, 0x78, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F,
  0x3C, 0x1C, 0xF0, 0x07, 0xBC, 0x1E, 0xF0, 0x07, 0xB8, 0x1E, 0xF0, 0x07,
  0xB8, 0x1E, 0xE0, 0x07, 0xB8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xDF, 0x01, 0xE7,
  0xC0, 0xF8, 0xF0, 0x3E, 0x3E, 0x0F, 0x07, 0x87, 0xC1, 0xF1, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xF8,
  0x7C, 0x3C, 0x0F, 0x1F, 0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x03,
  0xC0, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0x9E,
  0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x06, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xFC, 0x01,
  0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xFC, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x13, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0xDF, 0xE3, 0xFF, 0xFC, 0x07, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 39, 13, 3, -39 },
  { 31, 14, 14, 20, 3, -39 },
  { 56, 23, 39, 25, 1, -39 },
  { 169, 19, 44, 23, 2, -41 },
  { 274, 32, 39, 36, 2, -39 },
  { 430, 24, 40, 26, 2, -39 },
  { 550, 5, 14, 11, 3, -39 },
  { 559, 11, 48, 16, 3, -39 },
  { 625, 11, 48, 16, 2, -39 },
  { 691, 18, 18, 21, 2, -41 },
  { 732, 19, 26, 23, 2, -32 },
  { 794, 7, 13, 12, 2, -6 },
  { 806, 12, 5, 15, 1, -17 },
  { 814, 6, 6, 12, 3, -6 },
  { 819, 18, 39, 20, 1, -39 },
  { 907, 19, 40, 23, 2, -39 },
  { 1002, 13, 39, 23, 3, -39 },
  { 1066, 19, 39, 23, 2, -39 },
  { 1159, 19, 40, 23, 2, -39 },
  { 1254, 21, 39, 23, 1, -39 },
  { 1357, 18, 40, 23, 3, -39 },
  { 1447, 19, 40, 23, 2, -39 },
  { 1542, 19, 39, 23, 2, -39 },
  { 1635, 19, 40, 23, 2, -39 },
  { 1730, 19, 40, 23, 2, -39 },
  { 1825, 6, 29, 12, 3, -29 },
  { 1847, 7, 36, 12, 2, -29 },
  { 1879, 20, 24, 23, 2, -31 },
  { 1939, 19, 16, 23, 2, -27 },
  { 1977, 20, 24, 23, 2, -31 },
  { 2037, 15, 39, 17, 1, -39 },
  { 2111, 30, 44, 35, 3, -39 },
  { 2276, 24, 39, 24, 0, -39 },
  { 2393, 20, 39, 26, 4, -39 },
  { 2491, 20, 40, 24, 3, -39 },
  { 2591, 21, 39, 28, 4, -39 },
  { 2694, 15, 39, 22, 4, -39 },
  { 2768, 15, 39, 21, 4, -39 },
  { 2842, 24, 40, 29, 3, -39 },
  { 2962, 21, 39, 29, 4, -39 },
  { 3065, 11, 39, 15, 2, -39 },
  { 3119, 11, 49, 12, -3, -39 },
  { 3187, 20, 39, 24, 4, -39 },
  { 3285, 15, 39, 20, 4, -39 },
  { 3359, 31, 39, 39, 4, -39 },
  { 3511, 23, 39, 31, 4, -39 },
  { 3624, 24, 40, 30, 3, -39 },
  { 3744, 18, 39, 24, 4, -39 },
  { 3832, 24, 48, 30, 3, -39 },
  { 3976, 20, 39, 25, 4, -39 },
  { 4074, 18, 40, 22, 2, -39 },
  { 4164, 19, 39, 21, 1, -39 },
  { 4257, 21, 40, 28, 4, -39 },
  { 4362, 24, 39, 24, 0, -39 },
  { 4479, 39, 39, 39, 0, -39 },
  { 4670, 21, 39, 22, 0, -39 },
  { 4773, 21, 39, 21, 0, -39 },
  { 4876, 17, 39, 20, 1, -39 },
  { 4959, 11, 48, 17, 4, -39 },
  { 5025, 18, 39, 20, 1, -39 },
  { 5113, 11, 48, 17, 2, -39 },
  { 5179, 22, 21, 24, 1, -39 },
  { 5237, 24, 4, 24, 0, 4 },
  { 5249, 10, 8, 14, 2, -41 },
  { 5259, 17, 31, 22, 2, -30 },
  { 5325, 19, 42, 25, 4, -41 },
  { 5425, 16, 31, 19, 2, -30 },
  { 5487, 19, 42, 25, 2, -41 },
  { 5587, 18, 30, 23, 2, -29 },
  { 5655, 15, 41, 14, 0, -41 },
  { 5732, 19, 43, 25, 2, -30 },
  { 5835, 17, 41, 25, 4, -41 },
  { 5923, 5, 40, 11, 3, -40 },
  { 5948, 9, 53, 11, -1, -40 },
  { 6008, 17, 41, 22, 4, -41 },
  { 6096, 4, 41, 11, 4, -41 },
  { 6117, 29, 30, 37, 4, -30 },
  { 6226, 17, 30, 25, 4, -30 },
  { 6290, 20, 31, 24, 2, -30 },
  { 6368, 19, 43, 25, 4, -30 },
  { 6471, 19, 43, 25, 2, -30 },
  { 6574, 12, 30, 16, 4, -30 },
  { 6619, 15, 31, 18, 2, -30 },
  { 6678, 12, 37, 14, 1, -36 },
  { 6734, 18, 30, 25, 3, -29 },
  { 6802, 20, 29, 20, 0, -29 },
  { 6875, 32, 29, 33, 0, -29 },
  { 6991, 18, 29, 20, 1, -29 },
  { 7057, 20, 42, 20, 0, -29 },
  { 7162, 14, 29, 16, 1, -29 },
  { 7213, 15, 48, 20, 2, -39 },
  { 7303, 4, 54, 22, 9, -41 },
  { 7330, 15, 48, 20, 2, -39 },
  { 7420, 20, 7, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Regular54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR54PT7B_H_
