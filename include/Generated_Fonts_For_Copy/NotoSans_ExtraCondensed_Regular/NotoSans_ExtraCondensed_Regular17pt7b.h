#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xCF, 0xD9, 0x99, 0x16, 0x14, 0x34, 0x7F, 0x24, 0x24,
  0x24, 0xFE, 0x2C, 0x28, 0x68, 0x48, 0x20, 0x8F, 0xA8, 0xA2, 0x86, 0x0E,
  0x2C, 0xBA, 0xBC, 0x20, 0x80, 0xE2, 0x28, 0x8B, 0x42, 0xD0, 0xB4, 0x2A,
  0xEE, 0xA8, 0x2B, 0x12, 0xC4, 0xB3, 0x28, 0x8E, 0x38, 0x6C, 0x6C, 0x28,
  0x28, 0x30, 0x7B, 0x4A, 0xCE, 0x46, 0x4E, 0x7B, 0xEA, 0x29, 0x6D, 0x24,
  0x93, 0x64, 0xC8, 0xC6, 0x23, 0x31, 0x11, 0x11, 0x32, 0x26, 0x40, 0x21,
  0x3E, 0xCD, 0x2C, 0x20, 0x82, 0x3F, 0xFC, 0x82, 0x08, 0xFA, 0xF0, 0xF0,
  0x04, 0x20, 0x86, 0x10, 0x43, 0x08, 0x21, 0x84, 0x30, 0x73, 0x68, 0xA2,
  0x8E, 0x38, 0xE3, 0x8A, 0x2D, 0x9C, 0x37, 0xD1, 0x11, 0x11, 0x11, 0x11,
  0xF2, 0x60, 0x82, 0x08, 0x61, 0x08, 0x61, 0x08, 0x3F, 0xFC, 0x42, 0x11,
  0xB8, 0x61, 0x08, 0x67, 0xE0, 0x0C, 0x38, 0x70, 0xE2, 0xC5, 0x93, 0x26,
  0xFE, 0x18, 0x30, 0x60, 0xFA, 0x08, 0x20, 0x83, 0xE0, 0x83, 0x0C, 0x29,
  0xBC, 0x79, 0x0C, 0x20, 0xB3, 0xE8, 0xA3, 0x8E, 0x2C, 0x9C, 0xFC, 0x20,
  0x86, 0x18, 0x43, 0x0C, 0x21, 0x86, 0x10, 0x7B, 0x28, 0xA2, 0xD9, 0xC5,
  0xA2, 0x8E, 0x38, 0x9E, 0x76, 0xE3, 0x18, 0xC7, 0xE5, 0x08, 0xC5, 0xE0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE8, 0x02, 0x1C, 0xE7, 0x06, 0x03, 0x03,
  0x81, 0xFC, 0x00, 0x3F, 0x83, 0x07, 0x07, 0x1D, 0xCC, 0x20, 0xF4, 0xC2,
  0x11, 0x98, 0x84, 0x20, 0x18, 0xC0, 0x3E, 0x30, 0x90, 0x79, 0xD9, 0x6C,
  0xB6, 0xD3, 0x69, 0x94, 0xCD, 0xB0, 0x08, 0x03, 0xE0, 0x18, 0x18, 0x38,
  0x2C, 0x2C, 0x24, 0x64, 0x7E, 0x46, 0x42, 0xC2, 0xC3, 0xFB, 0x3C, 0x71,
  0xCF, 0xEC, 0xF1, 0xC7, 0x1C, 0xFE, 0x3D, 0x9C, 0x30, 0x82, 0x08, 0x20,
  0xC3, 0x06, 0x4F, 0xF9, 0x9B, 0x16, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8B,
  0x37, 0xC0, 0xFE, 0x31, 0x8C, 0x7F, 0x18, 0xC6, 0x31, 0xF0, 0xFE, 0x31,
  0x8C, 0x63, 0xF8, 0xC6, 0x31, 0x80, 0x3E, 0xC7, 0x06, 0x08, 0x10, 0x23,
  0xC1, 0xC3, 0x85, 0x89, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x30, 0xE9, 0x24, 0x92, 0x49, 0x70, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x32, 0xE0, 0xC7, 0x9B, 0x26, 0x8F, 0x1E, 0x34, 0x6C,
  0xD9, 0x93, 0x36, 0x30, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xF0,
  0xC0, 0xF8, 0x7E, 0x17, 0x85, 0xF1, 0x74, 0xDD, 0x27, 0x49, 0xDE, 0x73,
  0x1C, 0xC7, 0x31, 0xC3, 0xC7, 0x8F, 0x9D, 0x3A, 0x76, 0xE5, 0xCF, 0x8F,
  0x1E, 0x10, 0x7C, 0x46, 0xC2, 0xC2, 0x82, 0x83, 0x83, 0x82, 0xC2, 0xC6,
  0x66, 0x3C, 0xFB, 0x3C, 0xF1, 0xCF, 0x3F, 0xB0, 0xC3, 0x0C, 0x30, 0x7C,
  0x46, 0xC2, 0xC2, 0x82, 0x83, 0x83, 0x82, 0xC2, 0xC6, 0x66, 0x3C, 0x0C,
  0x04, 0x06, 0xF9, 0x9B, 0x36, 0x2C, 0xD9, 0x3C, 0x6C, 0xC9, 0x93, 0x36,
  0x30, 0x7E, 0x61, 0x0C, 0x30, 0xE1, 0x08, 0x67, 0xE0, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8D, 0x13, 0xE0, 0xC3, 0xC2, 0x46, 0x46, 0x64, 0x64, 0x2C,
  0x2C, 0x28, 0x38, 0x18, 0x18, 0xC6, 0x1C, 0x63, 0x46, 0x34, 0x72, 0x47,
  0x26, 0xD2, 0x69, 0x62, 0x96, 0x29, 0x42, 0x9C, 0x38, 0xC3, 0x0C, 0xC6,
  0x89, 0xB1, 0x43, 0x82, 0x0E, 0x14, 0x28, 0xD9, 0x16, 0x30, 0xC6, 0x89,
  0x33, 0x42, 0x87, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x80, 0x7C, 0x20, 0x86,
  0x10, 0xC3, 0x08, 0x61, 0x04, 0x3F, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xF0, 0xC1, 0x06, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x20, 0x81, 0xE4,
  0x92, 0x49, 0x24, 0x92, 0x78, 0x10, 0x30, 0xA1, 0x24, 0x58, 0x40, 0xFE,
  0xC8, 0x80, 0xF0, 0xC2, 0x3E, 0xC6, 0x33, 0xE8, 0x82, 0x08, 0x20, 0xBB,
  0x3C, 0x71, 0x87, 0x1C, 0x73, 0xB8, 0x7E, 0x21, 0x08, 0x42, 0x18, 0x70,
  0x0C, 0x30, 0xC3, 0x7F, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0x74, 0x76, 0x63,
  0x1F, 0xC2, 0x19, 0x78, 0x3B, 0x18, 0xCF, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x00, 0x77, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0x7C, 0x30, 0xE2, 0xF0, 0x82,
  0x08, 0x20, 0xBB, 0x3C, 0xF3, 0x8E, 0x38, 0xE3, 0x8C, 0xB0, 0xAA, 0xAA,
  0x80, 0x4C, 0x04, 0x92, 0x49, 0x24, 0x92, 0xC0, 0x82, 0x08, 0x21, 0x8A,
  0x6B, 0x28, 0xF3, 0x49, 0xA2, 0x8C, 0xFF, 0xF8, 0xBB, 0xB3, 0x2C, 0xCF,
  0x33, 0x8C, 0xE3, 0x38, 0xCE, 0x33, 0x8C, 0xC0, 0xBB, 0x3C, 0xF3, 0x8E,
  0x38, 0xE3, 0x8C, 0x7B, 0x28, 0xE3, 0x8E, 0x38, 0xF2, 0x78, 0xBB, 0x3C,
  0x71, 0x87, 0x1C, 0x73, 0xBA, 0x08, 0x20, 0x80, 0x77, 0x38, 0xE3, 0x8E,
  0x38, 0xF3, 0x7C, 0x30, 0xC3, 0x0C, 0xBC, 0xCC, 0x88, 0x88, 0x80, 0xF8,
  0x8C, 0x63, 0x19, 0xF0, 0x66, 0xF6, 0x66, 0x66, 0x66, 0x30, 0x8E, 0x38,
  0xE3, 0x8E, 0x3C, 0xF3, 0x7C, 0xC7, 0x34, 0xD2, 0x69, 0xA3, 0x8C, 0x30,
  0xCC, 0x53, 0x34, 0xCD, 0x3A, 0x5A, 0x9C, 0xA3, 0x38, 0xCC, 0x33, 0x00,
  0xCD, 0xA3, 0x8C, 0x30, 0xE6, 0x92, 0xCC, 0xC7, 0x34, 0xD2, 0x68, 0xE3,
  0x8C, 0x30, 0xC2, 0x08, 0xE0, 0x78, 0x84, 0x62, 0x31, 0x08, 0xF8, 0x32,
  0x66, 0x66, 0x4C, 0x66, 0x66, 0x63, 0x10, 0xFF, 0xFF, 0x80, 0xC6, 0x66,
  0x66, 0x23, 0x66, 0x66, 0x6C, 0x80, 0x73, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 6, 1, -12 },
  { 6, 8, 12, 8, 0, -12 },
  { 18, 6, 14, 7, 1, -13 },
  { 29, 10, 12, 11, 1, -12 },
  { 44, 8, 12, 8, 0, -12 },
  { 56, 2, 4, 4, 1, -12 },
  { 57, 3, 15, 5, 1, -12 },
  { 63, 4, 15, 5, 0, -12 },
  { 71, 5, 6, 7, 1, -13 },
  { 75, 6, 8, 7, 1, -10 },
  { 81, 2, 4, 4, 1, -2 },
  { 82, 4, 1, 5, 0, -5 },
  { 83, 2, 2, 4, 1, -2 },
  { 84, 6, 12, 6, 0, -12 },
  { 93, 6, 12, 7, 1, -12 },
  { 102, 4, 12, 7, 1, -12 },
  { 108, 6, 12, 7, 1, -12 },
  { 117, 5, 12, 7, 1, -12 },
  { 125, 7, 12, 7, 0, -12 },
  { 136, 6, 12, 7, 1, -12 },
  { 145, 6, 12, 7, 1, -12 },
  { 154, 6, 12, 7, 1, -12 },
  { 163, 6, 12, 7, 1, -12 },
  { 172, 5, 12, 7, 1, -12 },
  { 180, 2, 9, 4, 1, -9 },
  { 183, 2, 11, 4, 1, -9 },
  { 186, 7, 8, 7, 0, -10 },
  { 193, 6, 4, 7, 1, -8 },
  { 196, 6, 8, 7, 1, -10 },
  { 202, 5, 12, 5, 0, -12 },
  { 210, 9, 13, 11, 1, -12 },
  { 225, 8, 12, 8, 0, -12 },
  { 237, 6, 12, 8, 1, -12 },
  { 246, 6, 12, 8, 1, -12 },
  { 255, 7, 12, 9, 1, -12 },
  { 266, 5, 12, 7, 1, -12 },
  { 274, 5, 12, 6, 1, -12 },
  { 282, 7, 12, 9, 1, -12 },
  { 293, 7, 12, 9, 1, -12 },
  { 304, 3, 12, 5, 1, -12 },
  { 309, 4, 15, 4, -1, -12 },
  { 317, 7, 12, 8, 1, -12 },
  { 328, 5, 12, 6, 1, -12 },
  { 336, 10, 12, 12, 1, -12 },
  { 351, 7, 12, 10, 1, -12 },
  { 362, 8, 12, 9, 1, -12 },
  { 374, 6, 12, 8, 1, -12 },
  { 383, 8, 15, 9, 1, -12 },
  { 398, 7, 12, 8, 1, -12 },
  { 409, 5, 12, 7, 1, -12 },
  { 417, 6, 12, 6, 0, -12 },
  { 426, 7, 12, 9, 1, -12 },
  { 437, 8, 12, 8, 0, -12 },
  { 449, 12, 12, 12, 0, -12 },
  { 467, 7, 12, 7, 0, -12 },
  { 478, 7, 12, 7, 0, -12 },
  { 489, 6, 12, 6, 0, -12 },
  { 498, 4, 15, 5, 1, -12 },
  { 506, 6, 12, 6, 0, -12 },
  { 515, 3, 15, 5, 1, -12 },
  { 521, 7, 6, 8, 0, -12 },
  { 527, 7, 1, 7, 0, 1 },
  { 528, 3, 3, 5, 1, -13 },
  { 530, 5, 9, 7, 1, -9 },
  { 536, 6, 13, 8, 1, -13 },
  { 546, 5, 9, 6, 1, -9 },
  { 552, 6, 13, 8, 1, -13 },
  { 562, 5, 9, 7, 1, -9 },
  { 568, 5, 13, 4, 0, -13 },
  { 577, 6, 13, 8, 1, -9 },
  { 587, 6, 13, 8, 1, -13 },
  { 597, 2, 13, 4, 1, -13 },
  { 601, 3, 17, 4, 0, -13 },
  { 608, 6, 13, 7, 1, -13 },
  { 618, 1, 13, 4, 1, -13 },
  { 620, 10, 9, 12, 1, -9 },
  { 632, 6, 9, 8, 1, -9 },
  { 639, 6, 9, 8, 1, -9 },
  { 646, 6, 13, 8, 1, -9 },
  { 656, 6, 13, 8, 1, -9 },
  { 666, 4, 9, 5, 1, -9 },
  { 671, 4, 9, 6, 1, -9 },
  { 676, 4, 11, 4, 0, -11 },
  { 682, 6, 9, 8, 1, -9 },
  { 689, 6, 9, 6, 0, -9 },
  { 696, 10, 9, 10, 0, -9 },
  { 708, 6, 9, 6, 0, -9 },
  { 715, 6, 13, 6, 0, -9 },
  { 725, 5, 9, 5, 0, -9 },
  { 731, 4, 15, 6, 1, -12 },
  { 739, 1, 17, 7, 3, -13 },
  { 742, 4, 15, 6, 1, -12 },
  { 750, 7, 2, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Regular17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR17PT7B_H_
