#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F,
  0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC6, 0x63, 0x00,
  0x0E, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x70, 0x31, 0x80, 0xC6,
  0x3F, 0xFF, 0xFF, 0xFC, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0xE0, 0x63,
  0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x31,
  0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFC,
  0x3F, 0xF7, 0xEE, 0x66, 0x0E, 0x60, 0xE6, 0x0E, 0x60, 0x66, 0x07, 0xE0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x6E, 0x06, 0x70, 0x63, 0x06, 0x30, 0x63,
  0x86, 0x7E, 0x6E, 0xFF, 0xE7, 0xF8, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x03, 0xE0, 0x60, 0x7E, 0x06, 0x06, 0x70, 0xE0, 0x63, 0x0C,
  0x0E, 0x30, 0xC0, 0xE3, 0x1C, 0x0E, 0x31, 0x80, 0xE3, 0x18, 0x0E, 0x33,
  0x80, 0x63, 0x31, 0xC6, 0x33, 0x3E, 0x67, 0x76, 0x67, 0xE6, 0x67, 0x3E,
  0x66, 0x30, 0x8C, 0xE3, 0x00, 0xCE, 0x30, 0x1C, 0xE3, 0x01, 0x8E, 0x30,
  0x18, 0xE3, 0x03, 0x86, 0x30, 0x30, 0x63, 0x03, 0x06, 0x70, 0x70, 0x7E,
  0x06, 0x03, 0xC0, 0x06, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xCE, 0x03, 0x1C,
  0x06, 0x18, 0x0C, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x37, 0x00, 0x7E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xE3, 0x9C, 0xE7, 0x39, 0xCE, 0xE1, 0xDD, 0xC3,
  0xBB, 0x83, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x1F, 0x1C, 0x7F, 0x3F, 0xEE,
  0x3F, 0x0E, 0xFF, 0xFF, 0xFF, 0x60, 0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x1C,
  0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xE1, 0xC3, 0x87, 0x0E,
  0x0C, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xC1, 0xC1,
  0x83, 0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0x87, 0x0E, 0x18, 0x70, 0xC3, 0x8E, 0x00, 0x0E, 0x01,
  0xC0, 0x18, 0x43, 0x17, 0xFF, 0xFF, 0xC3, 0x80, 0xF8, 0x1B, 0x87, 0x39,
  0xC6, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x1F, 0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x39, 0xDC, 0xE7, 0x31, 0x9C, 0xFF, 0xFF, 0xF8,
  0xEF, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x02,
  0x01, 0xF8, 0x3F, 0xC3, 0x9E, 0x70, 0xE7, 0x06, 0x70, 0x77, 0x07, 0x60,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x76, 0x07, 0x70, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x39, 0xE3, 0xFC, 0x1F,
  0x80, 0x07, 0x0F, 0x1F, 0x3F, 0x77, 0xE7, 0x47, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x03, 0xF8, 0xFF, 0xC6, 0x1E, 0x40, 0xE0, 0x06, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x03, 0xF8, 0xFF, 0xC6, 0x0E, 0x40, 0xE0, 0x06,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC1, 0xF8, 0x1F, 0x01, 0xFC,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0xE1, 0xEF, 0xFC, 0x7F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x6E, 0x03, 0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xE0, 0xC7, 0x0E, 0x38, 0x61,
  0xC7, 0x0E, 0x30, 0x73, 0x83, 0x98, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7F, 0xDF, 0xFB, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC3, 0xFE, 0x7F,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x1D, 0x87, 0xBF, 0xE7, 0xF8, 0x01, 0xC0, 0x7E, 0x1F, 0xE1, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x67, 0xC6, 0xFE, 0x78,
  0xEF, 0x07, 0xF0, 0x7E, 0x07, 0x60, 0x76, 0x07, 0x70, 0x77, 0x07, 0x70,
  0x73, 0x87, 0x38, 0xE1, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x06, 0x01, 0xFC, 0x3F, 0xE7,
  0x0E, 0x70, 0x77, 0x07, 0x60, 0x77, 0x07, 0x70, 0x73, 0x8E, 0x3D, 0xC1,
  0xF8, 0x0F, 0x01, 0xFC, 0x39, 0xE7, 0x0F, 0x60, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x77, 0x07, 0x78, 0xF3, 0xFE, 0x1F, 0xC0, 0x06, 0x01, 0xF8,
  0x3F, 0xC7, 0x9E, 0x70, 0xE6, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x77, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0x71, 0xE7, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x43, 0x87, 0xF8, 0x7E, 0x00, 0xEF,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x73, 0xDE, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x73, 0x9C, 0xC6, 0x70, 0x00, 0x08,
  0x01, 0xC0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x60, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x1F, 0xCF, 0xF9, 0x8F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0F, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0E, 0x03,
  0x83, 0x80, 0x38, 0x60, 0x03, 0x1C, 0x00, 0x73, 0x07, 0x86, 0xE1, 0xF8,
  0xDC, 0x73, 0x1B, 0x1C, 0x63, 0x63, 0x0C, 0x7C, 0x61, 0x8F, 0x8C, 0x31,
  0xF1, 0x8E, 0x3E, 0x31, 0xC6, 0xC6, 0x38, 0xD8, 0xC7, 0x1B, 0x1C, 0xA7,
  0x61, 0xF7, 0xCE, 0x1C, 0xF1, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC3, 0x80, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x36, 0x00, 0x6C, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x30, 0x0C, 0x60, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC3, 0x03, 0x07,
  0x0F, 0xFE, 0x1F, 0xFC, 0x38, 0x18, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xCE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0x38, 0x3D,
  0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFE, 0x70, 0x3B, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0x71, 0xFB, 0xFF, 0x9F, 0xF0, 0x01, 0x80,
  0xFF, 0x1F, 0xF3, 0xC3, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3E, 0x31, 0xFF, 0x0F, 0xF0,
  0xFF, 0x83, 0xFF, 0x8E, 0x1F, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xEE, 0x03,
  0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0,
  0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x1F, 0xF8, 0x7F, 0xF1,
  0xE0, 0x63, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0x77, 0x00, 0xE7, 0x01, 0xCF,
  0x87, 0x8F, 0xFF, 0x07, 0xFC, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFE,
  0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x3F, 0xFF, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xDF, 0x8C, 0x00,
  0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x8E, 0x1C,
  0x70, 0xE7, 0x07, 0x38, 0x3B, 0x81, 0xDE, 0x0F, 0xF0, 0x7B, 0x83, 0xCE,
  0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x39, 0xC1, 0xCE, 0x07, 0x70, 0x3B,
  0x81, 0xFC, 0x07, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFE, 0xC0, 0x3F,
  0xEC, 0x03, 0x7E, 0xE0, 0x37, 0xE6, 0x07, 0x7E, 0x60, 0x77, 0xE7, 0x06,
  0x7E, 0x70, 0x67, 0xE3, 0x0E, 0x7E, 0x30, 0xC7, 0xE3, 0x8C, 0x7E, 0x19,
  0xC7, 0xE1, 0x9C, 0x7E, 0x1D, 0x87, 0xE1, 0xD8, 0x7E, 0x0F, 0x87, 0xE0,
  0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x07, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFD, 0x81, 0xFB, 0x83, 0xF3, 0x07,
  0xE7, 0x0F, 0xCE, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x18, 0xFC, 0x39, 0xF8,
  0x73, 0xF0, 0x77, 0xE0, 0xEF, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0x01, 0x00, 0x3F, 0xC0, 0xFF, 0xC1,
  0xE3, 0xC7, 0x03, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x06, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x73, 0x80, 0xE7, 0x01, 0xCF, 0x07, 0x0F,
  0x3E, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x1E, 0xFF,
  0xCF, 0xF8, 0xF8, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0x00, 0x3F, 0xC0, 0xFF, 0xC1, 0xE3,
  0xC7, 0x03, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x73, 0x80, 0xE7, 0x01, 0xCF, 0x07, 0x0F, 0x3E,
  0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0xFF, 0x87, 0xFE, 0x38, 0xF9, 0xC1, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xFF, 0xCF,
  0xF8, 0x7F, 0xC3, 0x8E, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x39, 0xC1,
  0xCE, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x07, 0x06, 0x01, 0xFF, 0x3F, 0xE7,
  0x86, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE8, 0x0E, 0xF3, 0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0E, 0xE0, 0x77, 0x03, 0xBE, 0x78,
  0xFF, 0xC3, 0xFC, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xC0,
  0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x03, 0x18, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3B, 0x00, 0x36, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0,
  0xE0, 0x1C, 0x07, 0x60, 0x1C, 0x07, 0x70, 0x3C, 0x07, 0x70, 0x3C, 0x07,
  0x70, 0x3E, 0x0E, 0x70, 0x3E, 0x0E, 0x30, 0x36, 0x0E, 0x38, 0x76, 0x0E,
  0x38, 0x76, 0x0E, 0x38, 0x67, 0x1C, 0x38, 0x67, 0x1C, 0x18, 0x67, 0x1C,
  0x1C, 0xE3, 0x1C, 0x1C, 0xE3, 0x1C, 0x1C, 0xC3, 0xB8, 0x1C, 0xC3, 0xB8,
  0x0C, 0xC3, 0xB8, 0x0D, 0xC1, 0xB8, 0x0F, 0xC1, 0xB8, 0x0F, 0x81, 0xB0,
  0x0F, 0x81, 0xB0, 0x07, 0x81, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xE0,
  0x70, 0x39, 0x81, 0x8E, 0x1C, 0x70, 0xE1, 0x8E, 0x0E, 0x70, 0x73, 0x81,
  0xF8, 0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3F,
  0x01, 0xB8, 0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x38, 0x39,
  0xC0, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0xDC, 0x1C, 0xE0, 0xE3, 0x87, 0x1C,
  0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xDF, 0xF8, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x07, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF8,
  0x03, 0x60, 0x1D, 0xC0, 0x73, 0x03, 0x8E, 0x0E, 0x38, 0x30, 0x71, 0xC1,
  0xC6, 0x03, 0x38, 0x0E, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x02, 0x0F, 0xF0, 0xFF, 0x10, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xE7, 0xFD, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0x71, 0xEF, 0xEC, 0xF9, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x10, 0xEF, 0xCF, 0xFE, 0xF8, 0xEF, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x8E, 0xEF, 0xEE, 0x7C, 0x06, 0x07, 0xF3,
  0xFC, 0xE1, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x4F, 0xF1, 0xFC, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x87, 0x1F, 0xB9,
  0xFD, 0xDE, 0x3E, 0xE0, 0xF7, 0x07, 0xB8, 0x1D, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x77, 0x03, 0xB8, 0x3D, 0xC1, 0xE7, 0x1F,
  0x3F, 0xB8, 0xF9, 0xC0, 0x02, 0x01, 0xF8, 0x3F, 0xC3, 0x8E, 0x70, 0x67,
  0x07, 0x60, 0x76, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x21, 0xFE, 0x0F, 0xE0, 0x0F, 0x8F, 0xC7,
  0xA3, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x7F, 0x7F, 0x86, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x00, 0x04, 0x00, 0xFD, 0xCF, 0xEE, 0xF1, 0xF7, 0x07, 0xB8,
  0x3D, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x76, 0x03,
  0xB8, 0x1D, 0xC1, 0xEE, 0x0F, 0x38, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC8, 0x0E, 0x71, 0xE3, 0xFF, 0x0F, 0xE0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x18, 0xEF, 0xDF,
  0xFF, 0xE3, 0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0C, 0xFF,
  0xB0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xCE, 0x30,
  0x00, 0x07, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9F, 0xFE, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFC, 0x3B, 0x8E, 0x71, 0xCE, 0x71,
  0xCE, 0x3B, 0x87, 0x70, 0xFE, 0x1E, 0xE3, 0xDC, 0x71, 0xCE, 0x39, 0xC3,
  0xB8, 0x77, 0x0E, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x02, 0x02, 0x1D, 0xF9, 0xFB, 0xFF, 0x7F, 0x78,
  0xF8, 0xFF, 0x0F, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0,
  0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1,
  0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83,
  0x83, 0x80, 0x02, 0x1D, 0xFB, 0xFF, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0x80, 0x06, 0x00, 0xFE, 0x0F, 0xF8, 0x71, 0xC7,
  0x07, 0x38, 0x39, 0x80, 0xCC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x76, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x38, 0xE1, 0xFF, 0x03, 0xF0,
  0x03, 0x0E, 0xFC, 0xFF, 0xEF, 0x0E, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xF8, 0xEE, 0xFE, 0xE7, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x04, 0x00, 0xFD, 0xCF, 0xEE, 0xF1, 0xF7,
  0x07, 0xB8, 0x3D, 0xC0, 0xEC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x76, 0x03, 0xB8, 0x1D, 0xC1, 0xEE, 0x0F, 0x38, 0xF9, 0xFD, 0xC7, 0xCE,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x03, 0xCF, 0xEF, 0xFD, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x04, 0x1F, 0xDF, 0xFC,
  0x1E, 0x07, 0x03, 0x80, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x38, 0x0C,
  0x07, 0x07, 0xC3, 0xFF, 0xFF, 0x80, 0x30, 0x60, 0xC3, 0x8F, 0xFF, 0xDC,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xC3,
  0xE7, 0xC0, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x8F,
  0x7F, 0x67, 0xCC, 0xE0, 0x76, 0x07, 0x70, 0x77, 0x07, 0x70, 0x63, 0x0E,
  0x30, 0xE3, 0x8C, 0x38, 0xC1, 0x9C, 0x19, 0xC1, 0xD8, 0x1D, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0xE0, 0x70, 0x76, 0x0F, 0x07, 0x70,
  0xF0, 0x77, 0x0F, 0x86, 0x70, 0xD8, 0x63, 0x0D, 0x8E, 0x31, 0xD8, 0xE3,
  0x9D, 0x8E, 0x39, 0x9C, 0xC3, 0x99, 0xCC, 0x19, 0x8D, 0xC1, 0xB8, 0xDC,
  0x1F, 0x8D, 0x81, 0xF0, 0xD8, 0x1F, 0x0F, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xE0, 0x70, 0x70, 0x73, 0x0E, 0x38, 0xE3, 0x8C, 0x1D, 0xC1, 0xD8,
  0x0F, 0x80, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x81, 0xD8, 0x1D, 0xC1, 0x9C,
  0x38, 0xE3, 0x0E, 0x70, 0x7F, 0x07, 0xE0, 0x76, 0x07, 0x70, 0x77, 0x07,
  0x70, 0xE3, 0x0E, 0x38, 0xE3, 0x8C, 0x38, 0xC1, 0x9C, 0x1D, 0xC1, 0xD8,
  0x0D, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x0B, 0xC0, 0xF8, 0x0F, 0x00, 0xFF, 0x7F, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03,
  0x83, 0x81, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xC1, 0xF0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x3E, 0x0E,
  0x03, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x1F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3E, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xF0, 0x1C, 0x1F,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC3, 0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0xF8, 0xF1, 0xFF, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 9, 9, 13, 2, -24 },
  { 24, 14, 24, 16, 1, -24 },
  { 66, 12, 28, 15, 1, -26 },
  { 108, 20, 25, 23, 1, -25 },
  { 171, 15, 25, 16, 1, -25 },
  { 218, 3, 9, 7, 2, -24 },
  { 222, 7, 29, 10, 2, -24 },
  { 248, 7, 29, 10, 1, -24 },
  { 274, 11, 11, 14, 1, -26 },
  { 290, 13, 16, 15, 1, -20 },
  { 316, 5, 8, 8, 1, -4 },
  { 321, 7, 3, 9, 1, -11 },
  { 324, 4, 4, 8, 2, -4 },
  { 326, 11, 24, 13, 1, -24 },
  { 359, 12, 25, 15, 1, -25 },
  { 397, 8, 24, 15, 2, -24 },
  { 421, 12, 25, 15, 1, -25 },
  { 459, 12, 25, 15, 1, -25 },
  { 497, 13, 24, 15, 1, -24 },
  { 536, 11, 24, 15, 2, -24 },
  { 569, 12, 25, 15, 1, -25 },
  { 607, 12, 24, 15, 1, -24 },
  { 643, 12, 25, 15, 1, -25 },
  { 681, 12, 25, 15, 1, -25 },
  { 719, 4, 18, 8, 2, -18 },
  { 728, 5, 22, 8, 1, -18 },
  { 742, 13, 16, 15, 1, -20 },
  { 768, 13, 10, 15, 1, -17 },
  { 785, 13, 16, 15, 1, -20 },
  { 811, 10, 25, 11, 0, -25 },
  { 843, 19, 28, 22, 2, -25 },
  { 910, 15, 24, 15, 0, -24 },
  { 955, 13, 24, 16, 2, -24 },
  { 994, 12, 25, 15, 2, -25 },
  { 1032, 14, 24, 18, 2, -24 },
  { 1074, 10, 24, 14, 2, -24 },
  { 1104, 10, 24, 13, 2, -24 },
  { 1134, 15, 25, 19, 2, -25 },
  { 1181, 14, 24, 18, 2, -24 },
  { 1223, 7, 24, 10, 1, -24 },
  { 1244, 7, 31, 8, -2, -24 },
  { 1272, 13, 24, 15, 2, -24 },
  { 1311, 10, 24, 13, 2, -24 },
  { 1341, 20, 24, 24, 2, -24 },
  { 1401, 15, 24, 19, 2, -24 },
  { 1446, 15, 25, 19, 2, -25 },
  { 1493, 12, 24, 15, 2, -24 },
  { 1529, 15, 31, 19, 2, -25 },
  { 1588, 13, 24, 16, 2, -24 },
  { 1627, 12, 25, 14, 1, -25 },
  { 1665, 13, 24, 13, 0, -24 },
  { 1704, 13, 24, 18, 2, -24 },
  { 1743, 15, 24, 15, 0, -24 },
  { 1788, 24, 24, 24, 0, -24 },
  { 1860, 13, 24, 14, 0, -24 },
  { 1899, 13, 24, 13, 0, -24 },
  { 1938, 11, 24, 12, 1, -24 },
  { 1971, 8, 29, 11, 2, -24 },
  { 2000, 11, 24, 13, 1, -24 },
  { 2033, 7, 29, 11, 1, -24 },
  { 2059, 14, 13, 15, 1, -24 },
  { 2082, 15, 2, 15, 0, 3 },
  { 2086, 7, 5, 9, 1, -26 },
  { 2091, 11, 19, 14, 1, -19 },
  { 2118, 12, 26, 16, 2, -26 },
  { 2157, 10, 19, 12, 1, -19 },
  { 2181, 13, 26, 16, 1, -26 },
  { 2224, 12, 19, 14, 1, -19 },
  { 2253, 9, 26, 9, 0, -26 },
  { 2283, 13, 27, 16, 1, -19 },
  { 2327, 11, 26, 16, 2, -26 },
  { 2363, 3, 25, 7, 2, -25 },
  { 2373, 5, 33, 7, 0, -25 },
  { 2394, 11, 26, 14, 2, -26 },
  { 2430, 3, 26, 7, 2, -26 },
  { 2440, 19, 19, 23, 2, -19 },
  { 2486, 11, 19, 16, 2, -19 },
  { 2513, 13, 19, 15, 1, -19 },
  { 2544, 12, 27, 16, 2, -19 },
  { 2585, 13, 27, 16, 1, -19 },
  { 2629, 8, 19, 10, 2, -19 },
  { 2648, 9, 19, 12, 1, -19 },
  { 2670, 7, 22, 9, 1, -22 },
  { 2690, 11, 18, 16, 2, -18 },
  { 2715, 12, 18, 13, 0, -18 },
  { 2742, 20, 18, 21, 0, -18 },
  { 2787, 12, 18, 13, 0, -18 },
  { 2814, 12, 26, 13, 0, -18 },
  { 2853, 9, 18, 10, 1, -18 },
  { 2874, 10, 29, 12, 1, -24 },
  { 2911, 2, 34, 14, 6, -26 },
  { 2920, 10, 29, 12, 1, -24 },
  { 2957, 13, 4, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Regular34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR34PT7B_H_
