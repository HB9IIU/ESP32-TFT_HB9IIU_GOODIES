#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7E, 0x7E, 0x18, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80,
  0xF9, 0xE0, 0x3E, 0x78, 0x07, 0x9E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x7F, 0x38, 0x3C, 0x7C, 0x38, 0x08, 0xFC, 0x38, 0x00,
  0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00,
  0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xFC, 0x38, 0x00,
  0x7E, 0x38, 0x00, 0x7F, 0xB8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x39, 0xFC, 0x00, 0x38, 0x7E, 0x00, 0x38, 0x3E,
  0x00, 0x38, 0x3E, 0x00, 0x38, 0x3E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1F,
  0x00, 0x38, 0x1E, 0x00, 0x38, 0x3E, 0x00, 0x38, 0x3E, 0x80, 0x38, 0x7E,
  0xE0, 0x38, 0xFC, 0xFE, 0x3F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x1F,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1E,
  0x01, 0xE0, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xE0,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0xF0,
  0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0x0F,
  0x80, 0x00, 0xF0, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x1F, 0x07, 0xC0, 0xF8, 0x1E,
  0x1E, 0x0F, 0xE0, 0xF8, 0x1E, 0x3E, 0x1F, 0xF0, 0xF8, 0x3E, 0x3E, 0x3F,
  0xF8, 0x78, 0x3E, 0x3C, 0x7E, 0xFC, 0x78, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0x3C, 0x3F, 0xF8, 0x78, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8,
  0xF8, 0x3E, 0x1F, 0xF0, 0xF0, 0xF0, 0x3E, 0x07, 0xE0, 0xF0, 0xF0, 0x1E,
  0x00, 0x01, 0xF0, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x0F, 0x80,
  0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x00, 0x3F,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x07,
  0xE0, 0xFC, 0xFC, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x0F, 0xC1, 0xF8, 0x3E,
  0x1F, 0x81, 0xF8, 0x7C, 0x3E, 0x03, 0xF1, 0xF8, 0xFC, 0x03, 0xF3, 0xF1,
  0xF8, 0x07, 0xE7, 0xC3, 0xF0, 0x07, 0xFF, 0x87, 0xE0, 0x07, 0xFF, 0x0F,
  0xC0, 0x0F, 0xFC, 0x1F, 0x80, 0x0F, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x81, 0xF8,
  0x03, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x7E, 0x07, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xC0, 0xFE, 0x07, 0xFF,
  0x00, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE0, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x38, 0x3E, 0x0E, 0x7F, 0x39, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F,
  0x8F, 0x80, 0x3F, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xE0,
  0x38, 0x00, 0x40, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0x10, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0xF8,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xFC, 0x1F, 0x81, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xDF, 0x1F, 0xDF, 0x3F, 0xBF, 0x7F, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F,
  0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7E, 0x03, 0xFC, 0x3C, 0x01, 0xFC, 0x10, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7E, 0x03, 0xFC, 0x38, 0x00, 0xFC,
  0x10, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x80, 0x00, 0xFE,
  0x70, 0x01, 0xFC, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xEF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x38, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFA, 0x00, 0x0F, 0xE7, 0x00,
  0x3F, 0xCF, 0xC3, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x01,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x78, 0x07, 0xE3, 0xFE, 0x0F, 0xCF, 0xFE, 0x1F, 0xBF, 0xFE, 0x3E, 0xFF,
  0xFE, 0x7D, 0xF3, 0xFC, 0xFF, 0x81, 0xFD, 0xFE, 0x01, 0xFB, 0xF8, 0x01,
  0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC,
  0x0F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFC, 0x07, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0xC1,
  0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xFC,
  0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0xFE, 0x1F,
  0x80, 0xFE, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xBF, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFB, 0xF1, 0xFF, 0xE7, 0xE1, 0xFF, 0x8F, 0x80, 0xFE, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0x8F, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC2, 0x00, 0x0E, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0x7E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xF0, 0x3F, 0x88, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0xFE, 0x0F, 0x8F,
  0x80, 0x7F, 0xF8, 0x1E, 0x3E, 0x03, 0xFF, 0xE0, 0x78, 0xF0, 0x1F, 0x8F,
  0x81, 0xF7, 0xC0, 0x7C, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0xF8, 0x1F, 0x7C,
  0x0F, 0x03, 0xE0, 0x7D, 0xE0, 0x7C, 0x0F, 0x80, 0xF7, 0x81, 0xF0, 0x3E,
  0x03, 0xDE, 0x07, 0xC0, 0xF8, 0x0F, 0xF8, 0x1E, 0x03, 0xE0, 0x3F, 0xE0,
  0x78, 0x0F, 0x80, 0xFF, 0x81, 0xE0, 0x3E, 0x03, 0xFE, 0x07, 0x80, 0xF8,
  0x0F, 0xF8, 0x1E, 0x03, 0xE0, 0x7F, 0xE0, 0x78, 0x0F, 0x81, 0xFF, 0x81,
  0xE0, 0x3E, 0x07, 0xFE, 0x07, 0x80, 0xF8, 0x1F, 0xF8, 0x1E, 0x07, 0xE0,
  0x7B, 0xE0, 0x7C, 0x1F, 0x81, 0xEF, 0x81, 0xF0, 0x7E, 0x0F, 0x9E, 0x07,
  0xC1, 0xB8, 0x3E, 0x78, 0x0F, 0x8E, 0xF1, 0xF1, 0xF0, 0x3F, 0xFB, 0xFF,
  0xC7, 0xC0, 0x7F, 0xC7, 0xFE, 0x1F, 0x00, 0xFF, 0x1F, 0xF0, 0x3C, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x1F, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x07,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xE0, 0x7F, 0xE3, 0xF0, 0x07, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0,
  0x3F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0x1F, 0x80, 0x1F, 0xCF,
  0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80,
  0x3F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0x01, 0xC0, 0x7F, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x04, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0xFF,
  0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC3, 0xF0,
  0x07, 0xF8, 0x7E, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x03, 0x03, 0xFC, 0x00, 0x04, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01,
  0xF7, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F,
  0xC0, 0x00, 0x7C, 0x3F, 0x80, 0x01, 0xF0, 0x7F, 0x00, 0x07, 0xC1, 0xFF,
  0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x87, 0xF7, 0xFF, 0xBF,
  0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0xFC,
  0x00, 0xFF, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xBF, 0xF7, 0xC0, 0x00, 0x1F, 0x7F, 0xEF, 0x80, 0x00, 0x3E,
  0xFF, 0xDF, 0x00, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x01, 0xF3, 0xFF, 0x3E,
  0x00, 0x03, 0xE7, 0xFE, 0x7C, 0x00, 0x07, 0xDF, 0xFC, 0xF8, 0x00, 0x0F,
  0x3F, 0xF8, 0xF8, 0x00, 0x3E, 0x7F, 0xF1, 0xF0, 0x00, 0x7C, 0xFF, 0xE3,
  0xE0, 0x00, 0xF9, 0xFF, 0xC7, 0xC0, 0x03, 0xE3, 0xFF, 0x87, 0xC0, 0x07,
  0xC7, 0xFF, 0x0F, 0x80, 0x0F, 0x8F, 0xFE, 0x1F, 0x00, 0x1E, 0x1F, 0xFC,
  0x1F, 0x00, 0x7C, 0x3F, 0xF8, 0x3E, 0x00, 0xF8, 0x7F, 0xF0, 0x7C, 0x01,
  0xF0, 0xFF, 0xE0, 0xF8, 0x07, 0xC1, 0xFF, 0xC0, 0xF8, 0x0F, 0x83, 0xFF,
  0x81, 0xF0, 0x1F, 0x07, 0xFF, 0x03, 0xE0, 0x3C, 0x0F, 0xFE, 0x03, 0xE0,
  0xF8, 0x1F, 0xFC, 0x07, 0xC1, 0xF0, 0x3F, 0xF8, 0x0F, 0x83, 0xE0, 0x7F,
  0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0x1F, 0x01, 0xFF, 0xC0, 0x3E,
  0x3E, 0x03, 0xFF, 0x80, 0x7C, 0x78, 0x07, 0xFF, 0x00, 0x7D, 0xF0, 0x0F,
  0xFE, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0xF8, 0x00, 0x7F, 0xF7, 0xE0,
  0x03, 0xFF, 0x9F, 0x00, 0x1F, 0xFC, 0xF8, 0x00, 0xFF, 0xE7, 0xE0, 0x07,
  0xFF, 0x1F, 0x00, 0x3F, 0xF8, 0xFC, 0x01, 0xFF, 0xC3, 0xE0, 0x0F, 0xFE,
  0x1F, 0x80, 0x7F, 0xF0, 0xFC, 0x03, 0xFF, 0x83, 0xE0, 0x1F, 0xFC, 0x1F,
  0x80, 0xFF, 0xE0, 0x7C, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0x81,
  0xFF, 0xC0, 0x7E, 0x0F, 0xFE, 0x03, 0xF0, 0x7F, 0xF0, 0x0F, 0x83, 0xFF,
  0x80, 0x7E, 0x1F, 0xFC, 0x01, 0xF0, 0xFF, 0xE0, 0x0F, 0xC7, 0xFF, 0x00,
  0x3E, 0x3F, 0xF8, 0x01, 0xF9, 0xFF, 0xC0, 0x0F, 0xCF, 0xFE, 0x00, 0x3E,
  0x7F, 0xF0, 0x01, 0xF9, 0xFF, 0x80, 0x07, 0xCF, 0xFC, 0x00, 0x3F, 0x7F,
  0xE0, 0x01, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x8F, 0xFF, 0x3F,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F,
  0x7E, 0x01, 0xFC, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0xE1, 0xF8, 0x03,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1,
  0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x87, 0xF8, 0x3F, 0x1F, 0xC0, 0x0E, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF2, 0x00,
  0x0F, 0xE7, 0x80, 0x3F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFE, 0x01, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xBC, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x81, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFB, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7D, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x1E, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC7,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xE1,
  0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8,
  0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x3E,
  0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x1F,
  0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xC0, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x80, 0x03, 0xE1,
  0xE0, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x00, 0xF8,
  0xF8, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7C, 0x01, 0xF3, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xCF, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x0F, 0x3E, 0x00, 0x01,
  0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0,
  0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xC7, 0xF8, 0x38,
  0x07, 0xE0, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xF8, 0x1F, 0x3F, 0x80, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x07,
  0xDF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0x80,
  0xFF, 0x7F, 0x07, 0xFC, 0xFF, 0xFD, 0xF3, 0xFF, 0xE7, 0xC7, 0xFF, 0x0F,
  0x0F, 0xF8, 0x3C, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x7F, 0xE0, 0x7E,
  0x7F, 0xF8, 0x3F, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFC, 0x1F, 0xC7,
  0xFC, 0x07, 0xF3, 0xFC, 0x01, 0xF9, 0xFC, 0x00, 0x7C, 0xFE, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01,
  0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF,
  0xF0, 0x07, 0xE7, 0xF8, 0x03, 0xF3, 0xFE, 0x03, 0xF9, 0xFF, 0xC3, 0xF8,
  0xF9, 0xFF, 0xF8, 0x7C, 0xFF, 0xFC, 0x3E, 0x3F, 0xFC, 0x1F, 0x07, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x81, 0x8F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0x1F, 0xE1, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x1F, 0x07,
  0xFE, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F,
  0x81, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x00, 0xFF, 0x3F, 0xC3, 0xFF, 0x1F,
  0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFF, 0x1F, 0x03, 0xFE, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFC, 0xFF, 0x07, 0xF0, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x00,
  0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03,
  0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0x1F, 0xC0, 0x0C, 0x1F, 0xE0,
  0x78, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFF, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF,
  0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x00,
  0xFF, 0x3F, 0xC3, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFF,
  0x1F, 0x03, 0xFE, 0x1F, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x20, 0x00, 0xFC, 0x38, 0x01,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0xE0, 0xFC, 0x7F, 0xE1, 0xF9, 0xFF, 0xE3, 0xF7, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFC, 0x1F, 0xDF, 0xF0, 0x1F, 0xBF, 0xC0, 0x3F, 0x7F, 0x00,
  0x3E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x7B, 0xFF,
  0xFF, 0xFF, 0xF7, 0xC4, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFD,
  0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0x7F, 0x00,
  0x7E, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFE, 0xF8, 0x07,
  0xF9, 0xF8, 0x0F, 0xF1, 0xF0, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xE0,
  0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xE1, 0xFF, 0x83,
  0xFF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFF, 0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0xFB,
  0xFF, 0xFB, 0xFF, 0xFB, 0xFE, 0x0F, 0xFE, 0x0F, 0xEF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xBF, 0x80, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x01,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0xF8, 0x3F, 0xC1, 0xF0, 0xFF, 0xC3, 0xE3, 0xFF, 0xC7, 0xCF, 0xFF, 0xCF,
  0xBF, 0xFF, 0x9F, 0xF8, 0x3F, 0xBF, 0xC0, 0x3F, 0x7F, 0x80, 0x7E, 0xFE,
  0x00, 0x7D, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x80, 0xFC, 0x1F,
  0xC3, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x1F, 0xC0, 0x7C, 0x3F, 0xF0, 0x3E,
  0x3F, 0xFC, 0x1F, 0x3F, 0xFF, 0x0F, 0xBF, 0xFF, 0xC7, 0xFC, 0x07, 0xE3,
  0xFC, 0x01, 0xF9, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x3E, 0x7F, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7,
  0xF8, 0x03, 0xF3, 0xFC, 0x01, 0xF9, 0xFF, 0x01, 0xF8, 0xFF, 0xE1, 0xFC,
  0x7E, 0xFF, 0xFC, 0x3F, 0x7F, 0xFE, 0x1F, 0x9F, 0xFE, 0x0F, 0xC3, 0xFE,
  0x07, 0xE0, 0x78, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F,
  0x1F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x3F, 0x00, 0xFF,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF,
  0x3F, 0x00, 0xFF, 0x3F, 0xC3, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F,
  0x07, 0xFF, 0x1F, 0x03, 0xFE, 0x1F, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF9, 0xFF, 0xF9, 0xFE, 0xFB, 0xFE, 0xFB, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFC, 0x03, 0x1F, 0x00,
  0x27, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7E,
  0xFC, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xC0,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xFE, 0x3F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE3, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x70, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xF7, 0xC0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xDF, 0x80, 0x7F, 0xBF, 0x81, 0xFF, 0x3F, 0x8F, 0xBE, 0x7F, 0xFE,
  0x7C, 0x7F, 0xFC, 0xF8, 0xFF, 0xF1, 0xF0, 0x7F, 0xC3, 0xE0, 0x1C, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0,
  0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFE, 0x00, 0x3E,
  0xFC, 0x00, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x7C, 0x01,
  0xFF, 0x00, 0x7C, 0x7C, 0x01, 0xFF, 0x00, 0x7C, 0x7E, 0x01, 0xEF, 0x00,
  0x7C, 0x7E, 0x01, 0xEF, 0x00, 0xFC, 0x3E, 0x01, 0xEF, 0x00, 0xFC, 0x3E,
  0x03, 0xEF, 0x80, 0xF8, 0x3E, 0x03, 0xEF, 0x80, 0xF8, 0x3F, 0x03, 0xEF,
  0x80, 0xF8, 0x3F, 0x03, 0xE7, 0x81, 0xF8, 0x1F, 0x03, 0xC7, 0x81, 0xF0,
  0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x1F, 0x87,
  0xC7, 0xC1, 0xF0, 0x1F, 0x87, 0xC3, 0xC3, 0xF0, 0x0F, 0x87, 0x83, 0xC3,
  0xE0, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0x07, 0xCF, 0x81, 0xE7, 0xC0, 0x07, 0xCF, 0x01,
  0xE7, 0xC0, 0x07, 0xCF, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x03, 0xFE,
  0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x3E,
  0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x00,
  0xF8, 0x7C, 0x01, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0,
  0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03,
  0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x9F, 0xFC, 0x00, 0x5F, 0xFF, 0x80, 0xFF, 0xFF, 0xF9, 0xFF,
  0xDF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0x00, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 50, 16, 4, -49 },
  { 51, 18, 18, 26, 4, -49 },
  { 92, 29, 49, 31, 1, -49 },
  { 270, 24, 56, 29, 3, -52 },
  { 438, 40, 50, 45, 3, -49 },
  { 688, 31, 50, 32, 2, -49 },
  { 882, 6, 18, 14, 4, -49 },
  { 896, 15, 60, 20, 3, -49 },
  { 1009, 14, 60, 20, 2, -49 },
  { 1114, 23, 23, 27, 2, -52 },
  { 1181, 25, 32, 29, 2, -40 },
  { 1281, 10, 17, 15, 2, -8 },
  { 1303, 15, 5, 19, 2, -21 },
  { 1313, 7, 9, 15, 4, -8 },
  { 1321, 23, 49, 25, 1, -49 },
  { 1462, 23, 50, 29, 3, -49 },
  { 1606, 16, 49, 29, 4, -49 },
  { 1704, 24, 49, 29, 2, -49 },
  { 1851, 24, 50, 29, 2, -49 },
  { 2001, 27, 49, 29, 1, -49 },
  { 2167, 23, 50, 29, 3, -49 },
  { 2311, 23, 50, 29, 3, -49 },
  { 2455, 25, 49, 29, 2, -49 },
  { 2609, 25, 50, 29, 2, -49 },
  { 2766, 23, 50, 29, 3, -49 },
  { 2910, 7, 38, 16, 4, -37 },
  { 2944, 10, 46, 16, 2, -37 },
  { 3002, 25, 30, 29, 2, -39 },
  { 3096, 25, 20, 29, 2, -34 },
  { 3159, 25, 30, 29, 2, -39 },
  { 3253, 19, 50, 22, 1, -49 },
  { 3372, 38, 55, 44, 3, -49 },
  { 3634, 31, 49, 31, 0, -49 },
  { 3824, 25, 49, 32, 5, -49 },
  { 3978, 26, 50, 30, 3, -49 },
  { 4141, 27, 49, 35, 5, -49 },
  { 4307, 19, 49, 27, 5, -49 },
  { 4424, 19, 49, 26, 5, -49 },
  { 4541, 30, 50, 37, 3, -49 },
  { 4729, 26, 49, 36, 5, -49 },
  { 4889, 15, 49, 19, 2, -49 },
  { 4981, 13, 62, 15, -3, -49 },
  { 5082, 26, 49, 30, 5, -49 },
  { 5242, 19, 49, 25, 5, -49 },
  { 5359, 39, 49, 49, 5, -49 },
  { 5598, 29, 49, 39, 5, -49 },
  { 5776, 31, 50, 37, 3, -49 },
  { 5970, 23, 49, 30, 5, -49 },
  { 6111, 31, 61, 37, 3, -49 },
  { 6348, 25, 49, 31, 5, -49 },
  { 6502, 23, 50, 28, 3, -49 },
  { 6646, 24, 49, 26, 1, -49 },
  { 6793, 26, 50, 36, 5, -49 },
  { 6956, 30, 49, 30, 0, -49 },
  { 7140, 49, 49, 49, 0, -49 },
  { 7441, 27, 49, 27, 0, -49 },
  { 7607, 27, 49, 27, 0, -49 },
  { 7773, 21, 49, 25, 2, -49 },
  { 7902, 14, 60, 21, 5, -49 },
  { 8007, 23, 49, 25, 1, -49 },
  { 8148, 14, 60, 21, 2, -49 },
  { 8253, 28, 25, 30, 1, -48 },
  { 8341, 30, 4, 30, 0, 6 },
  { 8356, 12, 11, 18, 3, -52 },
  { 8373, 22, 38, 28, 2, -37 },
  { 8478, 25, 53, 31, 4, -52 },
  { 8644, 19, 38, 24, 3, -37 },
  { 8735, 24, 53, 31, 3, -52 },
  { 8894, 23, 38, 28, 3, -37 },
  { 9004, 18, 52, 17, 1, -52 },
  { 9121, 24, 53, 31, 3, -37 },
  { 9280, 23, 52, 31, 4, -52 },
  { 9430, 6, 50, 14, 4, -50 },
  { 9468, 11, 66, 14, -1, -50 },
  { 9559, 23, 52, 27, 4, -52 },
  { 9709, 6, 52, 14, 4, -52 },
  { 9748, 38, 37, 46, 4, -37 },
  { 9924, 23, 37, 31, 4, -37 },
  { 10031, 24, 38, 30, 3, -37 },
  { 10145, 25, 53, 31, 4, -37 },
  { 10311, 24, 53, 31, 3, -37 },
  { 10470, 16, 37, 21, 4, -37 },
  { 10544, 19, 38, 23, 2, -37 },
  { 10635, 16, 46, 18, 1, -45 },
  { 10727, 23, 38, 31, 4, -37 },
  { 10837, 25, 37, 25, 0, -37 },
  { 10953, 40, 37, 41, 1, -37 },
  { 11138, 23, 37, 25, 1, -37 },
  { 11245, 25, 53, 25, 0, -37 },
  { 11411, 17, 37, 21, 2, -37 },
  { 11490, 19, 60, 25, 3, -49 },
  { 11633, 5, 68, 28, 11, -52 },
  { 11676, 19, 60, 25, 3, -49 },
  { 11819, 25, 8, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Regular68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR68PT7B_H_
