#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x00, 0x27, 0xFF, 0xFF,
  0xFF, 0xE4, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF, 0x83, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1,
  0xE7, 0x83, 0xCF, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07,
  0x83, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xF0, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0F, 0x00,
  0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xE0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x38,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0x9C, 0x19, 0xE3, 0x80,
  0x7C, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x87, 0x00,
  0xF8, 0xE0, 0x0F, 0x9C, 0x01, 0xFB, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1C, 0xF8,
  0x03, 0x8F, 0x80, 0x70, 0xF0, 0x0E, 0x1E, 0x01, 0xC1, 0xC0, 0x38, 0x38,
  0x07, 0x0F, 0x00, 0xE1, 0xF0, 0x1C, 0x7F, 0xC3, 0x9F, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF8, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0x80, 0x3F, 0xE0, 0x07, 0x00, 0x3D, 0xE0, 0x0F,
  0x00, 0x78, 0xF0, 0x0F, 0x00, 0x78, 0x70, 0x0E, 0x00, 0x70, 0x70, 0x1E,
  0x00, 0x70, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1C, 0x00, 0xF0, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x38, 0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x78,
  0x00, 0xF0, 0x78, 0x70, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0xF0,
  0x00, 0xF0, 0x78, 0xE1, 0xF0, 0x70, 0x79, 0xE3, 0xFC, 0x70, 0x71, 0xE7,
  0xFC, 0x78, 0x71, 0xC7, 0x9E, 0x78, 0xF3, 0xC7, 0x0E, 0x3F, 0xE3, 0xCF,
  0x0F, 0x3F, 0xE3, 0x8F, 0x0F, 0x1F, 0xC7, 0x8E, 0x0F, 0x07, 0x07, 0x8E,
  0x0F, 0x00, 0x07, 0x0E, 0x0F, 0x00, 0x0F, 0x0E, 0x07, 0x00, 0x0F, 0x0E,
  0x07, 0x00, 0x0E, 0x0E, 0x07, 0x00, 0x1E, 0x0E, 0x07, 0x00, 0x1C, 0x0E,
  0x0F, 0x00, 0x3C, 0x0E, 0x0F, 0x00, 0x3C, 0x0E, 0x0F, 0x00, 0x38, 0x0F,
  0x0F, 0x00, 0x78, 0x0F, 0x0F, 0x00, 0x78, 0x0F, 0x0E, 0x00, 0x70, 0x07,
  0x9E, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3E, 0x3E,
  0xF8, 0x3E, 0x7C, 0x7C, 0x3E, 0x78, 0x7C, 0x3C, 0xF8, 0x3E, 0x3C, 0xF8,
  0x1E, 0x7C, 0xF0, 0x1F, 0x7C, 0xF0, 0x0F, 0xF8, 0xF0, 0x0F, 0xF8, 0xF0,
  0x07, 0xF8, 0xF0, 0x03, 0xF0, 0xF0, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xF8,
  0x07, 0xF8, 0x7C, 0x1F, 0xF8, 0x7F, 0xFF, 0x7C, 0x3F, 0xFE, 0x7E, 0x3F,
  0xFC, 0x3E, 0x0F, 0xF0, 0x1F, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x01, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x10, 0x78, 0x27, 0x9E,
  0x7B, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0xF8, 0x78, 0x3E, 0x1F, 0x03,
  0x03, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x11, 0xFF, 0xFF, 0xFF, 0xF7, 0x84, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x81, 0xFB, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xE1, 0xE0, 0x3E, 0x7C,
  0x03, 0xCF, 0x80, 0x79, 0xF0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80,
  0x3E, 0xF0, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0xC7, 0x80,
  0xF8, 0xF8, 0x1E, 0x1F, 0x87, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x8F, 0xFC, 0xFD, 0xEF, 0xCF, 0xFC, 0x7B, 0xC3, 0xCC, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xE7, 0xF8, 0xE0, 0x1F,
  0x08, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xC3, 0xF8, 0xE0, 0x1F, 0x88,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFA, 0x00, 0x1F, 0x60, 0x07, 0xCF, 0xEF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x77, 0xC0,
  0x01, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x39, 0xF0, 0x01, 0xE7, 0xC0, 0x07,
  0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1F,
  0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x1F, 0x03,
  0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x00,
  0x7C, 0x3C, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x80, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xA0, 0x07, 0xEC, 0x03, 0xF3, 0xF7, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x08, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x79, 0xFE, 0x0F,
  0x7F, 0xE1, 0xEF, 0xFE, 0x7F, 0x87, 0xEF, 0xE0, 0x7D, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C,
  0x03, 0xE7, 0x80, 0x7C, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC7,
  0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3E,
  0x78, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x7C, 0x3E, 0x07,
  0xC1, 0xF0, 0xF8, 0x1F, 0x9F, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x1F, 0x83, 0xE0, 0xF8, 0x7C,
  0x07, 0xC7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E,
  0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7F, 0x9F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFF, 0x83, 0xF3, 0xF8, 0xFC, 0x1F, 0x1F, 0x01, 0xE3, 0xC0,
  0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7D, 0xE0, 0x1F, 0xBE, 0x03, 0xF7, 0xE0, 0xFE, 0x7F, 0xFB, 0xCF, 0xFF,
  0xF8, 0xFF, 0xDF, 0x0F, 0xF3, 0xE0, 0x10, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x31, 0xFF, 0xFF, 0xFD,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x7F, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x18, 0x3E, 0x7E, 0x7E,
  0x7E, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE7, 0xFF,
  0xE7, 0x8F, 0xCC, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x02, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0xFC, 0x1E, 0x78, 0x0F, 0xFC, 0x39, 0xE0,
  0x7F, 0xE0, 0xF7, 0x03, 0xE3, 0x83, 0xFC, 0x1E, 0x0E, 0x0F, 0xF0, 0x78,
  0x78, 0x3F, 0xC1, 0xE1, 0xE0, 0x7F, 0x0F, 0x07, 0x81, 0xFC, 0x3C, 0x1E,
  0x07, 0xE0, 0xF0, 0x78, 0x1F, 0x83, 0xC1, 0xE0, 0x7E, 0x0F, 0x07, 0x81,
  0xF8, 0x3C, 0x1E, 0x07, 0xE0, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xE0, 0xFE,
  0x0F, 0x07, 0x83, 0xF8, 0x3C, 0x1E, 0x0F, 0xF0, 0xF0, 0xF8, 0x3B, 0xC1,
  0xE3, 0x71, 0xEF, 0x07, 0xFD, 0xFF, 0x3C, 0x0F, 0xF3, 0xFC, 0xF0, 0x1F,
  0x8F, 0xE1, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x80, 0x0F, 0xC0, 0x0C, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x83,
  0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF0,
  0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3E, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8,
  0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xF8, 0x7F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xF3, 0xE1, 0xF8, 0x02, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x02, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xF8, 0x1F, 0xC3,
  0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x3F, 0x0F, 0x83, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8,
  0x7E, 0x0F, 0xC0, 0x0C, 0x1F, 0x80, 0x04, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x05,
  0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xBF, 0xF7,
  0xFC, 0xFF, 0x07, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF7, 0x80, 0x01, 0xFF, 0xF7, 0x80, 0x03,
  0xDF, 0xF7, 0x80, 0x03, 0xDF, 0xF3, 0xC0, 0x03, 0xDF, 0xF3, 0xC0, 0x03,
  0xDF, 0xF3, 0xC0, 0x07, 0x9F, 0xF3, 0xC0, 0x07, 0x9F, 0xF1, 0xE0, 0x07,
  0x9F, 0xF1, 0xE0, 0x0F, 0x1F, 0xF1, 0xE0, 0x0F, 0x1F, 0xF0, 0xF0, 0x0F,
  0x1F, 0xF0, 0xF0, 0x0F, 0x1F, 0xF0, 0xF0, 0x1E, 0x1F, 0xF0, 0xF0, 0x1E,
  0x1F, 0xF0, 0x78, 0x1E, 0x1F, 0xF0, 0x78, 0x3C, 0x1F, 0xF0, 0x78, 0x3C,
  0x1F, 0xF0, 0x3C, 0x3C, 0x1F, 0xF0, 0x3C, 0x3C, 0x1F, 0xF0, 0x3C, 0x78,
  0x1F, 0xF0, 0x3C, 0x78, 0x1F, 0xF0, 0x1E, 0x78, 0x1F, 0xF0, 0x1E, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x07, 0xE0,
  0x1F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xC0,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFB, 0xC0, 0x0F,
  0xF7, 0x80, 0x1F, 0xEF, 0x80, 0x3F, 0xCF, 0x00, 0x7F, 0x9F, 0x00, 0xFF,
  0x1E, 0x01, 0xFE, 0x3C, 0x03, 0xFC, 0x7C, 0x07, 0xF8, 0x78, 0x0F, 0xF0,
  0xF8, 0x1F, 0xE0, 0xF0, 0x3F, 0xC1, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x03,
  0xC1, 0xFE, 0x07, 0xC3, 0xFC, 0x07, 0x87, 0xF8, 0x0F, 0x8F, 0xF0, 0x0F,
  0x1F, 0xE0, 0x1F, 0x3F, 0xC0, 0x3E, 0x7F, 0x80, 0x3C, 0xFF, 0x00, 0x7D,
  0xFE, 0x00, 0x7B, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFC, 0x07,
  0xC0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x7C,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF3, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03,
  0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x7E,
  0x7C, 0x7F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x9F, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x81, 0xF8, 0x7C,
  0x07, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x1F, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFC, 0x03, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xFA, 0x00, 0x3F, 0x78, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0x81, 0xFF, 0xC0, 0x02, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x04,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00,
  0x78, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3,
  0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xE0, 0x03, 0xCF, 0x80,
  0x1F, 0xC0, 0x07, 0x8F, 0x00, 0x3F, 0x80, 0x1F, 0x1E, 0x00, 0x7F, 0x80,
  0x3E, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x7C, 0x01, 0xDE, 0x00, 0xF0, 0xF8,
  0x07, 0xBC, 0x01, 0xE0, 0xF0, 0x0F, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x78,
  0x0F, 0x83, 0xE0, 0x3C, 0xF0, 0x1F, 0x07, 0xC0, 0x79, 0xE0, 0x3C, 0x0F,
  0x81, 0xE3, 0xC0, 0x78, 0x0F, 0x03, 0xC7, 0x81, 0xF0, 0x1E, 0x07, 0x87,
  0x83, 0xE0, 0x3E, 0x0F, 0x0F, 0x07, 0xC0, 0x7C, 0x1E, 0x1E, 0x0F, 0x00,
  0x78, 0x78, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x78, 0x7C, 0x01, 0xE1, 0xE0,
  0x78, 0xF8, 0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x07, 0xC7, 0x81, 0xE3, 0xC0,
  0x07, 0x9E, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x07, 0x9F, 0x00, 0x1E, 0x78,
  0x07, 0x3E, 0x00, 0x3C, 0xF0, 0x0F, 0x7C, 0x00, 0x7D, 0xE0, 0x1E, 0xF0,
  0x00, 0x7B, 0x80, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x1F, 0x1F,
  0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF8, 0x01,
  0xF1, 0xE0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x3C, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x3C,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFD,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x7C, 0x0F,
  0x00, 0xF0, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x1E, 0x3E, 0x00,
  0x7C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0x78,
  0x3C, 0x00, 0xF8, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0xC0, 0x01, 0xEF,
  0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xC0,
  0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0x81, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xCF, 0x7E, 0x07,
  0xBE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xDF, 0x0F, 0xEF, 0xFE, 0x73,
  0xFE, 0x38, 0xFE, 0x1C, 0x18, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x0F,
  0x81, 0xE7, 0xFC, 0x3D, 0xFF, 0xC7, 0xBF, 0xFC, 0xFE, 0x0F, 0x9F, 0x80,
  0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x1F,
  0x3F, 0xC7, 0xE7, 0xBF, 0xF8, 0xE3, 0xFF, 0x1C, 0x3F, 0x80, 0x00, 0x80,
  0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x06, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x01, 0x1F, 0xCF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF1, 0xF0,
  0xFF, 0x9F, 0x1F, 0xFD, 0xF1, 0xFF, 0xEF, 0x3F, 0x0F, 0xF3, 0xE0, 0x7F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x3C, 0x03, 0xF3,
  0xE0, 0x7F, 0x3F, 0x9E, 0xF1, 0xFF, 0xEF, 0x0F, 0xFC, 0xF0, 0x7F, 0x8F,
  0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x0F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x18, 0x7F, 0x1F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFE, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x03, 0xF0, 0xF0, 0xFF, 0x8F, 0x0F, 0xFC, 0xF1, 0xFF, 0xEF, 0x3F, 0x0F,
  0xF3, 0xE0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F,
  0x3C, 0x03, 0xF3, 0xE0, 0x7F, 0x3F, 0x9E, 0xF1, 0xFF, 0xCF, 0x0F, 0xFD,
  0xF0, 0x7F, 0x1F, 0x00, 0x81, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE4, 0x00, 0x3E, 0x38,
  0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF, 0xFC,
  0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x33,
  0xFF, 0xFF, 0xBC, 0xC0, 0x00, 0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x78, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xFF, 0xDF, 0xEF,
  0xE7, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x01, 0xF3,
  0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF0,
  0xF0, 0x3C, 0x7C, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x83,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0,
  0x1E, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8,
  0x0F, 0xC3, 0x8F, 0xF8, 0x7F, 0xCE, 0x7F, 0xE3, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFE, 0xFE, 0x1F, 0x70, 0xFB, 0xF0, 0x3F, 0x81, 0xFF, 0x80, 0xFC, 0x07,
  0xFE, 0x03, 0xF0, 0x1F, 0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x1E, 0x00, 0xFF,
  0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0,
  0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07,
  0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03,
  0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF,
  0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0,
  0x1E, 0x00, 0xF0, 0xE0, 0xF8, 0x38, 0xFF, 0x8E, 0x7F, 0xF3, 0xFF, 0xFC,
  0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x07, 0xC3,
  0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0x80, 0x1F,
  0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0xDF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x20, 0x00, 0xE0, 0xF8, 0x1C, 0x7F, 0xC3, 0x9F, 0xFC,
  0x7B, 0xFF, 0xCF, 0xE0, 0xF9, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF7,
  0xC0, 0x3E, 0xFC, 0x07, 0xDF, 0x81, 0xF3, 0xFE, 0xFE, 0x7B, 0xFF, 0x8F,
  0x3F, 0xF1, 0xE3, 0xF8, 0x3C, 0x08, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0xF0, 0x7F, 0x8F, 0x0F, 0xFC, 0xF1, 0xFF, 0xEF, 0x3F, 0x0F,
  0xF3, 0xE0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F,
  0x3C, 0x03, 0xF3, 0xE0, 0x7F, 0x3F, 0x9E, 0xF1, 0xFF, 0xCF, 0x0F, 0xFD,
  0xF0, 0x7F, 0x1F, 0x00, 0x81, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0xE0, 0xFE, 0x3F, 0xE7, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xF0, 0x3F,
  0xF8, 0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0xDF, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFB, 0xF7, 0xF7,
  0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x91, 0xFF, 0x0F,
  0xF0, 0x7F, 0x00, 0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x01, 0xFB, 0xC0,
  0x3F, 0x7C, 0x07, 0xEF, 0x81, 0xFC, 0xFD, 0xFF, 0x9F, 0xFC, 0xF1, 0xFF,
  0x9E, 0x1F, 0xC3, 0xC0, 0x60, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE3,
  0xC0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF8, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x39,
  0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x0F, 0xBC, 0x01, 0xF0, 0x07, 0xDE, 0x00, 0xFC, 0x03, 0xCF, 0x80, 0x7E,
  0x01, 0xE7, 0xC0, 0x7F, 0x00, 0xF1, 0xE0, 0x3F, 0x80, 0xF8, 0xF0, 0x1D,
  0xC0, 0x78, 0x78, 0x0E, 0xF0, 0x3C, 0x3E, 0x07, 0x78, 0x1E, 0x1F, 0x07,
  0xBC, 0x0F, 0x07, 0x83, 0xDE, 0x0F, 0x83, 0xC1, 0xE7, 0x07, 0x81, 0xE0,
  0xE3, 0xC3, 0xC0, 0xF8, 0xF1, 0xE1, 0xE0, 0x7C, 0x78, 0xF0, 0xF0, 0x1E,
  0x3C, 0x78, 0xF8, 0x0F, 0x1E, 0x1C, 0x78, 0x07, 0x8E, 0x0F, 0x3C, 0x03,
  0xEF, 0x07, 0x9E, 0x00, 0xF7, 0x83, 0xCF, 0x00, 0x7B, 0xC1, 0xEF, 0x00,
  0x3D, 0xE0, 0xF7, 0x80, 0x1E, 0xE0, 0x3B, 0xC0, 0x0F, 0x70, 0x1D, 0xE0,
  0x03, 0xB8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xEF, 0x00, 0xF9, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF8, 0xF0, 0x0F, 0x3E, 0x01, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xDE,
  0x00, 0xF3, 0xC0, 0x1E, 0x7C, 0x07, 0xC7, 0x80, 0xF0, 0xF8, 0x3E, 0x0F,
  0x07, 0x81, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x07,
  0xC0, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x7C,
  0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x03, 0xC1,
  0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x9F,
  0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xF8, 0x07, 0xFE, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 40, 13, 4, -39 },
  { 26, 15, 14, 21, 3, -39 },
  { 53, 23, 39, 25, 1, -39 },
  { 166, 19, 45, 24, 2, -42 },
  { 273, 32, 41, 37, 2, -40 },
  { 437, 24, 41, 26, 2, -40 },
  { 560, 5, 14, 11, 3, -39 },
  { 569, 11, 49, 16, 3, -40 },
  { 637, 11, 49, 16, 2, -40 },
  { 705, 18, 18, 22, 2, -42 },
  { 746, 20, 25, 24, 2, -32 },
  { 809, 8, 13, 12, 2, -6 },
  { 822, 13, 4, 15, 1, -17 },
  { 829, 6, 8, 12, 3, -7 },
  { 835, 19, 39, 20, 1, -39 },
  { 928, 19, 41, 24, 2, -40 },
  { 1026, 13, 39, 24, 3, -39 },
  { 1090, 19, 40, 24, 2, -40 },
  { 1185, 19, 41, 24, 2, -40 },
  { 1283, 22, 40, 24, 1, -40 },
  { 1393, 18, 40, 24, 3, -39 },
  { 1483, 19, 41, 24, 2, -40 },
  { 1581, 20, 39, 24, 2, -39 },
  { 1679, 20, 41, 24, 2, -40 },
  { 1782, 19, 41, 24, 2, -40 },
  { 1880, 6, 31, 13, 3, -30 },
  { 1904, 8, 37, 13, 2, -30 },
  { 1941, 20, 25, 24, 2, -32 },
  { 2004, 20, 15, 24, 2, -27 },
  { 2042, 20, 25, 24, 2, -32 },
  { 2105, 15, 41, 17, 1, -40 },
  { 2182, 30, 45, 36, 3, -40 },
  { 2351, 25, 39, 25, 0, -39 },
  { 2473, 20, 39, 26, 4, -39 },
  { 2571, 20, 41, 25, 3, -40 },
  { 2674, 22, 39, 28, 4, -39 },
  { 2782, 16, 39, 22, 4, -39 },
  { 2860, 16, 39, 21, 4, -39 },
  { 2938, 24, 41, 30, 3, -40 },
  { 3061, 21, 39, 29, 4, -39 },
  { 3164, 12, 39, 16, 2, -39 },
  { 3223, 11, 50, 12, -3, -39 },
  { 3292, 21, 39, 25, 4, -39 },
  { 3395, 15, 39, 20, 4, -39 },
  { 3469, 32, 39, 39, 4, -39 },
  { 3625, 23, 39, 31, 4, -39 },
  { 3738, 25, 41, 30, 3, -40 },
  { 3867, 19, 39, 24, 4, -39 },
  { 3960, 25, 49, 30, 3, -40 },
  { 4114, 21, 39, 25, 4, -39 },
  { 4217, 19, 41, 23, 2, -40 },
  { 4315, 19, 39, 21, 1, -39 },
  { 4408, 21, 40, 29, 4, -39 },
  { 4513, 24, 39, 24, 0, -39 },
  { 4630, 39, 39, 40, 0, -39 },
  { 4821, 22, 39, 22, 0, -39 },
  { 4929, 22, 39, 22, 0, -39 },
  { 5037, 18, 39, 20, 1, -39 },
  { 5125, 11, 49, 17, 4, -40 },
  { 5193, 19, 39, 20, 1, -39 },
  { 5286, 11, 49, 17, 2, -40 },
  { 5354, 23, 21, 24, 1, -39 },
  { 5415, 24, 3, 24, 0, 5 },
  { 5424, 10, 9, 15, 2, -42 },
  { 5436, 17, 31, 23, 2, -30 },
  { 5502, 19, 43, 25, 4, -42 },
  { 5605, 16, 31, 19, 2, -30 },
  { 5667, 20, 43, 25, 2, -42 },
  { 5775, 19, 31, 23, 2, -30 },
  { 5849, 15, 42, 14, 0, -42 },
  { 5928, 20, 43, 25, 2, -30 },
  { 6036, 18, 42, 25, 4, -42 },
  { 6131, 5, 41, 12, 3, -41 },
  { 6157, 9, 54, 12, -1, -41 },
  { 6218, 18, 42, 22, 4, -42 },
  { 6313, 4, 42, 12, 4, -42 },
  { 6334, 30, 30, 38, 4, -30 },
  { 6447, 18, 30, 25, 4, -30 },
  { 6515, 20, 31, 24, 2, -30 },
  { 6593, 19, 43, 25, 4, -30 },
  { 6696, 20, 43, 25, 2, -30 },
  { 6804, 12, 30, 17, 4, -30 },
  { 6849, 15, 31, 19, 2, -30 },
  { 6908, 12, 37, 14, 1, -36 },
  { 6964, 19, 31, 25, 3, -30 },
  { 7038, 20, 30, 20, 0, -30 },
  { 7113, 33, 30, 33, 0, -30 },
  { 7237, 19, 30, 21, 1, -30 },
  { 7309, 20, 43, 20, 0, -30 },
  { 7417, 15, 30, 17, 1, -30 },
  { 7474, 16, 48, 20, 2, -39 },
  { 7570, 4, 55, 22, 9, -42 },
  { 7598, 16, 48, 20, 2, -39 },
  { 7694, 20, 7, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Regular55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR55PT7B_H_
