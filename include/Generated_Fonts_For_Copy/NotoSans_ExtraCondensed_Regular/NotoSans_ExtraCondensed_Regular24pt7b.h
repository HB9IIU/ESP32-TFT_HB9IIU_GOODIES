#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xEE, 0xCD, 0x9A, 0x34, 0x48, 0x80,
  0x08, 0x81, 0x10, 0x26, 0x0C, 0xC1, 0x98, 0xFF, 0xC6, 0x40, 0x88, 0x11,
  0x02, 0x23, 0xFF, 0x7F, 0xE3, 0x30, 0x66, 0x0C, 0x81, 0x10, 0x22, 0x00,
  0x08, 0x08, 0x3F, 0x6F, 0xC8, 0xC8, 0xC8, 0xE8, 0x78, 0x3E, 0x0F, 0x0B,
  0x09, 0x09, 0x8B, 0xFE, 0x78, 0x08, 0x08, 0x70, 0x63, 0x61, 0x0C, 0x8C,
  0x32, 0x20, 0xCC, 0x83, 0x36, 0x0C, 0x91, 0x32, 0xDE, 0xDB, 0x4D, 0xC9,
  0x30, 0x6C, 0xC1, 0xB3, 0x04, 0xCC, 0x33, 0x30, 0xC4, 0xC2, 0x1A, 0x18,
  0x38, 0x3C, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xC8, 0x0F, 0x01, 0xC0,
  0x78, 0x0D, 0x9B, 0x33, 0x63, 0xCC, 0x79, 0x87, 0x31, 0xE7, 0xFE, 0x7C,
  0xE0, 0xED, 0xA4, 0x80, 0x19, 0x8C, 0xC6, 0x31, 0x98, 0xC6, 0x31, 0x8C,
  0x61, 0x8C, 0x61, 0x8C, 0x21, 0x80, 0xC3, 0x18, 0x63, 0x18, 0xC3, 0x18,
  0xC6, 0x31, 0x8C, 0xC6, 0x33, 0x19, 0x8C, 0x00, 0x18, 0x18, 0xD2, 0xFF,
  0x38, 0x2C, 0x66, 0x24, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87, 0xFC, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x00, 0x6D, 0xED, 0x80, 0xFF, 0xC0, 0x7D, 0x80,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x06,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x00, 0x3C, 0x7E, 0x67, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x7E,
  0x3C, 0x0C, 0x73, 0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x7C, 0xEE, 0x87, 0x03, 0x03, 0x03, 0x07, 0x06, 0x0E, 0x0C,
  0x18, 0x18, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x7E, 0xEE, 0x87, 0x03, 0x03,
  0x03, 0x06, 0x3C, 0x3C, 0x06, 0x03, 0x03, 0x03, 0x03, 0x07, 0xFE, 0xFC,
  0x03, 0x01, 0xC0, 0x70, 0x3C, 0x0B, 0x06, 0xC1, 0x30, 0xCC, 0x33, 0x18,
  0xC6, 0x33, 0x0C, 0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7E, 0x7E,
  0x40, 0x40, 0x40, 0xC0, 0xD0, 0xFE, 0x47, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0xFE, 0xFC, 0x1E, 0x39, 0x60, 0x60, 0x40, 0xC0, 0xDC, 0xFE, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x63, 0x7E, 0x3E, 0xFF, 0xFF, 0x03, 0x03,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x60, 0x3E, 0x33, 0xB0, 0xD8, 0x6C, 0x33, 0x19, 0x98, 0x78, 0x3C, 0x33,
  0x30, 0xD8, 0x6C, 0x1E, 0x1B, 0x0C, 0xFE, 0x3E, 0x00, 0x3C, 0x7E, 0xC7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x3B, 0x03, 0x03, 0x06, 0x06,
  0x7C, 0x78, 0x7D, 0x80, 0x00, 0x01, 0xF6, 0x7D, 0x80, 0x00, 0x01, 0xB7,
  0xB6, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x06, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x3C, 0x38, 0x70, 0x60, 0x20, 0x00, 0xFC,
  0xDC, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x20, 0xC1, 0x80, 0x00, 0x0C,
  0x18, 0x30, 0x0F, 0xC0, 0x61, 0x83, 0x03, 0x08, 0x06, 0x61, 0x99, 0x1F,
  0x2C, 0xCC, 0xB3, 0x33, 0xCC, 0xCF, 0x23, 0x3C, 0x88, 0xB3, 0x22, 0xCD,
  0x5B, 0x1D, 0xC4, 0x00, 0x18, 0x00, 0x30, 0x00, 0xF3, 0x00, 0xF8, 0x00,
  0x0E, 0x01, 0xC0, 0x38, 0x0D, 0x01, 0xB0, 0x36, 0x04, 0xC1, 0x88, 0x31,
  0x86, 0x30, 0xFE, 0x3F, 0xC6, 0x0C, 0xC1, 0x98, 0x37, 0x06, 0xC0, 0x60,
  0xFC, 0x7F, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x1D, 0xFC, 0xFE, 0x63, 0xB0,
  0xD8, 0x6C, 0x3E, 0x1B, 0x0D, 0xFE, 0xFC, 0x00, 0x1F, 0x9E, 0xDC, 0x0C,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01,
  0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x7F, 0x31, 0xD8, 0x6C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1B, 0x1D, 0xFC, 0xFC, 0x00,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0xFD, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xFE, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFD, 0xFB,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x1F, 0xE7, 0xB8, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC3, 0xF8, 0x7F, 0x01, 0xF0, 0x36, 0x06,
  0xC0, 0xCC, 0x19, 0xFF, 0x1F, 0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0x80, 0xFB, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8E,
  0xF8, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x6F, 0x60, 0xC3, 0xE1, 0xB1, 0x99, 0xCC, 0xC6, 0xC3, 0x61, 0xE0,
  0xF8, 0x7C, 0x33, 0x19, 0x8C, 0x66, 0x33, 0x1D, 0x86, 0xC3, 0x80, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x7F, 0xFE, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0B, 0xF0, 0x6F, 0xC1,
  0xBD, 0x84, 0xF6, 0x33, 0xD8, 0xCF, 0x23, 0x3C, 0xC8, 0xF3, 0x63, 0xCD,
  0x8F, 0x16, 0x3C, 0x70, 0xF1, 0xC3, 0xC3, 0x0C, 0xC0, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0xF6, 0x3D, 0x8F, 0x23, 0xCC, 0xF3, 0x3C, 0x6F, 0x1B, 0xC3,
  0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xC0, 0x1F, 0x07, 0x71, 0xC3, 0x30, 0x66,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x36, 0x0E,
  0xC1, 0x9C, 0x71, 0xFC, 0x1F, 0x00, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC6, 0xDE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F,
  0x07, 0x71, 0xC3, 0x30, 0x66, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x36, 0x0E, 0xC1, 0x9C, 0x71, 0xFC, 0x1F, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0xFC, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B, 0x0D,
  0x8C, 0xFE, 0x7C, 0x33, 0x19, 0x8C, 0x66, 0x33, 0x1D, 0x86, 0xC3, 0x80,
  0x3F, 0x7F, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x03,
  0x03, 0x03, 0x87, 0xFE, 0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0E, 0xFE, 0x7E, 0x00, 0xC0, 0xF8, 0x19,
  0x83, 0x30, 0x66, 0x18, 0xC3, 0x0C, 0x61, 0x8C, 0x33, 0x86, 0x60, 0x4C,
  0x0D, 0x81, 0xB0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0xC1, 0xE0,
  0xE0, 0xD8, 0x70, 0x6C, 0x38, 0x66, 0x16, 0x33, 0x0B, 0x19, 0x8D, 0x8C,
  0x66, 0xC6, 0x33, 0x26, 0x19, 0x1B, 0x0C, 0x8D, 0x86, 0xC6, 0xC1, 0xE3,
  0x60, 0xF0, 0xE0, 0x78, 0x70, 0x38, 0x38, 0x0C, 0x1C, 0x00, 0x61, 0xB0,
  0xCC, 0xC6, 0x63, 0x30, 0xF0, 0x78, 0x18, 0x0C, 0x0F, 0x07, 0x86, 0xC3,
  0x31, 0x99, 0x8E, 0xC3, 0xC1, 0x80, 0xC1, 0xB0, 0xD8, 0xCC, 0x63, 0x31,
  0xB0, 0xD8, 0x3C, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0xFF, 0xFC, 0x18, 0x60, 0xC3, 0x86, 0x0C, 0x30, 0x61, 0xC3,
  0x06, 0x18, 0x30, 0x7F, 0xFE, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC7, 0xFF, 0x80, 0x0C, 0x03, 0x81, 0xE0, 0x6C, 0x13, 0x0C,
  0x62, 0x19, 0x83, 0xC0, 0xC0, 0xFF, 0xFF, 0xFC, 0xE6, 0x30, 0x7C, 0xFC,
  0x18, 0x30, 0x23, 0xDF, 0xE1, 0xC3, 0x8F, 0x1F, 0x57, 0xA0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x9C, 0xBE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC7, 0xBE, 0xBC, 0x3E, 0xF9, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x81, 0x83, 0xB3, 0xE0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x19, 0xED, 0xF6,
  0xC7, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0E, 0xC7, 0x77, 0x9E,
  0xC0, 0x3C, 0x7E, 0x63, 0xC3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0x60,
  0x77, 0x3E, 0x1E, 0x68, 0xC1, 0x83, 0x0F, 0xBF, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x3D, 0xBE, 0xD8, 0xF8, 0x7C, 0x3E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF8, 0xEF, 0xB3, 0xD8, 0x0C, 0x04, 0x06,
  0x83, 0x3F, 0x0E, 0x00, 0xC1, 0x83, 0x06, 0x0C, 0x17, 0xAF, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x5D, 0x00, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6C, 0x27, 0x20, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x26, 0xEC, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xF3, 0x66, 0xD9, 0x32,
  0xC7, 0xCD, 0x99, 0xB3, 0x66, 0xC7, 0x8C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xBC, 0xF5, 0xFF, 0xB1, 0xC7, 0x8C, 0x3C, 0x61, 0xE3, 0x0F, 0x18, 0x78,
  0xC3, 0xC6, 0x1E, 0x30, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0x80, 0xBD, 0x7F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x60, 0x3C, 0x3F,
  0x18, 0xD8, 0x6C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0x98, 0xCE, 0xE3,
  0xE0, 0x9C, 0xBE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7,
  0xBE, 0xBC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3D, 0xBE, 0xD8, 0xF8,
  0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF8, 0xEF, 0xB3, 0xD8, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x9D, 0xF9, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x00, 0x7F, 0xFC, 0x30, 0xC3, 0xC7, 0x87, 0x0C, 0x38, 0xFF,
  0xF8, 0x30, 0xC3, 0x1F, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0xCF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x1F, 0xD7,
  0xA0, 0xC1, 0xE1, 0x98, 0xCC, 0x66, 0x33, 0x10, 0xD8, 0x6C, 0x36, 0x1A,
  0x07, 0x03, 0x81, 0xC0, 0xC3, 0x0D, 0x0E, 0x36, 0x38, 0xD9, 0xE3, 0x66,
  0x99, 0x9A, 0x62, 0x6D, 0x8D, 0x36, 0x3C, 0xD0, 0xF1, 0x43, 0xC7, 0x07,
  0x1C, 0x18, 0x70, 0x63, 0xB1, 0x8D, 0x86, 0xC1, 0x60, 0xE0, 0x70, 0x38,
  0x36, 0x1B, 0x18, 0xCC, 0x6E, 0x38, 0xC1, 0xE1, 0x98, 0xCC, 0x66, 0x31,
  0x10, 0xD8, 0x6C, 0x36, 0x0A, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x30, 0x78, 0x38, 0x00, 0xFF, 0xF1, 0x86, 0x30, 0xC3, 0x18, 0x63, 0x8C,
  0x3F, 0xFC, 0x0E, 0x38, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x31, 0xE3, 0x01,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xF0, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x38,
  0x38, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0x8C, 0x00, 0xF0, 0xFF,
  0xE3, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 7, 6, 9, 1, -17 },
  { 12, 11, 17, 11, 0, -17 },
  { 36, 8, 19, 10, 1, -18 },
  { 55, 14, 17, 16, 1, -17 },
  { 85, 11, 17, 11, 1, -17 },
  { 109, 3, 6, 5, 1, -17 },
  { 112, 5, 21, 7, 1, -17 },
  { 126, 5, 21, 7, 1, -17 },
  { 140, 8, 8, 10, 1, -18 },
  { 148, 9, 11, 10, 1, -14 },
  { 161, 3, 6, 5, 1, -3 },
  { 164, 5, 2, 7, 1, -7 },
  { 166, 3, 3, 5, 1, -3 },
  { 168, 9, 17, 9, 0, -17 },
  { 188, 8, 17, 10, 1, -17 },
  { 205, 6, 17, 10, 1, -17 },
  { 218, 8, 17, 10, 1, -17 },
  { 235, 8, 17, 10, 1, -17 },
  { 252, 10, 17, 10, 0, -17 },
  { 274, 8, 17, 10, 1, -17 },
  { 291, 8, 17, 10, 1, -17 },
  { 308, 8, 17, 10, 1, -17 },
  { 325, 9, 17, 10, 1, -17 },
  { 345, 8, 17, 10, 1, -17 },
  { 362, 3, 13, 5, 1, -13 },
  { 367, 3, 16, 5, 1, -13 },
  { 373, 9, 11, 10, 1, -14 },
  { 386, 9, 7, 10, 1, -12 },
  { 394, 9, 11, 10, 1, -14 },
  { 407, 7, 17, 8, 0, -17 },
  { 422, 14, 19, 16, 1, -17 },
  { 456, 11, 17, 11, 0, -17 },
  { 480, 9, 17, 11, 2, -17 },
  { 500, 9, 17, 11, 1, -17 },
  { 520, 9, 17, 12, 2, -17 },
  { 540, 7, 17, 10, 2, -17 },
  { 555, 7, 17, 9, 2, -17 },
  { 570, 11, 17, 13, 1, -17 },
  { 594, 9, 17, 13, 2, -17 },
  { 614, 5, 17, 7, 1, -17 },
  { 625, 5, 22, 5, -1, -17 },
  { 639, 9, 17, 11, 2, -17 },
  { 659, 7, 17, 9, 2, -17 },
  { 674, 14, 17, 17, 2, -17 },
  { 704, 10, 17, 14, 2, -17 },
  { 726, 11, 17, 13, 1, -17 },
  { 750, 8, 17, 11, 2, -17 },
  { 767, 11, 21, 13, 1, -17 },
  { 796, 9, 17, 11, 2, -17 },
  { 816, 8, 17, 10, 1, -17 },
  { 833, 9, 17, 9, 0, -17 },
  { 853, 9, 17, 13, 2, -17 },
  { 873, 11, 17, 11, 0, -17 },
  { 897, 17, 17, 17, 0, -17 },
  { 934, 9, 17, 10, 0, -17 },
  { 954, 9, 17, 9, 0, -17 },
  { 974, 7, 17, 9, 1, -17 },
  { 989, 5, 21, 7, 2, -17 },
  { 1003, 9, 17, 9, 0, -17 },
  { 1023, 5, 21, 7, 1, -17 },
  { 1037, 10, 9, 11, 0, -17 },
  { 1049, 11, 2, 10, 0, 2 },
  { 1052, 4, 3, 6, 1, -18 },
  { 1054, 7, 13, 10, 1, -13 },
  { 1066, 8, 18, 11, 2, -18 },
  { 1084, 7, 13, 8, 1, -13 },
  { 1096, 9, 18, 11, 1, -18 },
  { 1117, 8, 13, 10, 1, -13 },
  { 1130, 7, 18, 6, 0, -18 },
  { 1146, 9, 19, 11, 1, -13 },
  { 1168, 7, 18, 11, 2, -18 },
  { 1184, 3, 18, 5, 1, -18 },
  { 1191, 4, 24, 5, 0, -18 },
  { 1203, 7, 18, 10, 2, -18 },
  { 1219, 2, 18, 5, 2, -18 },
  { 1224, 13, 13, 16, 2, -13 },
  { 1246, 7, 13, 11, 2, -13 },
  { 1258, 9, 13, 11, 1, -13 },
  { 1273, 8, 19, 11, 2, -13 },
  { 1292, 9, 19, 11, 1, -13 },
  { 1314, 5, 13, 7, 2, -13 },
  { 1323, 6, 13, 8, 1, -13 },
  { 1333, 6, 16, 6, 0, -16 },
  { 1345, 7, 13, 11, 2, -13 },
  { 1357, 9, 13, 9, 0, -13 },
  { 1372, 14, 13, 15, 0, -13 },
  { 1395, 9, 13, 9, 0, -13 },
  { 1410, 9, 19, 9, 0, -13 },
  { 1432, 6, 13, 7, 1, -13 },
  { 1442, 7, 21, 9, 1, -17 },
  { 1461, 2, 24, 10, 4, -18 },
  { 1467, 7, 21, 9, 1, -17 },
  { 1486, 9, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Regular24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR24PT7B_H_
