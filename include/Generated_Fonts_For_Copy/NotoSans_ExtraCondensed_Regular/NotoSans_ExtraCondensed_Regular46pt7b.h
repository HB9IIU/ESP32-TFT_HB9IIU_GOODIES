#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xF0, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x07,
  0x07, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x70, 0xE0, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x38, 0x07, 0x0E, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x60,
  0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x38, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7D, 0x8E, 0xF1, 0x80, 0xF1, 0x80, 0xE1, 0x80, 0xE1, 0x80, 0xE1,
  0x80, 0xF1, 0x80, 0xF1, 0x80, 0x7D, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0x9E, 0x01, 0x8F, 0x01, 0x8F, 0x01,
  0x87, 0x01, 0x87, 0x01, 0x8F, 0x81, 0x8F, 0xC1, 0x9E, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xF0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x1F, 0x00, 0x78, 0x07, 0xF0, 0x0E, 0x01, 0xFE, 0x01,
  0xC0, 0x38, 0xE0, 0x70, 0x0E, 0x1C, 0x0E, 0x01, 0xC3, 0x81, 0xC0, 0x38,
  0x70, 0x70, 0x07, 0x0E, 0x0E, 0x00, 0xE1, 0xE1, 0xC0, 0x1C, 0x3C, 0x70,
  0x03, 0x87, 0x8E, 0x00, 0x70, 0xF3, 0xC0, 0x0E, 0x1C, 0x70, 0x01, 0xC3,
  0x8E, 0x3E, 0x38, 0x73, 0x8F, 0xE7, 0x0E, 0x73, 0xFC, 0x71, 0xCE, 0x71,
  0xCF, 0xF3, 0x8E, 0x38, 0xFE, 0x73, 0x87, 0x0F, 0x8E, 0x70, 0xE0, 0x03,
  0x8E, 0x1E, 0x00, 0x71, 0xC1, 0xC0, 0x0E, 0x38, 0x38, 0x03, 0x87, 0x07,
  0x00, 0x70, 0xE0, 0xE0, 0x0E, 0x1C, 0x3C, 0x03, 0x83, 0x87, 0x80, 0x70,
  0x70, 0xE0, 0x0E, 0x07, 0x1C, 0x03, 0x80, 0xE3, 0x80, 0x70, 0x1E, 0xE0,
  0x1E, 0x01, 0xFC, 0x03, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00,
  0x1C, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0x8F, 0x3C, 0x3C, 0x79, 0xE1, 0xC7,
  0x87, 0x8E, 0x3C, 0x3C, 0xF3, 0xC0, 0xF7, 0x9E, 0x03, 0xF8, 0xF0, 0x1F,
  0xC7, 0x80, 0x7E, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xFC, 0x3E,
  0x1F, 0xF0, 0xFF, 0xF7, 0x87, 0xFF, 0x1E, 0x0F, 0xE0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEE, 0xEE, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x08, 0x38, 0x5E, 0x67, 0xBF, 0xFF, 0x7F, 0xFF, 0x07,
  0x80, 0x1F, 0x80, 0x7B, 0x80, 0xE7, 0x83, 0xC7, 0x0F, 0x0F, 0x06, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x3C, 0xF7, 0x9E, 0x79, 0xE7, 0x3C, 0xF3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3E, 0x7C, 0x3C, 0x3C, 0x78, 0x1C, 0x78, 0x1E, 0x70, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xE0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7B, 0xDE, 0x7F, 0x8F,
  0x61, 0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0xF8, 0x7C, 0x60, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xF8, 0xFF, 0xF8, 0xF0,
  0x7C, 0x60, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF8, 0x1F, 0xF0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x80, 0x3E, 0xC0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1D, 0xE0, 0x07, 0x78, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x39, 0xE0,
  0x1C, 0x78, 0x07, 0x1E, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x70, 0x78, 0x1C,
  0x1E, 0x0E, 0x07, 0x83, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07,
  0x8E, 0x01, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x20, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x80, 0x3C,
  0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0xFC, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0x84, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0xE0, 0xF3, 0xF8,
  0xF7, 0xFC, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x7C, 0x1E, 0x3E, 0x3C, 0x1F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x70,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x3C, 0x3C, 0x3E, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x3C, 0x7C, 0x78, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x78,
  0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7C, 0x7C, 0x78, 0x3C, 0xF0, 0x1C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0x78, 0x3E, 0x7E, 0xFE, 0x3F, 0xEE, 0x1F, 0xCE, 0x0F,
  0x8E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x41, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0x77, 0xBF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x7F, 0xFF, 0xF0, 0x39, 0xE7, 0xDF, 0x7C, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF7, 0x9E, 0x79,
  0xE7, 0x3C, 0xF3, 0x8E, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0x87, 0xFF, 0x3F, 0xFD, 0xC3, 0xE4, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0x1E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x8E, 0x07, 0xF8, 0xE7, 0x83, 0xFC, 0x39, 0xC1, 0xE7, 0x0E,
  0x70, 0xF1, 0xC1, 0xDC, 0x38, 0x70, 0x77, 0x0E, 0x1C, 0x1F, 0xC3, 0x87,
  0x07, 0xE1, 0xC1, 0xC1, 0xF8, 0x70, 0x70, 0x7E, 0x1C, 0x1C, 0x1F, 0x87,
  0x07, 0x07, 0xE1, 0xC1, 0xC1, 0xF8, 0x70, 0x70, 0xEE, 0x1E, 0x3C, 0x3B,
  0xC3, 0x8F, 0x0E, 0x70, 0xE3, 0xE7, 0x9C, 0x3F, 0x9F, 0xC7, 0x07, 0xE7,
  0xE1, 0xC0, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x10, 0x03, 0xE0, 0x18, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9E, 0x00, 0x1C, 0xF0,
  0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x80,
  0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00,
  0xF8, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9E, 0x1F, 0xCF, 0x01, 0xF7,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3C, 0x07, 0xDE, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xF7, 0x83, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0x71, 0xF0, 0x10, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x0C, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x3F, 0x3C, 0x03,
  0xCF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xFB,
  0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x7F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0x83,
  0xE1, 0xF0, 0x02, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0x87, 0xE0, 0x7C, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xE3,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE1, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x7F, 0xFD, 0xFE, 0xFE, 0x7C, 0x00, 0xF0, 0x07,
  0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xDE, 0x03, 0xE7, 0x80, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0,
  0x78, 0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07,
  0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xB8, 0x00, 0xEF, 0xF7, 0x00,
  0x1D, 0xFE, 0xE0, 0x03, 0xBF, 0xDE, 0x00, 0xF7, 0xF9, 0xC0, 0x1C, 0xFF,
  0x38, 0x03, 0x9F, 0xE7, 0x80, 0xF3, 0xFC, 0x70, 0x1C, 0x7F, 0x8E, 0x03,
  0x8F, 0xF1, 0xC0, 0x71, 0xFE, 0x3C, 0x1E, 0x3F, 0xC3, 0x83, 0x87, 0xF8,
  0x70, 0x70, 0xFF, 0x0F, 0x1E, 0x1F, 0xE1, 0xE3, 0x83, 0xFC, 0x1C, 0x70,
  0x7F, 0x83, 0x8E, 0x0F, 0xF0, 0x7B, 0xC1, 0xFE, 0x07, 0x70, 0x3F, 0xC0,
  0xEE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x3E, 0x03,
  0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x0E, 0x01, 0xE0, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF7, 0x80, 0xFF, 0x78, 0x0F,
  0xF3, 0x80, 0xFF, 0x3C, 0x0F, 0xF1, 0xC0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x07, 0x0F, 0xF0, 0x78, 0xFF, 0x03,
  0x8F, 0xF0, 0x3C, 0xFF, 0x03, 0xCF, 0xF0, 0x1E, 0xFF, 0x01, 0xEF, 0xF0,
  0x0E, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x81, 0xE0, 0x3E, 0x1F,
  0x00, 0xF0, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC1,
  0xE0, 0x3E, 0x0F, 0xC3, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x81, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0xF0,
  0x07, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1E,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC1, 0xE0, 0x3E, 0x0F,
  0xC3, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x07, 0xF8,
  0x3F, 0xFC, 0xFF, 0xFB, 0xF1, 0xE7, 0x80, 0x5F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x03, 0xDE, 0x1F, 0xBF, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D,
  0xE0, 0x1E, 0x7C, 0x07, 0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x80, 0xE0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0x70, 0xF0, 0x07, 0x8E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x39, 0xE0, 0x03, 0x9C, 0x00, 0x3D, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xDE, 0x00, 0xF8,
  0x01, 0xCF, 0x00, 0x7C, 0x01, 0xE7, 0x80, 0x3E, 0x00, 0xF3, 0xC0, 0x1F,
  0x00, 0x79, 0xE0, 0x1D, 0xC0, 0x3C, 0x78, 0x0E, 0xE0, 0x1C, 0x3C, 0x07,
  0x70, 0x1E, 0x1E, 0x03, 0xB8, 0x0F, 0x0F, 0x01, 0xDC, 0x07, 0x83, 0x81,
  0xEF, 0x03, 0xC1, 0xE0, 0xF3, 0x81, 0xC0, 0xF0, 0x71, 0xC1, 0xE0, 0x78,
  0x38, 0xE0, 0xF0, 0x3C, 0x1C, 0x70, 0x78, 0x0E, 0x1E, 0x3C, 0x3C, 0x07,
  0x8F, 0x0E, 0x1C, 0x03, 0xC7, 0x07, 0x1E, 0x01, 0xE3, 0x83, 0x8F, 0x00,
  0xF1, 0xC1, 0xC7, 0x80, 0x39, 0xE0, 0xF3, 0xC0, 0x1C, 0xF0, 0x39, 0xC0,
  0x0F, 0x70, 0x1D, 0xE0, 0x07, 0xB8, 0x0E, 0xF0, 0x03, 0xDC, 0x07, 0x78,
  0x00, 0xEE, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xCF, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x01, 0xCF, 0x00, 0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xB8, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x3C, 0x70,
  0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x0F,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1F, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xFC,
  0x00, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x38, 0x07, 0x8F, 0x03, 0xC3, 0xC0,
  0xF0, 0x70, 0x38, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xE1, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x01, 0xCE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xCE,
  0x00, 0x39, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0xC0, 0x78, 0x38, 0x0E, 0x07,
  0x83, 0xC0, 0x70, 0x70, 0x0F, 0x1E, 0x00, 0xE3, 0x80, 0x1E, 0xF0, 0x03,
  0xDC, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x0F, 0xE1, 0xFF, 0xC3, 0xFF, 0x8E,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x7F, 0xC7, 0xFF, 0x3F, 0xFD, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFD, 0xDF, 0xE7,
  0x3F, 0x1C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0,
  0xF7, 0xF8, 0xFF, 0xFC, 0xFE, 0x3E, 0xF8, 0x1E, 0xF8, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1E, 0xFC, 0x3E, 0xEF, 0xFC, 0xE7, 0xFC, 0xE3, 0xF8,
  0x07, 0xF0, 0xFF, 0xC7, 0xFC, 0x7C, 0x67, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x04,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x0F, 0xC7, 0x1F, 0xE7, 0x3F, 0xF7, 0x3E, 0x3F, 0x78, 0x1F, 0x78,
  0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xF7, 0x1F,
  0xE7, 0x0F, 0xC7, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x81,
  0xCF, 0x03, 0xDC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x8F, 0xFF, 0x0F, 0xFE,
  0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1E, 0x20, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF9, 0xFF, 0xCF, 0xFE, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x0F,
  0xC7, 0x1F, 0xE7, 0x3F, 0xF7, 0x3E, 0x3F, 0x78, 0x1F, 0x78, 0x0F, 0x70,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xF7, 0x1F, 0xE7, 0x0F,
  0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x40, 0x1E, 0x78, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xCF, 0xC7, 0xBF, 0xCF, 0xFF, 0xDD,
  0xCF, 0xBE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0xEF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x9E, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x7F, 0x81, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78,
  0x78, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7E, 0xE0, 0xF9, 0xE1, 0xE3, 0xC3, 0xC3, 0xC7, 0x87, 0x8F,
  0x07, 0x1E, 0x0F, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xF0, 0x7E, 0x73, 0xFC,
  0x7F, 0xBB, 0xFE, 0x7F, 0xDD, 0x8F, 0xF1, 0xFF, 0x83, 0xF0, 0x7F, 0xC0,
  0xF0, 0x3F, 0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x03, 0xF8,
  0x0F, 0x01, 0xFC, 0x07, 0x80, 0xFE, 0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x3F,
  0x80, 0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x03,
  0xF8, 0x0F, 0x01, 0xFC, 0x07, 0x80, 0xFE, 0x03, 0xC0, 0x7F, 0x01, 0xE0,
  0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0xF0, 0x1E,
  0x03, 0x80, 0xE3, 0xF1, 0xCF, 0xF3, 0xBF, 0xF7, 0x71, 0xEF, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1E, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xC7, 0xC7, 0x81, 0xE3,
  0xC0, 0x79, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xBC, 0x01,
  0xDE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0,
  0x07, 0x78, 0x07, 0x9C, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xE1, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0xE3, 0xF0, 0xE7, 0xF8, 0xEF,
  0xFC, 0xEC, 0x3E, 0xF8, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1E, 0xFC, 0x3E, 0xFF, 0xFC, 0xF7, 0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xC7, 0x1F, 0xE7, 0x3F,
  0xF7, 0x3E, 0x3F, 0x78, 0x1F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x1F, 0x7C, 0x3F, 0x3F, 0xF7, 0x1F, 0xE7, 0x0F, 0xC7, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE3, 0xFC, 0xFB, 0x9F, 0x77,
  0xEE, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0xC3, 0xFF, 0x7F, 0xFF, 0x06,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0xFC, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x7F, 0x1F, 0xC3, 0xF0, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0x03, 0xEF, 0x0F, 0xDF, 0xFB, 0x9F, 0xE7, 0x1F, 0x8E, 0xF0, 0x07, 0xF8,
  0x03, 0xDC, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x78, 0xE0, 0x38,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x07, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0F, 0x78, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0xEE, 0x01, 0xE0, 0x1D, 0xE0, 0x7C,
  0x07, 0xBC, 0x0F, 0xC0, 0xF7, 0x81, 0xF8, 0x1E, 0x70, 0x3F, 0x03, 0x8E,
  0x07, 0xE0, 0xF1, 0xE1, 0xDC, 0x1E, 0x3C, 0x39, 0xC3, 0xC7, 0x87, 0x38,
  0x70, 0x70, 0xE7, 0x0E, 0x0E, 0x1C, 0xE3, 0xC1, 0xE7, 0x9C, 0x78, 0x3C,
  0xE3, 0xCF, 0x07, 0x9C, 0x39, 0xC0, 0x73, 0x87, 0x38, 0x0E, 0x70, 0xEF,
  0x01, 0xDE, 0x1D, 0xE0, 0x3F, 0x83, 0xB8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C,
  0x3C, 0x38, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x3C,
  0x78, 0x1C, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x07, 0xB8, 0x03, 0xDE, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3C,
  0x1E, 0x0E, 0x0F, 0x07, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0x71, 0xC0,
  0x38, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x9F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0x7F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x81, 0xFC,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xBF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFC, 0x07, 0xF4, 0x00, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 33, 11, 3, -33 },
  { 22, 12, 12, 17, 3, -33 },
  { 40, 19, 33, 21, 1, -33 },
  { 119, 16, 38, 20, 2, -35 },
  { 195, 27, 33, 31, 2, -33 },
  { 307, 21, 33, 22, 1, -33 },
  { 394, 4, 12, 10, 3, -33 },
  { 400, 10, 40, 13, 2, -33 },
  { 450, 10, 40, 13, 1, -33 },
  { 500, 15, 15, 18, 2, -35 },
  { 529, 17, 22, 20, 1, -27 },
  { 576, 6, 11, 10, 2, -5 },
  { 585, 10, 3, 13, 1, -14 },
  { 589, 5, 5, 10, 3, -5 },
  { 593, 15, 33, 17, 1, -33 },
  { 655, 16, 33, 20, 2, -33 },
  { 721, 11, 33, 20, 3, -33 },
  { 767, 16, 33, 20, 2, -33 },
  { 833, 16, 33, 20, 2, -33 },
  { 899, 18, 33, 20, 1, -33 },
  { 974, 16, 33, 20, 2, -33 },
  { 1040, 16, 33, 20, 2, -33 },
  { 1106, 17, 33, 20, 1, -33 },
  { 1177, 16, 33, 20, 2, -33 },
  { 1243, 16, 33, 20, 2, -33 },
  { 1309, 5, 25, 10, 3, -25 },
  { 1325, 6, 31, 10, 2, -25 },
  { 1349, 17, 21, 20, 1, -27 },
  { 1394, 17, 13, 20, 1, -23 },
  { 1422, 17, 21, 20, 1, -27 },
  { 1467, 13, 33, 15, 1, -33 },
  { 1521, 26, 37, 30, 2, -33 },
  { 1642, 21, 33, 21, 0, -33 },
  { 1729, 17, 33, 22, 3, -33 },
  { 1800, 17, 33, 21, 2, -33 },
  { 1871, 18, 33, 24, 3, -33 },
  { 1946, 13, 33, 18, 3, -33 },
  { 2000, 13, 33, 17, 3, -33 },
  { 2054, 21, 33, 25, 2, -33 },
  { 2141, 18, 33, 25, 3, -33 },
  { 2216, 9, 33, 13, 2, -33 },
  { 2254, 9, 42, 10, -2, -33 },
  { 2302, 18, 33, 21, 3, -33 },
  { 2377, 13, 33, 17, 3, -33 },
  { 2431, 27, 33, 33, 3, -33 },
  { 2543, 20, 33, 26, 3, -33 },
  { 2626, 21, 33, 25, 2, -33 },
  { 2713, 16, 33, 20, 3, -33 },
  { 2779, 21, 41, 25, 2, -33 },
  { 2887, 18, 33, 21, 3, -33 },
  { 2962, 15, 33, 19, 2, -33 },
  { 3024, 17, 33, 18, 0, -33 },
  { 3095, 18, 33, 24, 3, -33 },
  { 3170, 20, 33, 20, 0, -33 },
  { 3253, 33, 33, 33, 0, -33 },
  { 3390, 18, 33, 18, 0, -33 },
  { 3465, 18, 33, 18, 0, -33 },
  { 3540, 15, 33, 17, 1, -33 },
  { 3602, 10, 40, 14, 3, -33 },
  { 3652, 15, 33, 17, 1, -33 },
  { 3714, 10, 40, 14, 1, -33 },
  { 3764, 19, 18, 20, 1, -33 },
  { 3807, 20, 3, 20, 0, 4 },
  { 3815, 8, 7, 12, 2, -35 },
  { 3822, 14, 25, 19, 2, -25 },
  { 3866, 16, 35, 21, 3, -35 },
  { 3936, 13, 25, 16, 2, -25 },
  { 3977, 16, 35, 21, 2, -35 },
  { 4047, 15, 25, 19, 2, -25 },
  { 4094, 13, 35, 12, 0, -35 },
  { 4151, 16, 36, 21, 2, -25 },
  { 4223, 15, 35, 21, 3, -35 },
  { 4289, 4, 34, 10, 3, -34 },
  { 4306, 8, 45, 10, -1, -34 },
  { 4351, 15, 35, 18, 3, -35 },
  { 4417, 4, 35, 10, 3, -35 },
  { 4435, 25, 25, 31, 3, -25 },
  { 4514, 15, 25, 21, 3, -25 },
  { 4561, 17, 25, 20, 2, -25 },
  { 4615, 16, 36, 21, 3, -25 },
  { 4687, 16, 36, 21, 2, -25 },
  { 4759, 11, 25, 14, 3, -25 },
  { 4794, 12, 25, 16, 2, -25 },
  { 4832, 10, 30, 12, 1, -30 },
  { 4870, 15, 25, 21, 3, -25 },
  { 4917, 17, 25, 17, 0, -25 },
  { 4971, 27, 25, 28, 0, -25 },
  { 5056, 16, 25, 17, 1, -25 },
  { 5106, 17, 36, 17, 0, -25 },
  { 5183, 12, 25, 14, 1, -25 },
  { 5221, 13, 40, 17, 2, -33 },
  { 5286, 3, 46, 19, 8, -35 },
  { 5304, 13, 40, 17, 2, -33 },
  { 5369, 17, 6, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Regular46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR46PT7B_H_
