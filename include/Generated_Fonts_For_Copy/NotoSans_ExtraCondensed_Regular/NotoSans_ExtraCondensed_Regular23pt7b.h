#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x69, 0x00, 0xBB, 0xEF, 0x34, 0xD1, 0x45, 0x10,
  0x09, 0x86, 0x61, 0x90, 0x64, 0x7F, 0xDF, 0xF1, 0x10, 0x4C, 0x13, 0x04,
  0xCF, 0xFC, 0xC8, 0x32, 0x08, 0x82, 0x20, 0x98, 0x18, 0x18, 0x7F, 0xDA,
  0xD8, 0xD8, 0xD8, 0x78, 0x3C, 0x1E, 0x1B, 0x1B, 0x1B, 0x9B, 0xFE, 0x78,
  0x18, 0x18, 0x20, 0x03, 0x86, 0x36, 0x31, 0x91, 0x08, 0x98, 0x44, 0xC2,
  0x24, 0x19, 0x6E, 0xDA, 0x5B, 0x96, 0x49, 0xB2, 0x09, 0x90, 0x4C, 0x86,
  0x64, 0x23, 0x21, 0x0B, 0x18, 0x70, 0x18, 0x1F, 0x06, 0x41, 0x98, 0x64,
  0x19, 0x06, 0xC0, 0xE0, 0x38, 0x1E, 0x6C, 0xDB, 0x36, 0xC7, 0xB0, 0xCC,
  0x73, 0xFE, 0x7D, 0xC0, 0xF9, 0x24, 0x80, 0x18, 0x8C, 0x46, 0x31, 0x18,
  0xC6, 0x31, 0x8C, 0x61, 0x0C, 0x63, 0x0C, 0x21, 0x80, 0x86, 0x18, 0xC3,
  0x18, 0xC6, 0x10, 0xC6, 0x31, 0x18, 0xC6, 0x33, 0x19, 0x88, 0x00, 0x18,
  0x20, 0x47, 0xFF, 0xE7, 0x1B, 0x33, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x6D, 0xED, 0x00, 0xFF, 0xC0, 0x5F, 0x80,
  0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0x18, 0x3C, 0x66, 0x46, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x66, 0x7E, 0x3C, 0x1C, 0xF6, 0xF3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x38, 0xFC, 0xC6,
  0x06, 0x02, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xE0,
  0xFF, 0xFF, 0x38, 0xFE, 0xC6, 0x06, 0x02, 0x06, 0x06, 0x0C, 0x38, 0x0E,
  0x06, 0x03, 0x03, 0x03, 0x06, 0xCE, 0xFC, 0x03, 0x01, 0xC0, 0x70, 0x3C,
  0x0B, 0x06, 0xC1, 0x30, 0xCC, 0x33, 0x08, 0xC6, 0x31, 0x0C, 0xFF, 0xC0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7E, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xFC,
  0x7E, 0x06, 0x03, 0x03, 0x03, 0x03, 0x06, 0xCE, 0xFC, 0x0E, 0x3E, 0x70,
  0x60, 0x40, 0xC0, 0xC0, 0xDE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x63,
  0x7E, 0x3C, 0xFF, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x18, 0x7E, 0xE6, 0xC3, 0xC3, 0xC3,
  0x66, 0x7C, 0x38, 0x6E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6, 0x7C, 0x18,
  0x7C, 0xE6, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7F, 0x3B, 0x02, 0x06,
  0x06, 0x0E, 0x5C, 0x78, 0xFD, 0x00, 0x00, 0x0B, 0xB0, 0xFD, 0x00, 0x00,
  0x0D, 0xBD, 0xA0, 0x01, 0x07, 0x1C, 0x70, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x07, 0x1C, 0x70, 0xC0, 0x80, 0x39, 0xF9, 0x38, 0x30, 0x60, 0xC3, 0x06,
  0x18, 0x20, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x30, 0x03, 0x00, 0x7E, 0x0E,
  0x18, 0x40, 0x66, 0x01, 0x23, 0xCD, 0x32, 0x79, 0x93, 0xC8, 0x9E, 0x4C,
  0xF2, 0x67, 0x93, 0x3C, 0xD9, 0x67, 0xF9, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xCE, 0x03, 0xE0, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1B, 0x04, 0xC3, 0x30,
  0xCC, 0x31, 0x0F, 0xE7, 0xF9, 0x86, 0x61, 0x98, 0x3C, 0x0F, 0x03, 0xFE,
  0xC6, 0xC3, 0xC3, 0xC3, 0xC6, 0xCE, 0xFC, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFE, 0xFC, 0x0E, 0x0F, 0xCC, 0x4C, 0x06, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x7E, 0x1F, 0x00, 0xFC,
  0x67, 0x30, 0xD8, 0x6C, 0x36, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8,
  0x6C, 0x36, 0x3B, 0xF9, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFF,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x07, 0x07, 0xF3, 0x8D, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x00, 0xC3, 0xF0, 0xFC, 0x0F, 0x03, 0x60, 0xD8, 0x37, 0x0C,
  0xFF, 0x1F, 0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFB, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x9F, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xAD, 0xE0, 0xC3, 0xC6, 0xCE, 0xCC,
  0xD8, 0xD8, 0xF0, 0xF0, 0xF8, 0xD8, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF,
  0xE0, 0x3F, 0x01, 0xE8, 0x1F, 0x60, 0xFF, 0x05, 0xF8, 0x6F, 0x43, 0x7B,
  0x1B, 0xD8, 0x9E, 0x4C, 0xF3, 0x67, 0x9A, 0x3C, 0xF1, 0xE3, 0x8F, 0x1C,
  0x78, 0xC3, 0xC0, 0xF0, 0x78, 0x36, 0x1B, 0x0E, 0xC7, 0x63, 0x91, 0xCC,
  0xE6, 0x71, 0xB8, 0xDC, 0x3E, 0x1F, 0x0F, 0x83, 0x0E, 0x07, 0xE1, 0xC6,
  0x30, 0x66, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xF8, 0x1F, 0x03, 0x60,
  0x66, 0x0C, 0xC1, 0x98, 0x61, 0xFC, 0x1F, 0x00, 0xFD, 0x9F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE7, 0xFD, 0xE3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x0E, 0x07,
  0xE1, 0xC6, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xF8, 0x1F,
  0x03, 0x60, 0x66, 0x0C, 0xC1, 0x98, 0x61, 0xFC, 0x1F, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0xFC, 0xCE, 0xC6, 0xC6, 0xC3, 0xC6, 0xC6, 0xDE, 0xF8,
  0xD8, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3, 0x1C, 0x7E, 0xE2, 0xC0, 0xC0,
  0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x06, 0x07, 0x03, 0x03, 0x06, 0xFE, 0xFC,
  0xFF, 0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC3, 0xC3, 0xFF, 0x7E, 0xC0, 0xF0,
  0x36, 0x19, 0x86, 0x61, 0x98, 0x63, 0x10, 0xCC, 0x33, 0x0C, 0xC1, 0x20,
  0x78, 0x1E, 0x07, 0x80, 0xE0, 0x30, 0xC1, 0x83, 0xC1, 0xC3, 0x61, 0xC3,
  0x61, 0xC3, 0x63, 0x42, 0x63, 0x46, 0x23, 0x66, 0x32, 0x66, 0x32, 0x66,
  0x36, 0x24, 0x36, 0x2C, 0x16, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x1C, 0x18,
  0x1C, 0x18, 0x61, 0xB1, 0x8C, 0xC6, 0xC3, 0x60, 0xF0, 0x70, 0x18, 0x1C,
  0x0F, 0x0D, 0x86, 0xC2, 0x33, 0x19, 0x8D, 0x83, 0xC1, 0xB1, 0x98, 0xCC,
  0x63, 0x61, 0xB0, 0xD8, 0x38, 0x1C, 0x0E, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0xFE, 0x0C, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0xC1, 0x83,
  0x0C, 0x18, 0x3F, 0xFF, 0xFF, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x8F, 0xF0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18, 0x08,
  0x0C, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80, 0x0C, 0x03, 0x81,
  0xE0, 0x4C, 0x33, 0x08, 0x46, 0x1B, 0x83, 0xFF, 0xC0, 0xC6, 0x63, 0x18,
  0xF9, 0x18, 0x30, 0x60, 0xDF, 0xE3, 0xC7, 0x8F, 0x1E, 0x77, 0x20, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0xC6, 0xF3, 0x8D, 0xC6, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0x0B, 0x8D, 0xEE, 0xDE, 0x00, 0x18, 0xFD, 0x96, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x83, 0xA3, 0xC0, 0x03, 0x03, 0x03, 0x03, 0x13,
  0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x39,
  0x18, 0x7C, 0x66, 0xC2, 0xC3, 0xC3, 0xFF, 0xC0, 0xC0, 0xC0, 0x60, 0x72,
  0x3E, 0x08, 0xF3, 0x0C, 0x30, 0xCF, 0xCC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC0, 0x10, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x67, 0x3B, 0x03, 0x03, 0x03, 0x46, 0x7E, 0x10, 0xC0, 0xC0,
  0xC0, 0xC0, 0xCC, 0xDE, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x5D, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x27, 0x20,
  0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x6E, 0x80, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC1, 0xC6, 0xC6, 0xCC, 0xC8, 0xD8, 0xF8, 0xEC, 0xCC, 0xC6,
  0xC6, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x26, 0xF7, 0xF9,
  0xE7, 0xC6, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18,
  0xF0, 0xC7, 0x86, 0x3C, 0x31, 0x80, 0x0C, 0xDE, 0xE3, 0xE3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x18, 0x7E, 0x66, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x76, 0x3C, 0x0C, 0x6F, 0x38, 0xDC,
  0x6C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xB8, 0xDE, 0xED, 0xE6, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x10, 0x7F, 0x67, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x3B, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x0F, 0x7F, 0x78, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x31,
  0xFC, 0x70, 0xC3, 0x87, 0x0E, 0x0C, 0x30, 0xF7, 0xF8, 0x20, 0x82, 0x3E,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xD3, 0xC0, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x63, 0x6F, 0x3B, 0xC3, 0x43, 0x63,
  0x62, 0x66, 0x26, 0x36, 0x34, 0x3C, 0x1C, 0x1C, 0x18, 0xC3, 0x0D, 0x0C,
  0x26, 0x79, 0x99, 0xE6, 0x67, 0x99, 0x92, 0x42, 0x4B, 0x0F, 0x3C, 0x3C,
  0xF0, 0xE3, 0xC1, 0x86, 0x06, 0x18, 0xE3, 0x66, 0x36, 0x34, 0x1C, 0x1C,
  0x1C, 0x3C, 0x36, 0x66, 0x63, 0xC3, 0xC3, 0x43, 0x63, 0x62, 0x66, 0x26,
  0x36, 0x34, 0x3C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0x40,
  0xF8, 0xC6, 0x63, 0x19, 0x8C, 0xC6, 0x3F, 0xF0, 0x1C, 0x63, 0x0C, 0x30,
  0xC3, 0x0C, 0x33, 0x07, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x18,
  0x31, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xCE, 0x30, 0x61, 0xF9, 0x9F,
};

const GFXglyph NotoSans_ExtraCondensed_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 16, 5, 1, -16 },
  { 7, 6, 6, 9, 1, -16 },
  { 12, 10, 16, 11, 0, -16 },
  { 32, 8, 18, 10, 1, -17 },
  { 50, 13, 17, 15, 1, -17 },
  { 78, 10, 17, 11, 1, -17 },
  { 100, 3, 6, 5, 1, -16 },
  { 103, 5, 21, 7, 1, -17 },
  { 117, 5, 21, 7, 1, -17 },
  { 131, 7, 8, 9, 1, -18 },
  { 138, 8, 11, 10, 1, -14 },
  { 149, 3, 6, 5, 1, -3 },
  { 152, 5, 2, 6, 1, -7 },
  { 154, 3, 3, 5, 1, -3 },
  { 156, 8, 16, 9, 0, -16 },
  { 172, 8, 17, 10, 1, -17 },
  { 189, 6, 16, 10, 1, -16 },
  { 201, 8, 17, 10, 1, -17 },
  { 218, 8, 17, 10, 1, -17 },
  { 235, 10, 17, 10, 0, -17 },
  { 257, 8, 16, 10, 1, -16 },
  { 273, 8, 17, 10, 1, -17 },
  { 290, 8, 16, 10, 1, -16 },
  { 306, 8, 17, 10, 1, -17 },
  { 323, 8, 17, 10, 1, -17 },
  { 340, 3, 12, 5, 1, -12 },
  { 345, 3, 15, 5, 1, -12 },
  { 351, 8, 10, 10, 1, -13 },
  { 361, 8, 6, 10, 1, -11 },
  { 367, 8, 10, 10, 1, -13 },
  { 377, 7, 17, 7, 0, -17 },
  { 392, 13, 19, 15, 1, -17 },
  { 423, 10, 16, 10, 0, -16 },
  { 443, 8, 16, 11, 2, -16 },
  { 459, 9, 17, 10, 1, -17 },
  { 479, 9, 16, 12, 2, -16 },
  { 497, 6, 16, 9, 2, -16 },
  { 509, 6, 16, 9, 2, -16 },
  { 521, 10, 17, 13, 1, -17 },
  { 543, 9, 16, 12, 2, -16 },
  { 561, 5, 16, 7, 1, -16 },
  { 571, 5, 20, 5, -1, -16 },
  { 584, 8, 16, 10, 2, -16 },
  { 600, 6, 16, 9, 2, -16 },
  { 612, 13, 16, 17, 2, -16 },
  { 638, 9, 16, 13, 2, -16 },
  { 656, 11, 17, 13, 1, -17 },
  { 680, 7, 16, 10, 2, -16 },
  { 694, 11, 21, 13, 1, -17 },
  { 723, 8, 16, 11, 2, -16 },
  { 739, 8, 17, 10, 1, -17 },
  { 756, 9, 16, 9, 0, -16 },
  { 774, 8, 16, 12, 2, -16 },
  { 790, 10, 16, 10, 0, -16 },
  { 810, 16, 16, 17, 0, -16 },
  { 842, 9, 16, 9, 0, -16 },
  { 860, 9, 16, 9, 0, -16 },
  { 878, 7, 16, 8, 1, -16 },
  { 892, 4, 21, 7, 2, -17 },
  { 903, 8, 16, 9, 0, -16 },
  { 919, 5, 21, 7, 1, -17 },
  { 933, 10, 8, 10, 0, -16 },
  { 943, 10, 1, 10, 0, 2 },
  { 945, 4, 4, 6, 1, -18 },
  { 947, 7, 13, 10, 1, -13 },
  { 959, 9, 17, 11, 1, -17 },
  { 979, 7, 13, 8, 1, -13 },
  { 991, 8, 17, 11, 1, -17 },
  { 1008, 8, 13, 10, 1, -13 },
  { 1021, 6, 18, 6, 0, -18 },
  { 1035, 8, 19, 11, 1, -13 },
  { 1054, 8, 17, 10, 1, -17 },
  { 1071, 3, 17, 5, 1, -17 },
  { 1078, 4, 23, 5, 0, -17 },
  { 1090, 8, 17, 9, 1, -17 },
  { 1107, 2, 17, 5, 1, -17 },
  { 1112, 13, 13, 16, 1, -13 },
  { 1134, 8, 13, 10, 1, -13 },
  { 1147, 8, 13, 10, 1, -13 },
  { 1160, 9, 19, 11, 1, -13 },
  { 1182, 8, 19, 11, 1, -13 },
  { 1201, 6, 13, 7, 1, -13 },
  { 1211, 6, 13, 8, 1, -13 },
  { 1221, 6, 15, 6, 0, -15 },
  { 1233, 8, 12, 10, 1, -12 },
  { 1245, 8, 12, 9, 0, -12 },
  { 1257, 14, 12, 14, 0, -12 },
  { 1278, 8, 12, 9, 0, -12 },
  { 1290, 8, 18, 9, 0, -12 },
  { 1308, 5, 12, 7, 1, -12 },
  { 1316, 6, 20, 8, 1, -16 },
  { 1331, 2, 23, 9, 4, -18 },
  { 1337, 6, 20, 8, 1, -16 },
  { 1352, 8, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Regular23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR23PT7B_H_
