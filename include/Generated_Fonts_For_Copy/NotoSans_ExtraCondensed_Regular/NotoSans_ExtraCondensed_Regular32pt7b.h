#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x60, 0x06, 0xEF,
  0xE0, 0xE7, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0x0C, 0x60, 0x63,
  0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x9F, 0xFF, 0xFF, 0xF8,
  0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x63, 0xFF, 0xDF, 0xFE, 0x31,
  0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x00, 0x06,
  0x00, 0xC0, 0x3C, 0x1F, 0xF7, 0xFE, 0xCC, 0x79, 0x87, 0x30, 0xE6, 0x0C,
  0xC1, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xB8, 0x33, 0x06, 0x60, 0xCC,
  0x19, 0xE3, 0x7F, 0xFC, 0xFF, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x3C,
  0x0E, 0x0F, 0xC1, 0x81, 0x98, 0x30, 0x33, 0x0C, 0x0E, 0x71, 0x81, 0x86,
  0x30, 0x30, 0xCC, 0x06, 0x19, 0x80, 0xC3, 0x30, 0x1C, 0xEC, 0x71, 0x99,
  0x9F, 0x33, 0x36, 0x67, 0xEC, 0xCE, 0x79, 0x98, 0xC0, 0x73, 0x18, 0x0C,
  0x63, 0x01, 0x8C, 0x60, 0x71, 0x8C, 0x0C, 0x31, 0x81, 0x86, 0x30, 0x70,
  0xCC, 0x0C, 0x0F, 0x81, 0x81, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0x98, 0x0C,
  0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0E, 0x60, 0x3B, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x7F, 0x19, 0xDC, 0x6E, 0x3B, 0xB8, 0x6E, 0xE1, 0xFB,
  0x83, 0xCE, 0x0F, 0x38, 0x3C, 0xF1, 0xF9, 0xFE, 0xE3, 0xF1, 0xC0, 0xFF,
  0xFF, 0xF6, 0x0C, 0x63, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0E, 0x38, 0xE1, 0x87, 0x1C, 0x30, 0xE1, 0x83, 0xE0,
  0xC1, 0xC1, 0x83, 0x83, 0x07, 0x0E, 0x0C, 0x18, 0x30, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x1C, 0x30, 0xE1, 0x87, 0x00,
  0x0E, 0x01, 0xC0, 0x30, 0x76, 0xEF, 0xFC, 0x1C, 0x47, 0xC1, 0xD8, 0x73,
  0x86, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x3B, 0x9C, 0xE7, 0x31, 0x98, 0xFF, 0xFF, 0xF8, 0x5F, 0xF0, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x00, 0x1F, 0x07, 0xF0, 0xE7, 0x38, 0x67, 0x0E, 0xE1,
  0xD8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0x60, 0xEC, 0x1D, 0xC3, 0xB8, 0x63, 0x9C, 0x7F, 0x07, 0xC0,
  0x06, 0x1C, 0x79, 0xF7, 0x7C, 0xD1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x3F, 0x0F, 0xF3,
  0xCF, 0x20, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0x0F, 0xFB, 0x87, 0x20, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x7C, 0x0F, 0x80, 0x7C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7C, 0x1D, 0xFF, 0xBF,
  0xC0, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0D, 0xC1,
  0xDC, 0x19, 0xC1, 0x9C, 0x31, 0xC3, 0x1C, 0x61, 0xC6, 0x1C, 0xC1, 0xCC,
  0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0xFF, 0xBF, 0xEF, 0xFB, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0x8F, 0xF9, 0x1E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x87, 0xBF, 0xCF, 0xE0, 0x07, 0xC3, 0xF8, 0x78, 0x9C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0D, 0xF3, 0xFF, 0x78, 0x7F, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0x60, 0x6C, 0x0D, 0xC3, 0xB8, 0x73, 0x9C, 0x7F, 0x87,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x00,
  0x1F, 0x83, 0xFC, 0x71, 0xE7, 0x0E, 0x60, 0xE6, 0x06, 0x60, 0xE7, 0x0E,
  0x31, 0xC3, 0xBC, 0x1F, 0x01, 0xF0, 0x3B, 0x87, 0x1C, 0x60, 0xEE, 0x06,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0x70, 0xE7, 0xFC, 0x1F, 0x80, 0x1F,
  0x07, 0xF1, 0xE7, 0x38, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1D, 0x83, 0xB8, 0xF7, 0xF6, 0x7E, 0xC2, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x78, 0xFE, 0x1F, 0x80, 0xFF, 0xB0, 0x00, 0x00, 0x00,
  0xBF, 0xE0, 0x73, 0x9C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xCE,
  0x73, 0x98, 0xCC, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x0E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0,
  0x0C, 0x00, 0x80, 0x00, 0x3E, 0x3F, 0xE6, 0x38, 0x06, 0x01, 0x80, 0x70,
  0x18, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x0F, 0x01, 0xC0, 0x03, 0xF0, 0x07,
  0xFC, 0x07, 0x03, 0x87, 0x00, 0xC3, 0x00, 0x33, 0x00, 0x19, 0x87, 0x87,
  0xC7, 0xE3, 0xC7, 0x31, 0xE3, 0x18, 0xF1, 0x8C, 0x78, 0xC6, 0x3C, 0xE3,
  0x1E, 0x71, 0x8F, 0x38, 0xC7, 0x8C, 0xE3, 0xC6, 0x71, 0xE3, 0xEF, 0xB0,
  0xF7, 0xDC, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x30,
  0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x0F, 0xC0, 0x3B, 0x00, 0xCC, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xC6,
  0x06, 0x1C, 0x18, 0x70, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x30, 0x39, 0xC0,
  0xE7, 0x03, 0x9C, 0x07, 0x60, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0xFF, 0x0F,
  0xFC, 0xE3, 0xEE, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE,
  0x1E, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xEF, 0xFC, 0xFF, 0x80, 0x0F, 0xF1, 0xFE,
  0x3C, 0x67, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x21, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xFE, 0x3F,
  0xF9, 0xC1, 0xCE, 0x07, 0x70, 0x3B, 0x80, 0xDC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x37,
  0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x3E, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFE,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1F, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0x07, 0xF0, 0x7F, 0xE3, 0xE3, 0x9E, 0x02, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x3F, 0xC0,
  0xFF, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDE,
  0x07, 0x3C, 0x1C, 0x7F, 0xF0, 0xFF, 0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0xFF, 0xFC, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x9F, 0xFF, 0x80, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x77, 0xEF, 0x80, 0xE0, 0x7E, 0x0E, 0xE0,
  0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE,
  0x0F, 0xE0, 0xFF, 0x0F, 0x70, 0xE3, 0x0E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1,
  0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFB,
  0x01, 0xBF, 0x60, 0x37, 0xEE, 0x0E, 0xFD, 0xC1, 0xDF, 0x98, 0x33, 0xF3,
  0x06, 0x7E, 0x71, 0xCF, 0xC6, 0x31, 0xF8, 0xC6, 0x3F, 0x1D, 0xC7, 0xE3,
  0xB8, 0xFC, 0x36, 0x1F, 0x86, 0xC3, 0xF0, 0xF8, 0x7E, 0x0E, 0x0F, 0xC1,
  0xC1, 0xF8, 0x38, 0x38, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x7E, 0xC1, 0xFB, 0x87, 0xE6, 0x1F, 0x9C, 0x7E, 0x71, 0xF8,
  0xC7, 0xE3, 0x9F, 0x86, 0x7E, 0x1D, 0xF8, 0x37, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xC0, 0x0F, 0xC0, 0xFF,
  0x83, 0xCF, 0x1C, 0x1E, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C, 0x1E, 0x38, 0xF0, 0xFF, 0x80,
  0xFC, 0x00, 0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF3, 0xEF, 0xF9, 0xFE, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0xC0,
  0xFF, 0x83, 0xCF, 0x1C, 0x1E, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C, 0x1E, 0x38, 0xF0, 0xFF,
  0x80, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0xFE,
  0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCF, 0xFC, 0xFF, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xE1,
  0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x70, 0x1F, 0xC7,
  0xFD, 0xF7, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x7E, 0x3D, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x0C,
  0xE0, 0xE7, 0x8F, 0x1F, 0xF0, 0x7F, 0x00, 0xE0, 0x1F, 0x80, 0x76, 0x01,
  0xDC, 0x06, 0x70, 0x39, 0xC0, 0xE3, 0x03, 0x8C, 0x0C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x03, 0x30, 0x0C,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1D, 0x80, 0xE0, 0x33, 0x81, 0xC0, 0x67,
  0x06, 0xC1, 0xCE, 0x0D, 0x83, 0x9C, 0x1B, 0x07, 0x18, 0x36, 0x0C, 0x30,
  0x6C, 0x18, 0x71, 0xDC, 0x70, 0xE3, 0x18, 0xE1, 0xC6, 0x31, 0xC1, 0x8C,
  0x63, 0x03, 0x18, 0xC6, 0x07, 0x71, 0xDC, 0x0E, 0xC1, 0xB8, 0x0D, 0x83,
  0x70, 0x1B, 0x06, 0xC0, 0x36, 0x0D, 0x80, 0x6C, 0x1B, 0x00, 0xF8, 0x1E,
  0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x73, 0x83, 0x8C, 0x18,
  0x71, 0xC3, 0x8E, 0x0C, 0x60, 0x77, 0x01, 0xB8, 0x0D, 0x80, 0x7C, 0x01,
  0xC0, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x03, 0xB8, 0x18, 0xC1, 0xC6,
  0x0E, 0x38, 0x60, 0xC7, 0x07, 0x38, 0x3B, 0x80, 0xE0, 0xE0, 0x3F, 0x03,
  0x9C, 0x1C, 0xE0, 0xC3, 0x0E, 0x1C, 0x70, 0xE3, 0x03, 0x38, 0x1D, 0xC0,
  0xEC, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0xFF, 0xFC,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x03,
  0x00, 0x0C, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0xC0, 0x33, 0x01, 0xCE, 0x06,
  0x18, 0x38, 0x70, 0xC0, 0xC7, 0x03, 0xB8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0x04, 0x1F, 0xE3, 0xFC, 0x87, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x1F, 0xDF, 0xF7, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x8F, 0x7E, 0xCF, 0x30, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x7C, 0xFF, 0xDE, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xE3, 0xB7, 0xF6,
  0x7C, 0x02, 0x0F, 0xCF, 0xEF, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xF1, 0x3F, 0x8F, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x04, 0x71, 0xF7, 0x3F, 0xF7,
  0x0F, 0x70, 0xF6, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0x60, 0x76, 0x07, 0x70, 0xF7, 0x0F, 0x3F, 0xF1, 0xF3, 0x1F, 0x87,
  0xF9, 0xC3, 0x38, 0x76, 0x0E, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x11, 0xFE, 0x1F, 0xC0, 0x0F, 0x8F,
  0x86, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xFE, 0xFF, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x04, 0x01, 0xF7, 0x3F, 0xF7, 0x0F, 0x70, 0xF6, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x76, 0x07, 0x70, 0xF7,
  0x0F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x40, 0xE7,
  0xFC, 0x7F, 0x80, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x87, 0x7C, 0xFF, 0xDE, 0x3B, 0x83, 0x70, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0x5F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x11, 0xCE,
  0x70, 0x00, 0x07, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0xFB, 0xD8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x0E, 0xE1, 0x9C, 0x73, 0x9C, 0x73, 0x0E, 0xE1,
  0xD8, 0x3F, 0x87, 0xF0, 0xF6, 0x1C, 0xE3, 0x8C, 0x71, 0xCE, 0x39, 0xC3,
  0xB8, 0x77, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x02, 0x04, 0x33, 0xE7, 0xCD, 0xFF, 0xFB, 0xC7, 0x8E, 0xE1, 0xE1, 0xF8,
  0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C,
  0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x07,
  0xE0, 0xC1, 0xF8, 0x30, 0x70, 0x02, 0x19, 0xF3, 0x7F, 0x78, 0xEE, 0x0D,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x02, 0x01, 0xF8, 0x3F, 0xC7, 0x0E,
  0x70, 0x66, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x60, 0x76, 0x06, 0x70, 0xE3, 0x8E, 0x3F, 0xC1, 0xF8, 0x02, 0x19, 0xF3,
  0x7F, 0x78, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x8E, 0xFF, 0xDD, 0xF3, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x04, 0x01, 0xF7,
  0x3F, 0xF7, 0x0F, 0x70, 0xF6, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x60, 0x76, 0x07, 0x70, 0xF7, 0x0F, 0x3F, 0xF1, 0xF7,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x05, 0x9F, 0x7E, 0xCF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC0, 0x08, 0x1F, 0xDF, 0xDC, 0x2E, 0x07, 0x03, 0x80,
  0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x8E, 0xFF, 0x7F,
  0x00, 0x30, 0x61, 0xC3, 0x8F, 0xFF, 0xDC, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xF3, 0xE0, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xFC, 0xFB, 0xFF, 0x3E, 0xE0, 0xE0, 0x76, 0x06, 0x60,
  0xE7, 0x0E, 0x70, 0xE3, 0x0C, 0x30, 0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x19,
  0x81, 0xB8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0xE0,
  0xEC, 0x1C, 0x1D, 0x83, 0xC3, 0x38, 0xF8, 0x67, 0x1B, 0x0C, 0xE3, 0x63,
  0x8C, 0x6C, 0x71, 0x8D, 0xCC, 0x3B, 0x99, 0x87, 0x63, 0x30, 0x6C, 0x6E,
  0x0D, 0x8D, 0xC1, 0xB1, 0xF0, 0x36, 0x1E, 0x07, 0x83, 0xC0, 0x70, 0x78,
  0x0E, 0x0E, 0x00, 0x70, 0xE7, 0x0E, 0x39, 0xC3, 0x9C, 0x19, 0x81, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x19, 0x83, 0x9C,
  0x30, 0xC7, 0x0E, 0xE0, 0x70, 0xE0, 0x76, 0x06, 0x60, 0xE7, 0x0E, 0x70,
  0xE3, 0x0C, 0x31, 0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x19, 0x81, 0xF8, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0xFC, 0x0F, 0x80, 0x60, 0x00, 0xFF, 0xFF, 0x06, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF,
  0x01, 0x83, 0xC3, 0xC1, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0xC7, 0xC3, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x3C,
  0x0E, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x1E, 0x3E, 0x1E, 0x00, 0x7C, 0x1F, 0xFF, 0x87, 0xF8, 0x1C,
};

const GFXglyph NotoSans_ExtraCondensed_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 8, 8, 12, 2, -23 },
  { 21, 13, 23, 15, 1, -23 },
  { 59, 11, 26, 14, 1, -24 },
  { 95, 19, 23, 21, 1, -23 },
  { 150, 14, 23, 15, 1, -23 },
  { 191, 3, 8, 7, 2, -23 },
  { 194, 6, 28, 9, 2, -23 },
  { 215, 7, 28, 9, 1, -23 },
  { 240, 11, 10, 13, 1, -24 },
  { 254, 12, 15, 14, 1, -19 },
  { 277, 5, 8, 7, 1, -4 },
  { 282, 7, 3, 9, 1, -10 },
  { 285, 3, 4, 7, 2, -4 },
  { 287, 10, 23, 12, 1, -23 },
  { 316, 11, 23, 14, 1, -23 },
  { 348, 7, 23, 14, 2, -23 },
  { 369, 11, 23, 14, 1, -23 },
  { 401, 11, 23, 14, 1, -23 },
  { 433, 12, 23, 14, 1, -23 },
  { 468, 10, 23, 14, 2, -23 },
  { 497, 11, 23, 14, 1, -23 },
  { 529, 12, 23, 14, 1, -23 },
  { 564, 12, 23, 14, 1, -23 },
  { 599, 11, 23, 14, 1, -23 },
  { 631, 3, 17, 7, 2, -17 },
  { 638, 5, 21, 7, 1, -17 },
  { 652, 12, 15, 14, 1, -19 },
  { 675, 12, 9, 14, 1, -16 },
  { 689, 12, 15, 14, 1, -19 },
  { 712, 10, 23, 10, 0, -23 },
  { 741, 17, 26, 21, 2, -23 },
  { 797, 14, 23, 14, 0, -23 },
  { 838, 12, 23, 15, 2, -23 },
  { 873, 12, 23, 14, 2, -23 },
  { 908, 13, 23, 17, 2, -23 },
  { 946, 9, 23, 13, 2, -23 },
  { 972, 9, 23, 12, 2, -23 },
  { 998, 14, 23, 17, 2, -23 },
  { 1039, 13, 23, 17, 2, -23 },
  { 1077, 7, 23, 9, 1, -23 },
  { 1098, 7, 29, 7, -2, -23 },
  { 1124, 12, 23, 14, 2, -23 },
  { 1159, 9, 23, 12, 2, -23 },
  { 1185, 19, 23, 23, 2, -23 },
  { 1240, 14, 23, 18, 2, -23 },
  { 1281, 14, 23, 18, 2, -23 },
  { 1322, 11, 23, 14, 2, -23 },
  { 1354, 14, 28, 18, 2, -23 },
  { 1403, 12, 23, 15, 2, -23 },
  { 1438, 11, 23, 13, 1, -23 },
  { 1470, 12, 23, 12, 0, -23 },
  { 1505, 13, 23, 17, 2, -23 },
  { 1543, 14, 23, 14, 0, -23 },
  { 1584, 23, 23, 23, 0, -23 },
  { 1651, 13, 23, 13, 0, -23 },
  { 1689, 13, 23, 13, 0, -23 },
  { 1727, 10, 23, 12, 1, -23 },
  { 1756, 7, 28, 10, 2, -23 },
  { 1781, 10, 23, 12, 1, -23 },
  { 1810, 7, 28, 10, 1, -23 },
  { 1835, 14, 12, 14, 0, -23 },
  { 1856, 14, 2, 14, 0, 3 },
  { 1860, 6, 6, 9, 1, -25 },
  { 1865, 10, 18, 13, 1, -18 },
  { 1888, 11, 24, 15, 2, -24 },
  { 1921, 9, 18, 11, 1, -18 },
  { 1942, 12, 24, 15, 1, -24 },
  { 1978, 11, 17, 13, 1, -17 },
  { 2002, 9, 24, 8, 0, -24 },
  { 2029, 12, 26, 15, 1, -18 },
  { 2068, 11, 24, 15, 2, -24 },
  { 2101, 3, 24, 7, 2, -24 },
  { 2110, 5, 32, 7, 0, -24 },
  { 2130, 11, 24, 13, 2, -24 },
  { 2163, 3, 24, 7, 2, -24 },
  { 2172, 18, 18, 22, 2, -18 },
  { 2213, 11, 18, 15, 2, -18 },
  { 2238, 12, 18, 14, 1, -18 },
  { 2265, 11, 26, 15, 2, -18 },
  { 2301, 12, 26, 15, 1, -18 },
  { 2340, 7, 18, 10, 2, -18 },
  { 2356, 9, 18, 11, 1, -18 },
  { 2377, 7, 21, 8, 1, -21 },
  { 2396, 11, 17, 15, 2, -17 },
  { 2420, 12, 17, 12, 0, -17 },
  { 2446, 19, 17, 19, 0, -17 },
  { 2487, 12, 17, 12, 0, -17 },
  { 2513, 12, 25, 12, 0, -17 },
  { 2551, 8, 17, 10, 1, -17 },
  { 2568, 9, 28, 12, 1, -23 },
  { 2600, 3, 32, 13, 5, -24 },
  { 2612, 9, 28, 12, 1, -23 },
  { 2644, 12, 4, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Regular32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR32PT7B_H_
