#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0x07,
  0xBF, 0xFF, 0xFF, 0xDE, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0, 0xF7,
  0x07, 0x80, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70,
  0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFC, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x07,
  0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x38,
  0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7C,
  0xC7, 0x1E, 0x30, 0x4F, 0x0C, 0x03, 0xC3, 0x00, 0xF0, 0xC0, 0x3C, 0x30,
  0x0F, 0x0C, 0x03, 0xC3, 0x00, 0x78, 0xC0, 0x1F, 0xB0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0x7E, 0x00,
  0xC7, 0x80, 0x30, 0xF0, 0x0C, 0x3C, 0x03, 0x0F, 0x00, 0xC3, 0xC0, 0x30,
  0xF0, 0x0C, 0x3B, 0x03, 0x1E, 0xF8, 0xDF, 0x3F, 0xFF, 0xCF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x78, 0x03,
  0xFC, 0x01, 0xC0, 0x1E, 0x78, 0x07, 0x00, 0x70, 0xE0, 0x3C, 0x01, 0xC3,
  0x80, 0xE0, 0x0F, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x1E, 0x00, 0xF0, 0xF0,
  0x70, 0x03, 0x83, 0xC3, 0xC0, 0x0E, 0x0F, 0x0E, 0x00, 0x38, 0x3C, 0x38,
  0x00, 0xE0, 0xF1, 0xE0, 0x03, 0x83, 0xC7, 0x00, 0x0F, 0x0F, 0x1C, 0x00,
  0x3C, 0x3C, 0xF1, 0xF8, 0xF0, 0xE3, 0x8F, 0xF1, 0xC3, 0x8E, 0x3F, 0xC7,
  0x0E, 0x79, 0xC7, 0x9E, 0x79, 0xC7, 0x0E, 0x3F, 0xC7, 0x3C, 0x38, 0x7E,
  0x3C, 0xF0, 0xF0, 0xF0, 0xE3, 0xC3, 0xC0, 0x03, 0x8E, 0x0F, 0x00, 0x1E,
  0x38, 0x3C, 0x00, 0x70, 0xE0, 0xF0, 0x03, 0xC3, 0x83, 0xC0, 0x0F, 0x0E,
  0x0F, 0x00, 0x38, 0x38, 0x3C, 0x01, 0xE0, 0xF0, 0xF0, 0x07, 0x03, 0xC3,
  0xC0, 0x1C, 0x0F, 0x0E, 0x00, 0xF0, 0x1C, 0x38, 0x03, 0x80, 0x71, 0xE0,
  0x0E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF1,
  0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x83, 0xC7,
  0xCF, 0x07, 0x8F, 0x0F, 0x0F, 0x3C, 0x1F, 0x3C, 0x78, 0x1E, 0x78, 0xF0,
  0x3E, 0xF1, 0xE0, 0x3F, 0xE7, 0xC0, 0x3F, 0x8F, 0x80, 0x7F, 0x0F, 0x00,
  0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xF8, 0x7C, 0x0F, 0xF0, 0x7E, 0x7F,
  0xF0, 0xFF, 0xF9, 0xF0, 0xFF, 0xE1, 0xE0, 0xFF, 0x83, 0xE0, 0x30, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0xE0,
  0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x41, 0xC3, 0xFD, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3E, 0x08, 0x10,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x9E,
  0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xEF, 0xBF, 0xF9, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1E, 0x0F,
  0x07, 0xC3, 0xC0, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3E, 0x1F, 0x0F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x30, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xEF, 0x7C,
  0xFF, 0x8F, 0x70, 0xF2, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xE0, 0x0F, 0xFC,
  0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0x83, 0xF3, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF,
  0x03, 0xF3, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x78, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07,
  0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFB, 0x00, 0x7C, 0xF8, 0x7E, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x8F, 0x83, 0xCF, 0xF0, 0xF7, 0xFE, 0x3D,
  0xFF, 0xCF, 0xE1, 0xFB, 0xF0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F,
  0x78, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0x78, 0xF0, 0x3E, 0x3E, 0x0F, 0x07,
  0xCF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0x79,
  0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C,
  0x0F, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x7C, 0xF8, 0x0F, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0x7E, 0x0F, 0x87, 0xC7, 0xC0, 0xF9,
  0xE0, 0x1E, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0x78, 0x0F, 0x9F, 0x87,
  0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x10, 0x00, 0x03, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0,
  0x3D, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBC, 0x07,
  0xDF, 0x07, 0xEF, 0xC7, 0xF3, 0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0x9E, 0x02,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x10, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x60, 0x00, 0x21, 0xEF, 0xBF, 0xFF, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBE, 0xFF, 0xFF, 0x9E, 0x10, 0x79, 0xF3, 0xF7, 0xEF, 0x8E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x9F, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x0F, 0x81, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x60, 0xFD, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x38,
  0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0xF8, 0x3C, 0x78,
  0x1F, 0xF0, 0xE3, 0x81, 0xFF, 0x87, 0x3C, 0x1E, 0x3C, 0x39, 0xE1, 0xE1,
  0xE1, 0xEE, 0x0F, 0x0F, 0x0F, 0x70, 0x70, 0x78, 0x7B, 0x83, 0x83, 0xC3,
  0xDC, 0x3C, 0x1C, 0x1E, 0xE1, 0xE0, 0xE0, 0xFF, 0x0F, 0x07, 0x07, 0xF8,
  0x78, 0x38, 0x3F, 0xC3, 0xC1, 0xC1, 0xFE, 0x1E, 0x1E, 0x0F, 0xF0, 0xF0,
  0xF0, 0x73, 0x87, 0x87, 0x83, 0x9C, 0x1C, 0x3E, 0x3C, 0xE0, 0xF3, 0xF1,
  0xC7, 0x07, 0xF9, 0xFE, 0x3C, 0x1F, 0xCF, 0xE1, 0xE0, 0x7C, 0x3E, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x40, 0x03, 0xE0, 0x0C,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xC1, 0xFE, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0x7B,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xF8, 0x18, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x43,
  0xFC, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x0F, 0xF0, 0xF0, 0x1F,
  0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xEF, 0x00,
  0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07,
  0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x03, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xC0, 0x78, 0x7C, 0x00, 0x43, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xE0,
  0x03, 0xCF, 0xC0, 0x0F, 0x1F, 0x80, 0x3C, 0x3F, 0x87, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xD0, 0xFB, 0xFF, 0x7F, 0xCF, 0xF0, 0xF8, 0x00, 0xF0, 0x07, 0xFE,
  0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78,
  0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF0, 0x0F, 0x9F, 0x01, 0xF1,
  0xE0, 0x3C, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0,
  0xF8, 0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80,
  0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xF0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xEF, 0xF7, 0x00, 0x0F, 0x7F, 0xBC,
  0x00, 0x7B, 0xFD, 0xE0, 0x03, 0x9F, 0xEF, 0x00, 0x3C, 0xFF, 0x38, 0x01,
  0xE7, 0xF9, 0xE0, 0x0F, 0x3F, 0xCF, 0x00, 0x71, 0xFE, 0x38, 0x07, 0x8F,
  0xF1, 0xE0, 0x3C, 0x7F, 0x8F, 0x01, 0xC3, 0xFC, 0x78, 0x1E, 0x1F, 0xE1,
  0xC0, 0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF8, 0x78, 0x38, 0x3F, 0xC1, 0xC3,
  0xC1, 0xFE, 0x0F, 0x1E, 0x0F, 0xF0, 0x78, 0xE0, 0x7F, 0x83, 0xCF, 0x03,
  0xFC, 0x0E, 0x78, 0x1F, 0xE0, 0x7B, 0xC0, 0xFF, 0x03, 0xDC, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0x1F,
  0x80, 0x7F, 0x80, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x1E, 0x00,
  0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF7, 0x80,
  0x7F, 0xBC, 0x03, 0xFD, 0xF0, 0x1F, 0xE7, 0x80, 0xFF, 0x3C, 0x07, 0xF8,
  0xF0, 0x3F, 0xC7, 0x81, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0xC3,
  0xFC, 0x1E, 0x1F, 0xE0, 0xF0, 0xFF, 0x03, 0xC7, 0xF8, 0x1E, 0x3F, 0xC0,
  0xF9, 0xFE, 0x03, 0xCF, 0xF0, 0x1F, 0x7F, 0x80, 0x7B, 0xFC, 0x03, 0xDF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7B, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xF8, 0x7E, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x78,
  0x00, 0x79, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x3F, 0xCF, 0x03,
  0xF7, 0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1E,
  0xF0, 0x1F, 0x78, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x07, 0xFE,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0x3E,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0x79, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x05, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x78, 0xFF, 0x8F, 0x03, 0xF1, 0xE0, 0x3E, 0x3C, 0x03,
  0xE7, 0x80, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x3E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xE1, 0xE0,
  0x3C, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF8,
  0x78, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x7C,
  0xF0, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x01, 0xF0, 0x03, 0xF8,
  0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xE7, 0xE0, 0xF3, 0xE0, 0x09, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1E, 0xC0, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE3, 0xE0, 0x3E,
  0x3F, 0xDF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F,
  0x7C, 0x00, 0x79, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C,
  0x00, 0xF0, 0xF8, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0,
  0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xC0,
  0x07, 0x9E, 0x00, 0x3E, 0x00, 0x3C, 0xF0, 0x01, 0xF0, 0x03, 0xE7, 0xC0,
  0x1F, 0x80, 0x1F, 0x3E, 0x00, 0xFE, 0x00, 0xF0, 0xF0, 0x07, 0xF0, 0x07,
  0x87, 0x80, 0x3B, 0x80, 0x3C, 0x3C, 0x01, 0xDC, 0x03, 0xE1, 0xE0, 0x1E,
  0xE0, 0x1F, 0x0F, 0x80, 0xF7, 0x80, 0xF0, 0x3C, 0x07, 0xBC, 0x07, 0x81,
  0xE0, 0x39, 0xE0, 0x3C, 0x0F, 0x01, 0xCF, 0x03, 0xE0, 0x78, 0x1E, 0x38,
  0x1E, 0x03, 0xE0, 0xF1, 0xE0, 0xF0, 0x0F, 0x07, 0x8F, 0x07, 0x80, 0x78,
  0x38, 0x78, 0x3C, 0x03, 0xC1, 0xC3, 0xC3, 0xE0, 0x1E, 0x1E, 0x0E, 0x1E,
  0x00, 0x78, 0xF0, 0x78, 0xF0, 0x03, 0xC7, 0x83, 0xC7, 0x80, 0x1E, 0x38,
  0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0xF3, 0xE0, 0x07, 0x9E, 0x03, 0x9E, 0x00,
  0x1E, 0xF0, 0x1C, 0xF0, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0x07, 0xB8, 0x07,
  0xBC, 0x00, 0x3D, 0xC0, 0x3D, 0xE0, 0x01, 0xEE, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF3, 0xC0, 0x1E, 0x3E, 0x03, 0xE1, 0xE0,
  0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xDE,
  0x00, 0x7D, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0x78, 0x1F, 0x07, 0x81, 0xE0, 0x7C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C,
  0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x10, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x3F, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xEF, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x7F, 0x7F, 0xEF, 0x3F, 0xE7, 0x1F, 0x87, 0x06, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC3, 0xE0, 0xF1, 0xFE, 0x3C, 0xFF, 0xCF, 0x7F, 0xF3, 0xF8, 0x3E, 0xFC,
  0x07, 0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFF, 0x01, 0xEF, 0xC0, 0xFB, 0xFC, 0x7E, 0xF7, 0xFF, 0x3C, 0xFF,
  0x8F, 0x1F, 0xC0, 0x00, 0x80, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE3, 0xE0, 0x47, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x0C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x0C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x0F, 0x0F, 0x0F, 0xF3, 0xC7, 0xFE, 0xF3, 0xFF, 0xFC, 0xF8, 0x7F,
  0x7C, 0x0F, 0xDF, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F,
  0x78, 0x07, 0xDF, 0x01, 0xF3, 0xC0, 0xFC, 0xF8, 0x7F, 0x1F, 0xFD, 0xC7,
  0xFE, 0x70, 0x7F, 0x1C, 0x06, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC3, 0xC1, 0xF1, 0xE0, 0x79, 0xE0, 0x1C, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x02, 0x3F, 0x07, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x71, 0xFF, 0x9C,
  0xFF, 0xFF, 0x3E, 0x1F, 0xDF, 0x03, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0x78,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3F, 0x3F,
  0x1F, 0xC7, 0xFE, 0xF1, 0xFF, 0xBC, 0x3F, 0x8F, 0x01, 0x83, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x79,
  0x80, 0x3E, 0x7E, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xC0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x1F,
  0x0F, 0x3F, 0xE7, 0xBF, 0xF3, 0xDF, 0xFD, 0xFC, 0x3E, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0x67, 0xBF,
  0xFF, 0xB8, 0x00, 0x00, 0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x06, 0x07,
  0x83, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7B, 0xFD, 0xFC, 0xFE, 0x7E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0xF7, 0x80,
  0xFB, 0xC0, 0xF9, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3C, 0x1E,
  0x3E, 0x0F, 0x1E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0xC0, 0xF7, 0xE0,
  0x7F, 0xF0, 0x3F, 0x3C, 0x1F, 0x9E, 0x0F, 0x8F, 0x87, 0x83, 0xC3, 0xC1,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1F, 0x3C, 0x07, 0x9E, 0x03, 0xEF,
  0x00, 0xF7, 0x80, 0x7F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0x87, 0x9F, 0xE1, 0xFE, 0x3D, 0xFF, 0x9F,
  0xF9, 0xEF, 0xFC, 0xFF, 0xEF, 0xE1, 0xFE, 0x1F, 0x7E, 0x07, 0xE0, 0x7B,
  0xE0, 0x3E, 0x03, 0xDF, 0x01, 0xF0, 0x1E, 0xF8, 0x0F, 0x80, 0xFF, 0xC0,
  0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x00, 0xF0,
  0x0F, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x3C, 0x03, 0xFE, 0x01, 0xE0, 0x1F,
  0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xE0,
  0x1E, 0x01, 0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x3C,
  0x03, 0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x07,
  0xFC, 0x03, 0xC0, 0x3F, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x79, 0xFF,
  0x3D, 0xFF, 0x9E, 0xFF, 0xEF, 0xE1, 0xF7, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F,
  0x9F, 0x01, 0xE1, 0xE0, 0x7C, 0x3F, 0x1F, 0x03, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x3C, 0x7F, 0x8F, 0x3F, 0xF3,
  0xDF, 0xFC, 0xFE, 0x0F, 0xBF, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7B, 0xF0, 0x3E, 0xF7,
  0x1F, 0xBD, 0xFF, 0xCF, 0x3F, 0xE3, 0xC7, 0xF0, 0xF0, 0x20, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x03, 0xFC, 0x71, 0xFF, 0x9C, 0xFF, 0xFF, 0x3E, 0x1F, 0xDF, 0x03,
  0xF7, 0xC0, 0x7D, 0xE0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x3F, 0x3F, 0x1F, 0xC7, 0xFE, 0xF1, 0xFF, 0xBC,
  0x3F, 0x8F, 0x01, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xF7,
  0x9F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x7F, 0xF7, 0xFF, 0x9F, 0xFE, 0xF8, 0x13, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xE0, 0x1E, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0x1F, 0xF0,
  0x04, 0x00, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0x11, 0xFF, 0x0F, 0xF0, 0xFF, 0x01, 0x80, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x7E, 0xFC, 0xFF, 0x3F, 0xF7,
  0x9F, 0xFB, 0xC7, 0xF0, 0xE0, 0x60, 0x00, 0xF8, 0x03, 0xEF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x00,
  0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x07, 0x70, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x3D, 0xE0, 0x1F, 0x00, 0xF7, 0x80, 0x7C, 0x03, 0xDE,
  0x03, 0xF8, 0x0F, 0x7C, 0x0E, 0xE0, 0x78, 0xF0, 0x3B, 0x81, 0xE3, 0xC0,
  0xEE, 0x07, 0x8F, 0x03, 0xB8, 0x1E, 0x3C, 0x1E, 0xF0, 0x70, 0x78, 0x7B,
  0xC3, 0xC1, 0xE1, 0xCF, 0x0F, 0x07, 0x87, 0x1C, 0x3C, 0x1E, 0x3C, 0x70,
  0xF0, 0x78, 0xF1, 0xE7, 0x80, 0xF3, 0xC7, 0x9E, 0x03, 0xCE, 0x1E, 0x78,
  0x0F, 0x38, 0x39, 0xE0, 0x3C, 0xE0, 0xE7, 0x00, 0x77, 0x83, 0x9C, 0x01,
  0xDE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xBC, 0x07, 0x9F, 0x07,
  0xC7, 0x83, 0xC3, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x1E, 0xF8, 0x0F,
  0x78, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xC7,
  0x81, 0xE3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x3E, 0x78, 0x0F, 0x7C,
  0x07, 0xFC, 0x01, 0xE0, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C,
  0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x3C, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x01,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x03, 0xF8, 0x0F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0xE0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xF8,
  0x00, 0x1F, 0x80, 0x17, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0x3F, 0xFF, 0xC0,
  0x7F, 0xE8, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 36, 12, 3, -36 },
  { 28, 13, 13, 19, 3, -36 },
  { 50, 22, 36, 23, 1, -36 },
  { 149, 18, 42, 22, 2, -39 },
  { 244, 30, 37, 34, 2, -37 },
  { 383, 23, 38, 24, 1, -37 },
  { 493, 5, 13, 11, 3, -36 },
  { 502, 11, 45, 15, 2, -37 },
  { 564, 11, 45, 15, 1, -37 },
  { 626, 16, 17, 20, 2, -39 },
  { 660, 18, 24, 22, 2, -30 },
  { 714, 7, 13, 12, 2, -6 },
  { 726, 12, 4, 14, 1, -16 },
  { 732, 6, 6, 12, 3, -6 },
  { 737, 17, 37, 19, 1, -37 },
  { 816, 18, 38, 22, 2, -37 },
  { 902, 12, 36, 22, 3, -36 },
  { 956, 17, 37, 22, 2, -37 },
  { 1035, 17, 38, 22, 2, -37 },
  { 1116, 20, 37, 22, 1, -37 },
  { 1209, 18, 37, 22, 2, -36 },
  { 1293, 18, 38, 22, 2, -37 },
  { 1379, 18, 36, 22, 2, -36 },
  { 1460, 18, 38, 22, 2, -37 },
  { 1546, 17, 38, 22, 2, -37 },
  { 1627, 6, 28, 12, 3, -28 },
  { 1648, 7, 35, 12, 2, -28 },
  { 1679, 19, 22, 22, 1, -29 },
  { 1732, 18, 14, 22, 2, -25 },
  { 1764, 18, 22, 22, 2, -29 },
  { 1814, 14, 37, 16, 1, -37 },
  { 1879, 29, 41, 33, 2, -37 },
  { 2028, 23, 36, 23, 0, -36 },
  { 2132, 18, 36, 24, 4, -36 },
  { 2213, 19, 38, 23, 3, -37 },
  { 2304, 20, 36, 26, 4, -36 },
  { 2394, 14, 36, 21, 4, -36 },
  { 2457, 14, 36, 19, 4, -36 },
  { 2520, 22, 38, 28, 3, -37 },
  { 2625, 20, 36, 27, 4, -36 },
  { 2715, 11, 36, 14, 2, -36 },
  { 2765, 11, 46, 11, -3, -36 },
  { 2829, 19, 36, 23, 4, -36 },
  { 2915, 14, 36, 19, 4, -36 },
  { 2978, 29, 36, 37, 4, -36 },
  { 3109, 21, 36, 29, 4, -36 },
  { 3204, 23, 38, 28, 3, -37 },
  { 3314, 17, 36, 23, 4, -36 },
  { 3391, 23, 46, 28, 3, -37 },
  { 3524, 19, 36, 24, 4, -36 },
  { 3610, 17, 38, 21, 2, -37 },
  { 3691, 18, 36, 19, 1, -36 },
  { 3772, 20, 37, 27, 3, -36 },
  { 3865, 22, 36, 22, 0, -36 },
  { 3964, 37, 36, 37, 0, -36 },
  { 4131, 20, 36, 20, 0, -36 },
  { 4221, 20, 36, 20, 0, -36 },
  { 4311, 16, 36, 18, 1, -36 },
  { 4383, 10, 45, 16, 4, -37 },
  { 4440, 17, 37, 19, 1, -37 },
  { 4519, 10, 45, 16, 2, -37 },
  { 4576, 21, 19, 23, 1, -36 },
  { 4626, 22, 3, 22, 0, 4 },
  { 4635, 10, 8, 14, 2, -39 },
  { 4645, 16, 29, 21, 2, -28 },
  { 4703, 18, 40, 24, 3, -39 },
  { 4793, 15, 29, 18, 2, -28 },
  { 4848, 18, 40, 24, 2, -39 },
  { 4938, 17, 29, 21, 2, -28 },
  { 5000, 14, 39, 13, 0, -39 },
  { 5069, 18, 40, 24, 2, -28 },
  { 5159, 17, 39, 23, 3, -39 },
  { 5242, 5, 38, 11, 3, -38 },
  { 5266, 9, 50, 11, -1, -38 },
  { 5323, 17, 39, 20, 3, -39 },
  { 5406, 4, 39, 11, 3, -39 },
  { 5426, 29, 28, 35, 3, -28 },
  { 5528, 17, 28, 23, 3, -28 },
  { 5588, 19, 29, 23, 2, -28 },
  { 5657, 18, 40, 24, 3, -28 },
  { 5747, 18, 40, 24, 2, -28 },
  { 5837, 12, 28, 16, 3, -28 },
  { 5879, 14, 29, 17, 2, -28 },
  { 5930, 12, 35, 13, 1, -34 },
  { 5983, 17, 28, 23, 3, -27 },
  { 6043, 19, 27, 19, 0, -27 },
  { 6108, 30, 27, 31, 0, -27 },
  { 6210, 17, 27, 19, 1, -27 },
  { 6268, 19, 39, 19, 0, -27 },
  { 6361, 13, 27, 15, 1, -27 },
  { 6405, 14, 45, 18, 2, -37 },
  { 6484, 4, 51, 21, 8, -39 },
  { 6510, 14, 45, 18, 2, -37 },
  { 6589, 20, 6, 22, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Regular51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR51PT7B_H_
