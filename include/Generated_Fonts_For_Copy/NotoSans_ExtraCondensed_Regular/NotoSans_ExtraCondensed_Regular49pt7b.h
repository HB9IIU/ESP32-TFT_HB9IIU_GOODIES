#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xE7, 0x39, 0xCE, 0x70, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xDE, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3B, 0xC1, 0xDE, 0x0E,
  0xF0, 0x77, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x1F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0x83, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x1E, 0x00, 0xF0, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x01, 0xE1,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xBE, 0x79, 0xC1,
  0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xC7,
  0x00, 0xF3, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0x7C, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE1,
  0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x7C, 0x0E, 0x7B, 0xC7, 0x7D, 0xFF,
  0xFC, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x1C, 0x01, 0xFC, 0x01,
  0xC0, 0x1F, 0xF0, 0x0E, 0x00, 0xE3, 0x80, 0xF0, 0x07, 0x1E, 0x07, 0x00,
  0x78, 0x70, 0x38, 0x03, 0x83, 0x83, 0xC0, 0x1C, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0xE0, 0x07, 0x07, 0x0F, 0x00, 0x38, 0x38, 0x70, 0x01, 0xC1, 0xC3,
  0x80, 0x0E, 0x0E, 0x3C, 0x00, 0x70, 0x71, 0xC1, 0x03, 0x83, 0x8E, 0x3F,
  0x1E, 0x1C, 0xF3, 0xFC, 0x71, 0xE7, 0x1F, 0xE3, 0x8E, 0x39, 0xC7, 0x9F,
  0xF3, 0xCE, 0x1C, 0x7F, 0x1C, 0x70, 0xE1, 0xF0, 0xE7, 0x87, 0x00, 0x0E,
  0x3C, 0x38, 0x00, 0x71, 0xE1, 0xE0, 0x07, 0x8E, 0x0F, 0x00, 0x38, 0x70,
  0x78, 0x01, 0xC3, 0x83, 0xC0, 0x1E, 0x1E, 0x1E, 0x00, 0xE0, 0xF0, 0xE0,
  0x07, 0x07, 0x87, 0x00, 0x78, 0x1C, 0x38, 0x03, 0x80, 0xE1, 0xC0, 0x1C,
  0x07, 0x1E, 0x01, 0xE0, 0x1F, 0xE0, 0x0E, 0x00, 0xFF, 0x00, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xC7, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x07, 0x8F, 0xBC, 0x1E, 0x3C, 0x78, 0x79, 0xE1,
  0xF1, 0xE7, 0x83, 0xCF, 0x1E, 0x07, 0xBC, 0xF8, 0x1E, 0xF3, 0xE0, 0x3F,
  0xCF, 0x00, 0xFE, 0x3E, 0x01, 0xF8, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x87,
  0xC0, 0xFE, 0x1F, 0x8F, 0xFC, 0x3F, 0xFE, 0xF8, 0x7F, 0xF1, 0xE0, 0xFF,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x70, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x83, 0x82, 0xF3, 0x9E, 0xFF, 0xFE, 0xFF,
  0xFF, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C,
  0x7C, 0x7C, 0x38, 0x08, 0x30, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x3E, 0x78, 0xF1, 0xE7, 0xCF, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xC3, 0xC1, 0xE3, 0xE0,
  0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xE0, 0xF0, 0xF0, 0x78, 0x7E, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFC, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xDF,
  0x7F, 0xCF, 0x71, 0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0x0F,
  0xC6, 0x01, 0xE2, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xFE, 0x3F,
  0xFF, 0x1F, 0x0F, 0xC6, 0x01, 0xF2, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFA, 0x00,
  0x7D, 0xE0, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3B, 0xC0, 0x07, 0x78, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x0F, 0x3C,
  0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x78,
  0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC4, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x10, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xFA, 0x00, 0xF9, 0xE0, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x81, 0xF8, 0x41, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x8F, 0xC3, 0xCF, 0xF1, 0xEF, 0xFC, 0xFF,
  0xFE, 0x7E, 0x0F, 0xBE, 0x03, 0xDF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0xF3, 0xE0, 0x78, 0xF0, 0x7C, 0x7C, 0x7C, 0x1F, 0xFE, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3F, 0xE0, 0x0F,
  0x70, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE3, 0xC1, 0xE1, 0xF1,
  0xF0, 0x7D, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x07,
  0xCF, 0xC7, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x3E, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xC7, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0x78, 0x1F, 0xBE, 0x0F,
  0xDF, 0xFD, 0xE7, 0xFE, 0xE1, 0xFE, 0x70, 0x7E, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x83, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x7F, 0xFF, 0xFB, 0xC0, 0x7C, 0xF9, 0xF3, 0xE7, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE7, 0x8F, 0x1E, 0x7C, 0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFF, 0xCF, 0xFF, 0x3C,
  0x7E, 0x40, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C,
  0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x3C, 0x1E, 0x38, 0x1F, 0xF0, 0xE3, 0x83,
  0xFF, 0x0E, 0x78, 0x78, 0xF0, 0xE7, 0x07, 0x8F, 0x0E, 0x70, 0x70, 0xF0,
  0xF7, 0x0F, 0x0F, 0x0F, 0x70, 0xE0, 0xF0, 0xFF, 0x0E, 0x0F, 0x0F, 0xF0,
  0xE0, 0xF0, 0xFF, 0x0E, 0x0F, 0x0F, 0xF0, 0xE0, 0xE0, 0xFF, 0x0E, 0x0E,
  0x0E, 0xF0, 0xE0, 0xE0, 0xEF, 0x0E, 0x0E, 0x0E, 0x70, 0xF1, 0xE0, 0xE7,
  0x0F, 0x1F, 0x1C, 0x70, 0x7F, 0xBF, 0xC7, 0x07, 0xF3, 0xF8, 0x78, 0x3E,
  0x1F, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x7C,
  0x03, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x73, 0x80, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x03, 0x80,
  0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x01, 0xE0, 0xF8, 0x07,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xC0, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01,
  0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xFB, 0xC0, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3C, 0x3F, 0x9E, 0x03, 0xEF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7D, 0xFF, 0xFE, 0xFF, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFC, 0x3C, 0x3F, 0x00, 0x87, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x02, 0x0F, 0xE1, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x03, 0xF1, 0xE0, 0x3F, 0x3C, 0x03, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78,
  0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x3E, 0x3C, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFC, 0x3E, 0x0F, 0x80,
  0x18, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xF8, 0x03,
  0xC3, 0xFC, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x9F, 0xBF,
  0xCF, 0xF3, 0xF8, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C,
  0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C,
  0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xF9, 0xE0, 0x3C, 0x7C, 0x0F, 0x0F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0xF0, 0x1E, 0x3C, 0x07, 0xCF, 0x01,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7C, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xEE, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0xEF, 0xEF,
  0x00, 0x1E, 0xFE, 0xF0, 0x01, 0xEF, 0xE7, 0x00, 0x1C, 0xFE, 0x78, 0x01,
  0xCF, 0xE7, 0x80, 0x3C, 0xFF, 0x38, 0x03, 0xCF, 0xF3, 0xC0, 0x38, 0xFF,
  0x3C, 0x07, 0x8F, 0xF3, 0xC0, 0x78, 0xFF, 0x1C, 0x07, 0x0F, 0xF1, 0xE0,
  0x70, 0xFF, 0x1E, 0x0F, 0x0F, 0xF0, 0xE0, 0xF0, 0xFF, 0x0F, 0x0E, 0x0F,
  0xF0, 0xF1, 0xE0, 0xFF, 0x0F, 0x1E, 0x0F, 0xF0, 0x71, 0xC0, 0xFF, 0x07,
  0x9C, 0x0F, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xF0, 0x0F, 0xF0,
  0x1F, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFE, 0xF0, 0x0F, 0xEF, 0x00, 0xFE, 0x78, 0x0F, 0xE7,
  0x80, 0xFE, 0x38, 0x0F, 0xE3, 0xC0, 0xFE, 0x3C, 0x0F, 0xF1, 0xE0, 0xFF,
  0x1E, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x07, 0x8F,
  0xF0, 0x78, 0xFF, 0x03, 0xCF, 0xF0, 0x3C, 0xFF, 0x01, 0xEF, 0xF0, 0x1E,
  0x7F, 0x01, 0xE7, 0xF0, 0x0F, 0x7F, 0x00, 0xF7, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E,
  0x3F, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3E, 0x1E, 0x00,
  0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF9, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF7,
  0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xE0,
  0x0F, 0x83, 0xC0, 0x1E, 0x07, 0xC0, 0x7C, 0x07, 0xE3, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x7E, 0x3F, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x80,
  0x3E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0xC0, 0x7C, 0x07, 0xE3,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x7E, 0x3C, 0x07, 0xCF, 0x01,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x7E, 0x3F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F,
  0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF8,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC,
  0x01, 0xEF, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0x3E, 0x7C, 0x02, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x3E, 0xFC, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x07, 0xDF, 0x01,
  0xF1, 0xFC, 0x7E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x78, 0x00,
  0xF9, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0,
  0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1E,
  0x00, 0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x38, 0x00, 0x3D,
  0xE0, 0x00, 0x77, 0x80, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0x00, 0x3D, 0xE0, 0x07, 0xC0,
  0x0F, 0xBC, 0x00, 0xF8, 0x01, 0xE7, 0x80, 0x1F, 0x00, 0x3C, 0xF0, 0x03,
  0xF0, 0x07, 0x8F, 0x00, 0xFE, 0x00, 0xF1, 0xE0, 0x1D, 0xC0, 0x3E, 0x3C,
  0x03, 0xB8, 0x07, 0x87, 0x80, 0x77, 0x00, 0xF0, 0xF0, 0x0E, 0xF0, 0x1E,
  0x0F, 0x03, 0xDE, 0x03, 0xC1, 0xE0, 0x79, 0xC0, 0xF8, 0x3C, 0x0E, 0x38,
  0x1E, 0x07, 0x81, 0xC7, 0x03, 0xC0, 0xF0, 0x38, 0xF0, 0x78, 0x0F, 0x0F,
  0x1E, 0x0F, 0x01, 0xE1, 0xE1, 0xC3, 0xE0, 0x3C, 0x3C, 0x38, 0x78, 0x07,
  0x87, 0x07, 0x0F, 0x00, 0xF0, 0xE0, 0xF1, 0xE0, 0x0F, 0x3C, 0x1E, 0x3C,
  0x01, 0xE7, 0x81, 0xCF, 0x80, 0x3C, 0xF0, 0x39, 0xE0, 0x07, 0x9C, 0x07,
  0x3C, 0x00, 0xF3, 0x80, 0xF7, 0x80, 0x0E, 0x70, 0x1E, 0xF0, 0x01, 0xFE,
  0x01, 0xDC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x03,
  0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x07, 0x0F, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x01, 0xCF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xF1,
  0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0xF0, 0x01,
  0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x0F, 0x38, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0x1E, 0x00, 0xF0, 0xF0,
  0x0E, 0x0F, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x83, 0xC0, 0x38, 0x3C, 0x03,
  0xC7, 0x80, 0x1C, 0x78, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xE1, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x1F, 0xF1, 0xFF, 0xE7, 0xFF, 0xDF, 0x87, 0xBC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xFC, 0x3F, 0x7F, 0xEE, 0xFF, 0x9C, 0xFE, 0x38, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x0F, 0x03, 0xCF, 0xF0, 0xF7,
  0xFE, 0x3D, 0xFF, 0xCF, 0xE1, 0xF3, 0xF0, 0x3C, 0xF8, 0x07, 0xBE, 0x01,
  0xEF, 0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0,
  0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3E, 0xFC, 0x0F, 0x3F, 0x87,
  0xCF, 0x7F, 0xE3, 0xCF, 0xF8, 0xF1, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0xF1,
  0xFF, 0xC7, 0xFE, 0x3E, 0x09, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x83, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x3C, 0x3F, 0x8F, 0x1F,
  0xF3, 0xCF, 0xFE, 0xF3, 0xC1, 0xFD, 0xF0, 0x3F, 0x78, 0x07, 0xDE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0x87,
  0xF3, 0xFF, 0xBC, 0x7F, 0xCF, 0x0F, 0xE3, 0xC0, 0x01, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xEF, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xE0, 0x3C, 0xF0,
  0x1E, 0x70, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x04, 0x7C, 0x0E, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x03,
  0xC0, 0x03, 0xF8, 0xF1, 0xFF, 0x3C, 0xFF, 0xEF, 0x3C, 0x1F, 0xDF, 0x03,
  0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x03,
  0xF7, 0xC0, 0xFC, 0xF8, 0x6F, 0x3F, 0xFB, 0xC7, 0xFC, 0xF0, 0xFE, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x90, 0x03, 0xC7, 0x01, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0xF0, 0xF3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF7, 0xBF, 0xEF, 0x00, 0x00, 0x00, 0x3D,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xE0, 0x0F, 0x07, 0x83, 0xE1, 0xE0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xEF, 0xE7, 0xF3, 0xF0, 0xE0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0,
  0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0xC0, 0xFF, 0xE0, 0xFD, 0xE0,
  0xFD, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x7C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x1E, 0x1C, 0x7F,
  0x0F, 0xF3, 0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0x7F, 0xEF, 0xC3, 0xFC, 0x3F,
  0xF0, 0x3F, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0xF0, 0x0F,
  0x01, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0xFF,
  0x00, 0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x78,
  0x0F, 0xF0, 0x0F, 0x01, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xF8,
  0x07, 0x80, 0xFF, 0x00, 0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0xC0,
  0x7F, 0x80, 0x78, 0x0F, 0xF0, 0x0F, 0x01, 0xFE, 0x01, 0xE0, 0x3F, 0xC0,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0xE3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x01, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3E, 0x1F, 0x1F, 0x03, 0xC7, 0x80,
  0x79, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0xC0,
  0xF0, 0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF0,
  0x3C, 0xFF, 0x0F, 0x7F, 0xE3, 0xDF, 0xFC, 0xFE, 0x1F, 0x3F, 0x03, 0xCF,
  0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xEF,
  0xC0, 0xF3, 0xF8, 0x7C, 0xF7, 0xFE, 0x3C, 0xFF, 0x8F, 0x1F, 0x83, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0xF1, 0xFF, 0x3C, 0xFF, 0xEF, 0x3C,
  0x1F, 0xDF, 0x03, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x78,
  0x07, 0xDE, 0x03, 0xF7, 0xC0, 0xFC, 0xF8, 0x6F, 0x3F, 0xFB, 0xC7, 0xFC,
  0xF0, 0xFE, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xFC, 0x7F, 0x9F, 0xFB, 0xFF,
  0xF3, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xFF, 0x9F,
  0xFF, 0xFF, 0xEF, 0x03, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xFC, 0x3E, 0xFF,
  0xF7, 0xFF, 0x1F, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE2, 0x3F, 0xC7, 0xF8, 0x7F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x77, 0x7F, 0xF7,
  0x3F, 0xE7, 0x1F, 0xC7, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x07, 0x03, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0x87, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x7B, 0xC0, 0x7C, 0x03, 0xDE, 0x03,
  0xF0, 0x1E, 0xF0, 0x1F, 0x80, 0xE7, 0x80, 0xFC, 0x0F, 0x1E, 0x0F, 0xE0,
  0x78, 0xF0, 0x77, 0x03, 0xC7, 0x83, 0xBC, 0x1E, 0x3C, 0x1C, 0xE1, 0xE0,
  0xE0, 0xE7, 0x0F, 0x07, 0x8F, 0x38, 0x78, 0x3C, 0x79, 0xC3, 0xC1, 0xE3,
  0x8F, 0x1C, 0x0F, 0x1C, 0x79, 0xE0, 0x38, 0xE1, 0xCF, 0x01, 0xEF, 0x0E,
  0x78, 0x0F, 0x78, 0x73, 0xC0, 0x7B, 0x83, 0xDC, 0x03, 0xDC, 0x1E, 0xE0,
  0x0E, 0xE0, 0x7F, 0x00, 0x77, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x87, 0x83, 0xC3, 0xC3,
  0xC0, 0xF1, 0xE0, 0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE0,
  0xF1, 0xE0, 0x78, 0xF0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xC0, 0xF8, 0x03,
  0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x1C, 0x0F, 0x07, 0x83, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x0E, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0x3C,
  0x01, 0xCE, 0x00, 0x7B, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x3F,
  0xC0, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xC0, 0x0F, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0x2F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x07, 0xF9, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 35, 12, 3, -35 },
  { 23, 13, 13, 19, 3, -35 },
  { 45, 21, 35, 23, 1, -35 },
  { 137, 17, 40, 21, 2, -37 },
  { 222, 29, 35, 33, 2, -35 },
  { 349, 22, 35, 23, 1, -35 },
  { 446, 4, 13, 10, 3, -35 },
  { 453, 11, 43, 14, 2, -35 },
  { 513, 11, 43, 14, 1, -35 },
  { 573, 16, 16, 19, 2, -37 },
  { 605, 19, 23, 21, 1, -29 },
  { 660, 7, 12, 11, 2, -6 },
  { 671, 11, 4, 13, 1, -15 },
  { 677, 5, 6, 11, 3, -6 },
  { 681, 17, 35, 18, 1, -35 },
  { 756, 17, 35, 21, 2, -35 },
  { 831, 11, 35, 21, 3, -35 },
  { 880, 17, 35, 21, 2, -35 },
  { 955, 17, 35, 21, 2, -35 },
  { 1030, 19, 35, 21, 1, -35 },
  { 1114, 17, 35, 21, 2, -35 },
  { 1189, 17, 35, 21, 2, -35 },
  { 1264, 17, 35, 21, 2, -35 },
  { 1339, 17, 35, 21, 2, -35 },
  { 1414, 17, 35, 21, 2, -35 },
  { 1489, 5, 26, 11, 3, -26 },
  { 1506, 7, 32, 11, 2, -26 },
  { 1534, 19, 22, 21, 1, -28 },
  { 1587, 19, 14, 21, 1, -24 },
  { 1621, 19, 22, 21, 1, -28 },
  { 1674, 14, 35, 16, 1, -35 },
  { 1736, 28, 39, 32, 2, -35 },
  { 1873, 22, 35, 22, 0, -35 },
  { 1970, 17, 35, 23, 4, -35 },
  { 2045, 19, 36, 22, 2, -36 },
  { 2131, 19, 35, 25, 4, -35 },
  { 2215, 14, 35, 20, 4, -35 },
  { 2277, 14, 35, 19, 4, -35 },
  { 2339, 22, 35, 27, 2, -35 },
  { 2436, 19, 35, 26, 4, -35 },
  { 2520, 10, 35, 14, 2, -35 },
  { 2564, 10, 44, 11, -2, -35 },
  { 2619, 18, 35, 22, 4, -35 },
  { 2698, 13, 35, 18, 4, -35 },
  { 2755, 28, 35, 35, 4, -35 },
  { 2878, 20, 35, 28, 4, -35 },
  { 2966, 23, 35, 27, 2, -35 },
  { 3067, 16, 35, 22, 4, -35 },
  { 3137, 23, 43, 27, 2, -35 },
  { 3261, 18, 35, 23, 4, -35 },
  { 3340, 16, 36, 20, 2, -36 },
  { 3412, 18, 35, 19, 0, -35 },
  { 3491, 19, 35, 26, 3, -35 },
  { 3575, 22, 35, 22, 0, -35 },
  { 3672, 35, 35, 35, 0, -35 },
  { 3826, 19, 35, 20, 0, -35 },
  { 3910, 19, 35, 19, 0, -35 },
  { 3994, 16, 35, 18, 1, -35 },
  { 4064, 10, 43, 15, 4, -35 },
  { 4118, 17, 35, 18, 1, -35 },
  { 4193, 10, 43, 15, 2, -35 },
  { 4247, 20, 19, 22, 1, -35 },
  { 4295, 22, 3, 21, 0, 4 },
  { 4304, 9, 8, 13, 2, -38 },
  { 4313, 15, 27, 20, 2, -27 },
  { 4364, 18, 37, 23, 3, -37 },
  { 4448, 14, 27, 17, 2, -27 },
  { 4496, 18, 37, 23, 2, -37 },
  { 4580, 17, 27, 20, 2, -27 },
  { 4638, 14, 37, 12, 0, -37 },
  { 4703, 18, 39, 23, 2, -27 },
  { 4791, 16, 37, 22, 3, -37 },
  { 4865, 5, 36, 10, 3, -36 },
  { 4888, 9, 48, 10, -1, -36 },
  { 4942, 16, 37, 20, 3, -37 },
  { 5016, 4, 37, 10, 3, -37 },
  { 5035, 27, 27, 33, 3, -27 },
  { 5127, 16, 27, 22, 3, -27 },
  { 5181, 18, 27, 22, 2, -27 },
  { 5242, 18, 39, 23, 3, -27 },
  { 5330, 18, 39, 23, 2, -27 },
  { 5418, 11, 27, 15, 3, -27 },
  { 5456, 13, 27, 17, 2, -27 },
  { 5500, 11, 32, 13, 1, -32 },
  { 5544, 16, 26, 22, 3, -26 },
  { 5596, 18, 26, 18, 0, -26 },
  { 5655, 29, 26, 30, 0, -26 },
  { 5750, 17, 26, 18, 1, -26 },
  { 5806, 18, 38, 18, 0, -26 },
  { 5892, 13, 26, 15, 1, -26 },
  { 5935, 14, 43, 18, 2, -35 },
  { 6011, 4, 49, 20, 8, -37 },
  { 6036, 14, 43, 18, 2, -35 },
  { 6112, 19, 6, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Regular49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR49PT7B_H_
