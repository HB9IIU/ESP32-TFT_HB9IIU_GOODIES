#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x5F, 0x6F, 0x66, 0x46, 0xC6, 0x5D, 0x64, 0x42, 0xCB,
  0x2A, 0x74, 0xD2, 0x80, 0x46, 0x64, 0xBB, 0x70, 0xC0, 0x5A, 0x94, 0xD5,
  0x5C, 0x5D, 0x80, 0x4F, 0x44, 0x60, 0xC0, 0x80, 0x25, 0x25, 0x00, 0x4E,
  0xDB, 0x58, 0xD5, 0x50, 0x54, 0x92, 0xB8, 0x54, 0xB2, 0x78, 0x26, 0x6A,
  0xF2, 0xF3, 0x93, 0xC0, 0x2A, 0x7B, 0x58, 0xF2, 0x22, 0x44, 0x4A, 0xA6,
  0xA9, 0x60, 0x56, 0xD6, 0x58, 0x88, 0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3,
  0x68, 0x54, 0xA4, 0x10, 0x7B, 0xEF, 0x7A, 0xA0, 0xC0, 0x66, 0x66, 0x99,
  0xF7, 0x5B, 0xC0, 0x25, 0x88, 0x84, 0x70, 0xF6, 0xDB, 0x80, 0xEE, 0xB0,
  0xEE, 0xA0, 0x25, 0x88, 0x95, 0x70, 0xB7, 0xDB, 0x40, 0xD5, 0x70, 0xFF,
  0xBA, 0x6D, 0x40, 0xAA, 0xB0, 0x9C, 0xF7, 0xDE, 0xD4, 0xB7, 0xFB, 0x40,
  0x22, 0xA5, 0x18, 0xA9, 0xC0, 0xF6, 0xE9, 0x00, 0x22, 0xA3, 0x18, 0xA9,
  0xC2, 0x10, 0xF7, 0x6D, 0x40, 0x72, 0x22, 0x78, 0xE9, 0x24, 0x80, 0xB6,
  0xDB, 0xC0, 0x99, 0x66, 0x66, 0x96, 0x57, 0x5B, 0x69, 0x20, 0xA6, 0x46,
  0x6B, 0xB6, 0x44, 0x44, 0xE5, 0x29, 0xC0, 0xEA, 0xAC, 0x89, 0x22, 0x40,
  0xD5, 0x5C, 0x66, 0x90, 0xF0, 0xD0, 0x65, 0xDE, 0x93, 0x5B, 0x70, 0x72,
  0x46, 0x11, 0x79, 0x99, 0x70, 0x77, 0xC6, 0x5D, 0x54, 0x79, 0x99, 0x71,
  0x60, 0x93, 0x5B, 0x68, 0xBE, 0xBF, 0x80, 0x93, 0x69, 0xB8, 0xFE, 0xD5,
  0x6B, 0x5A, 0x80, 0xD6, 0xDA, 0x69, 0x99, 0x60, 0xD6, 0xDD, 0x20, 0x79,
  0x99, 0x71, 0x10, 0xEA, 0x80, 0x71, 0x1E, 0x7A, 0x90, 0xB6, 0xDE, 0xB6,
  0xA4, 0xAD, 0x6E, 0xB5, 0x00, 0xAD, 0x3A, 0xB6, 0xA4, 0xB0, 0xC9, 0x4E,
  0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 3, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 6, 7, 6, 0, -7 },
  { 16, 4, 7, 4, 0, -7 },
  { 20, 1, 2, 2, 0, -6 },
  { 21, 2, 7, 3, 0, -6 },
  { 23, 2, 7, 3, 0, -6 },
  { 25, 3, 3, 4, 0, -7 },
  { 27, 4, 4, 4, 0, -5 },
  { 29, 2, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -3 },
  { 31, 1, 1, 2, 1, -1 },
  { 32, 3, 6, 3, 0, -6 },
  { 35, 3, 7, 4, 0, -7 },
  { 38, 2, 6, 4, 1, -6 },
  { 40, 3, 7, 4, 0, -7 },
  { 43, 3, 7, 4, 0, -7 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 3, 6, 4, 0, -6 },
  { 52, 3, 7, 4, 0, -7 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 3, 7, 4, 0, -7 },
  { 65, 1, 5, 2, 1, -5 },
  { 66, 2, 6, 2, 0, -5 },
  { 68, 4, 4, 4, 0, -5 },
  { 70, 4, 2, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -5 },
  { 73, 3, 7, 3, 0, -7 },
  { 76, 5, 7, 6, 0, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 3, 6, 4, 1, -6 },
  { 87, 4, 7, 4, 0, -7 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 2, 6, 4, 1, -6 },
  { 96, 2, 6, 3, 1, -6 },
  { 98, 4, 7, 5, 0, -7 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 2, 6, 3, 0, -6 },
  { 107, 1, 8, 2, 0, -6 },
  { 108, 3, 6, 4, 1, -6 },
  { 111, 2, 6, 3, 1, -6 },
  { 113, 5, 6, 6, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 5, 7, 5, 0, -7 },
  { 125, 3, 6, 4, 1, -6 },
  { 128, 5, 9, 5, 0, -7 },
  { 134, 3, 6, 4, 1, -6 },
  { 137, 3, 7, 4, 0, -7 },
  { 140, 3, 6, 3, 0, -6 },
  { 143, 3, 6, 5, 1, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 6, 6, 6, 0, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 3, 6, 3, 0, -6 },
  { 163, 2, 7, 3, 1, -6 },
  { 165, 3, 6, 3, 0, -6 },
  { 168, 2, 7, 3, 0, -6 },
  { 170, 4, 3, 4, 0, -6 },
  { 172, 4, 1, 4, 0, 1 },
  { 173, 2, 2, 2, 0, -7 },
  { 174, 3, 5, 4, 0, -5 },
  { 176, 3, 7, 4, 1, -7 },
  { 179, 3, 5, 3, 0, -5 },
  { 181, 4, 7, 4, 0, -7 },
  { 185, 3, 5, 4, 0, -5 },
  { 187, 2, 7, 2, 0, -7 },
  { 189, 4, 7, 4, 0, -5 },
  { 193, 3, 7, 4, 1, -7 },
  { 196, 1, 7, 2, 0, -7 },
  { 197, 1, 9, 2, 0, -7 },
  { 199, 3, 7, 4, 1, -7 },
  { 202, 1, 7, 2, 0, -7 },
  { 203, 5, 5, 6, 1, -5 },
  { 207, 3, 5, 4, 1, -5 },
  { 209, 4, 5, 4, 0, -5 },
  { 212, 3, 7, 4, 1, -5 },
  { 215, 4, 7, 4, 0, -5 },
  { 219, 2, 5, 3, 1, -5 },
  { 221, 3, 5, 3, 0, -5 },
  { 223, 2, 6, 2, 0, -6 },
  { 225, 3, 5, 4, 1, -5 },
  { 227, 3, 5, 3, 0, -5 },
  { 229, 5, 5, 5, 0, -5 },
  { 233, 3, 5, 3, 0, -5 },
  { 235, 3, 7, 3, 0, -5 },
  { 238, 3, 5, 3, 0, -5 },
  { 240, 3, 7, 3, 0, -6 },
  { 243, 1, 9, 4, 1, -7 },
  { 245, 3, 7, 3, 0, -6 },
  { 248, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Regular9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR9PT7B_H_
