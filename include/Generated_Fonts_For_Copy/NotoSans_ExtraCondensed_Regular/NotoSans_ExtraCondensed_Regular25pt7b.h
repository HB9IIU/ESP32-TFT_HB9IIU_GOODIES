#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xE6, 0xCD, 0x9B, 0x36, 0x68, 0xD1,
  0x80, 0x0C, 0xC1, 0x10, 0x22, 0x04, 0x40, 0x88, 0xFF, 0xDF, 0xF8, 0xCC,
  0x19, 0x82, 0x30, 0x44, 0x7F, 0xFF, 0xFE, 0x66, 0x0C, 0xC1, 0x98, 0x33,
  0x06, 0x60, 0x08, 0x04, 0x0F, 0x8F, 0xEC, 0x96, 0x43, 0x21, 0x90, 0x68,
  0x1E, 0x07, 0x81, 0x60, 0x98, 0x4C, 0x27, 0x16, 0xFE, 0x1C, 0x02, 0x01,
  0x00, 0x70, 0x60, 0xF0, 0xC3, 0x21, 0x06, 0x66, 0x0C, 0xCC, 0x19, 0x90,
  0x33, 0x60, 0x66, 0xDC, 0xC9, 0x3C, 0xF6, 0xC9, 0xCD, 0x90, 0x13, 0x30,
  0x64, 0x60, 0xC8, 0xC1, 0x19, 0x86, 0x32, 0x0C, 0x6C, 0x30, 0x70, 0x3C,
  0x0F, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x0D, 0x81, 0xE0, 0x38, 0x0F,
  0x9B, 0xB3, 0x63, 0x6C, 0x6D, 0x87, 0x30, 0xE6, 0x1C, 0xFE, 0xCF, 0x9C,
  0xED, 0xB6, 0x90, 0x1C, 0x63, 0x0C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x30,
  0xC3, 0x0E, 0x18, 0x61, 0x83, 0x0C, 0x18, 0x70, 0xC3, 0x18, 0x63, 0x18,
  0xC3, 0x18, 0xC6, 0x31, 0x8C, 0x67, 0x31, 0x8C, 0xC6, 0x60, 0x18, 0x18,
  0x99, 0xFF, 0x18, 0x3C, 0x66, 0x66, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87,
  0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x6D, 0xFD, 0x80, 0xFF,
  0xC0, 0x7D, 0x80, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x00,
  0x3C, 0x3F, 0x18, 0xCC, 0x6C, 0x36, 0x1B, 0x0F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x7C, 0x36, 0x1B, 0x8C, 0xC6, 0x7E, 0x1E, 0x00, 0x19, 0xDF, 0xFD,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x7C, 0x7F, 0x11,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x81,
  0x81, 0x81, 0xC0, 0xFF, 0xFF, 0xC0, 0x7C, 0x7F, 0x10, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x1C, 0x3C, 0x1F, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x0D, 0x06,
  0xFF, 0x7E, 0x00, 0x03, 0x80, 0xE0, 0x78, 0x16, 0x0F, 0x82, 0xE1, 0xB8,
  0x4E, 0x33, 0x8C, 0xE6, 0x39, 0x8E, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x02, 0x03, 0x01, 0xF8, 0xFE,
  0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0D, 0x0E, 0xFE, 0x7E, 0x00, 0x1F,
  0x1F, 0x8C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0xBC, 0xFF, 0x71, 0xB0, 0xF8,
  0x3C, 0x1E, 0x0D, 0x8C, 0xC6, 0x7F, 0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x38, 0x00, 0x3E, 0x3F, 0x98, 0xD8, 0x6C, 0x3E, 0x19,
  0x8C, 0x6C, 0x1C, 0x1F, 0x19, 0xD8, 0x6C, 0x1E, 0x0F, 0x07, 0x87, 0x7F,
  0x1F, 0x00, 0x3C, 0x3F, 0x38, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x87, 0xC3,
  0xBE, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x7C, 0x3C, 0x00, 0x4F,
  0xA0, 0x00, 0x00, 0x3E, 0xC0, 0x4F, 0xA0, 0x00, 0x00, 0x36, 0xDE, 0xC0,
  0x01, 0x83, 0xC7, 0x87, 0x0E, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0,
  0x20, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x1C, 0x3C, 0x78, 0xF0, 0x60, 0x20, 0x00, 0x7D, 0xFD,
  0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x30, 0x41, 0x83, 0x00, 0x00, 0x18,
  0x38, 0x70, 0x07, 0xC0, 0x7B, 0x81, 0x83, 0x0C, 0x06, 0x60, 0x09, 0x8F,
  0x34, 0x6C, 0xF3, 0x33, 0xCC, 0xCF, 0x33, 0x3C, 0xCC, 0xF3, 0x33, 0xCC,
  0xCF, 0x37, 0xE4, 0x77, 0x98, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xCC, 0x03,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xCC,
  0x31, 0x86, 0x30, 0xFE, 0x1F, 0xE7, 0x0C, 0xC1, 0x98, 0x33, 0x07, 0xE0,
  0x78, 0x0C, 0xFC, 0x7F, 0xB0, 0xD8, 0x7C, 0x3E, 0x1F, 0x0D, 0x8E, 0xFC,
  0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x86, 0xFF, 0x7F, 0x00, 0x0F,
  0xCF, 0xE3, 0x09, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x3F, 0x83, 0xE0, 0xFC, 0x3F,
  0x8C, 0x73, 0x0E, 0xC1, 0xB0, 0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xB0, 0x6C, 0x3B, 0x1C, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x80, 0x0F, 0xC3, 0xFC, 0xE0, 0xB8, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x3F, 0x01, 0xF0, 0x36, 0x06, 0xC0,
  0xDC, 0x19, 0x83, 0x3F, 0xE1, 0xFC, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x70, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x77, 0xC0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xFB, 0x80, 0xC1, 0xE1, 0xB1, 0xD8,
  0xCC, 0xE6, 0x63, 0x71, 0xB0, 0xF8, 0x7C, 0x3B, 0x19, 0x8C, 0xE6, 0x33,
  0x1D, 0x86, 0xC3, 0xE0, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xBD, 0x86, 0xF6, 0x1B, 0xD8,
  0x6F, 0x23, 0x3C, 0xCC, 0xF3, 0x33, 0xCC, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC3, 0x0F, 0x0C, 0x30, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xF6,
  0x3D, 0x8F, 0x63, 0xCC, 0xF3, 0x3C, 0x6F, 0x1B, 0xC3, 0xF0, 0xDC, 0x3F,
  0x07, 0xC1, 0xF0, 0x30, 0x1F, 0x03, 0xFC, 0x70, 0xC6, 0x0E, 0x60, 0x6E,
  0x06, 0xE0, 0x6C, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x6E, 0x06, 0x60, 0x66,
  0x06, 0x60, 0xE7, 0x0C, 0x3F, 0xC1, 0xF8, 0xF8, 0xFE, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x1F, 0x03, 0xFC, 0x70, 0xC6, 0x0E, 0x60, 0x6E, 0x06, 0xE0, 0x6C,
  0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x6E, 0x06, 0x60, 0x66, 0x06, 0x60, 0xE7,
  0x0C, 0x3F, 0xC1, 0xF8, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0xF8, 0x7F,
  0x31, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC6, 0x7E, 0x3F, 0x19, 0x8C,
  0x66, 0x33, 0x1D, 0x86, 0xC3, 0xE0, 0xC0, 0x3F, 0x7F, 0xE1, 0xC0, 0xC0,
  0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0x03, 0x03, 0x03, 0x87, 0xFE,
  0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xC3, 0x7F, 0x1F, 0x00, 0xC0, 0x7C, 0x0D, 0x83, 0x30,
  0x66, 0x0C, 0xC1, 0x8C, 0x71, 0x8C, 0x31, 0x86, 0x30, 0xEE, 0x0D, 0x81,
  0xB0, 0x36, 0x06, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0xC0, 0xC0, 0xF0, 0x30,
  0x36, 0x0C, 0x19, 0x87, 0x86, 0x61, 0xE1, 0x98, 0x78, 0x66, 0x1E, 0x38,
  0xC4, 0x8C, 0x33, 0x33, 0x0C, 0xCC, 0xC3, 0x33, 0x30, 0xCC, 0xDC, 0x1A,
  0x16, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0x03,
  0x00, 0x61, 0xD8, 0x63, 0x18, 0xCC, 0x33, 0x06, 0xC1, 0xE0, 0x78, 0x0C,
  0x03, 0x81, 0xE0, 0x78, 0x33, 0x0C, 0xC3, 0x31, 0x86, 0x61, 0xB8, 0x70,
  0xC1, 0xF8, 0x66, 0x19, 0x86, 0x33, 0x0C, 0xC3, 0x30, 0x78, 0x1E, 0x07,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFE,
  0xFE, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60,
  0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xE0, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x04, 0x01, 0xC0, 0x38, 0x0D, 0x81,
  0xB0, 0x63, 0x0C, 0x63, 0x06, 0x60, 0xD8, 0x0C, 0xFF, 0xFF, 0xFC, 0xE3,
  0x0C, 0x30, 0x18, 0x7E, 0x46, 0x03, 0x03, 0x03, 0x3F, 0x73, 0xC3, 0xC3,
  0xC3, 0xC7, 0xEF, 0x7B, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x43, 0xF9,
  0xCE, 0xC3, 0x61, 0xB0, 0xD8, 0x7C, 0x3E, 0x1B, 0x0D, 0x86, 0xC3, 0x7F,
  0x27, 0x80, 0x1C, 0x7D, 0xCB, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x83,
  0x07, 0xE7, 0xC0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0xCD, 0xF6, 0xC7,
  0xE3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x63, 0xBB, 0xCF,
  0x60, 0x1C, 0x3E, 0x63, 0x63, 0xC3, 0xC1, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0x60, 0x7F, 0x3F, 0x1E, 0x7C, 0xC1, 0x83, 0x06, 0x3F, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x18, 0x1E, 0xD8, 0xFC,
  0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x6C, 0x77, 0xF9, 0xEC,
  0x06, 0x03, 0x01, 0xC1, 0x9F, 0xCF, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xCC, 0xFE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xEC, 0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x73, 0x00, 0x03,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x37, 0xEC, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC1, 0xC6, 0xCC, 0xCC, 0xD8, 0xF8, 0xF8, 0xF8, 0xDC, 0xCC,
  0xCC, 0xC6, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x65, 0xF7,
  0xF9, 0xE7, 0x8E, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E,
  0x18, 0xF0, 0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x8C, 0x08, 0xBE, 0xE6, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1C, 0x1F,
  0x18, 0xCC, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x6C, 0x67,
  0xF1, 0xF0, 0x08, 0x5F, 0x39, 0xD8, 0x6C, 0x36, 0x1B, 0x0F, 0x87, 0xC3,
  0x61, 0xB0, 0xD8, 0x6F, 0xE6, 0xF3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x00, 0x18, 0x1E, 0xD8, 0xFC, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x6C, 0x77, 0xF9, 0xEC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x0D, 0xEF, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x60, 0x18, 0xFF, 0x16,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x7F, 0xDF, 0x00, 0x30, 0xC3,
  0x3F, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xCF, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC7, 0xFF, 0x7B, 0xC1,
  0xB0, 0xD8, 0xCC, 0x66, 0x31, 0x98, 0xD8, 0x6C, 0x36, 0x0B, 0x07, 0x03,
  0x81, 0xC0, 0xC3, 0x86, 0xC7, 0x09, 0x8A, 0x33, 0x14, 0x66, 0x6C, 0xCC,
  0xD9, 0x8D, 0xB6, 0x1B, 0x2C, 0x34, 0x58, 0x78, 0xF0, 0x71, 0xE0, 0xE3,
  0x81, 0xC7, 0x00, 0x63, 0xB9, 0x8D, 0xC6, 0xC1, 0xE0, 0xE0, 0x70, 0x38,
  0x36, 0x1B, 0x1C, 0xCC, 0x6E, 0x18, 0xC1, 0xB0, 0xD8, 0xCC, 0x66, 0x31,
  0x98, 0xD8, 0x6C, 0x36, 0x0B, 0x07, 0x03, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x78, 0x38, 0x00, 0xFC, 0x31, 0x86, 0x38, 0xC3, 0x18, 0x63, 0x8C,
  0x3F, 0xFC, 0x06, 0x3C, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x63, 0x87,
  0x03, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xE1, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x38, 0x71, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x8F, 0x1C,
  0x00, 0xF8, 0xEF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 18, 6, 2, -18 },
  { 6, 7, 7, 9, 1, -18 },
  { 13, 11, 18, 12, 0, -18 },
  { 38, 9, 20, 11, 1, -19 },
  { 61, 15, 18, 17, 1, -18 },
  { 95, 11, 18, 12, 1, -18 },
  { 120, 3, 7, 5, 1, -18 },
  { 123, 6, 22, 7, 1, -18 },
  { 140, 5, 22, 7, 1, -18 },
  { 154, 8, 8, 10, 1, -19 },
  { 162, 9, 12, 11, 1, -15 },
  { 176, 3, 6, 6, 1, -3 },
  { 179, 5, 2, 7, 1, -8 },
  { 181, 3, 3, 6, 1, -3 },
  { 183, 9, 18, 9, 0, -18 },
  { 204, 9, 18, 11, 1, -18 },
  { 225, 5, 18, 11, 2, -18 },
  { 237, 9, 18, 11, 1, -18 },
  { 258, 9, 18, 11, 1, -18 },
  { 279, 10, 18, 11, 0, -18 },
  { 302, 9, 18, 11, 1, -18 },
  { 323, 9, 18, 11, 1, -18 },
  { 344, 9, 18, 11, 1, -18 },
  { 365, 9, 18, 11, 1, -18 },
  { 386, 9, 18, 11, 1, -18 },
  { 407, 3, 14, 6, 1, -14 },
  { 413, 3, 17, 6, 1, -14 },
  { 420, 9, 11, 11, 1, -14 },
  { 433, 9, 7, 11, 1, -12 },
  { 441, 9, 11, 11, 1, -14 },
  { 454, 7, 18, 8, 0, -18 },
  { 470, 14, 20, 16, 1, -18 },
  { 505, 11, 18, 11, 0, -18 },
  { 530, 9, 18, 12, 2, -18 },
  { 551, 10, 18, 11, 1, -18 },
  { 574, 10, 18, 13, 2, -18 },
  { 597, 7, 18, 10, 2, -18 },
  { 613, 7, 18, 10, 2, -18 },
  { 629, 11, 18, 14, 1, -18 },
  { 654, 10, 18, 13, 2, -18 },
  { 677, 5, 18, 7, 1, -18 },
  { 689, 5, 23, 6, -1, -18 },
  { 704, 9, 18, 11, 2, -18 },
  { 725, 7, 18, 9, 2, -18 },
  { 741, 14, 18, 18, 2, -18 },
  { 773, 10, 18, 14, 2, -18 },
  { 796, 12, 18, 14, 1, -18 },
  { 823, 8, 18, 11, 2, -18 },
  { 841, 12, 22, 14, 1, -18 },
  { 874, 9, 18, 12, 2, -18 },
  { 895, 8, 18, 10, 1, -18 },
  { 913, 9, 18, 10, 0, -18 },
  { 934, 9, 18, 13, 2, -18 },
  { 955, 11, 18, 11, 0, -18 },
  { 980, 18, 18, 18, 0, -18 },
  { 1021, 10, 18, 10, 0, -18 },
  { 1044, 10, 18, 10, 0, -18 },
  { 1067, 8, 18, 9, 1, -18 },
  { 1085, 5, 22, 8, 2, -18 },
  { 1099, 9, 18, 9, 0, -18 },
  { 1120, 5, 22, 8, 1, -18 },
  { 1134, 11, 10, 11, 0, -18 },
  { 1148, 11, 2, 11, 0, 2 },
  { 1151, 5, 4, 7, 1, -19 },
  { 1154, 8, 14, 10, 1, -14 },
  { 1168, 9, 19, 12, 2, -19 },
  { 1190, 7, 14, 9, 1, -14 },
  { 1203, 9, 19, 12, 1, -19 },
  { 1225, 8, 14, 10, 1, -14 },
  { 1239, 7, 19, 6, 0, -19 },
  { 1256, 9, 20, 12, 1, -14 },
  { 1279, 8, 19, 11, 2, -19 },
  { 1298, 3, 18, 5, 1, -18 },
  { 1305, 4, 24, 5, 0, -18 },
  { 1317, 8, 19, 10, 2, -19 },
  { 1336, 2, 19, 5, 2, -19 },
  { 1341, 13, 14, 17, 2, -14 },
  { 1364, 8, 14, 11, 2, -14 },
  { 1378, 9, 14, 11, 1, -14 },
  { 1394, 9, 20, 12, 2, -14 },
  { 1417, 9, 20, 12, 1, -14 },
  { 1440, 5, 14, 8, 2, -14 },
  { 1449, 7, 14, 8, 1, -14 },
  { 1462, 6, 16, 6, 0, -16 },
  { 1474, 8, 13, 11, 2, -13 },
  { 1487, 9, 13, 9, 0, -13 },
  { 1502, 15, 13, 15, 0, -13 },
  { 1527, 9, 13, 9, 0, -13 },
  { 1542, 9, 19, 9, 0, -13 },
  { 1564, 6, 13, 8, 1, -13 },
  { 1574, 7, 22, 9, 1, -18 },
  { 1594, 2, 25, 10, 4, -19 },
  { 1601, 7, 22, 9, 1, -18 },
  { 1621, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Regular25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR25PT7B_H_
