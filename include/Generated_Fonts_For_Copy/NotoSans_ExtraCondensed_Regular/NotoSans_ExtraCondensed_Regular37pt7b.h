#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x60, 0x00,
  0x7F, 0xF7, 0xF3, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xD8, 0x76, 0x19, 0x86,
  0x61, 0x80, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x31, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x0C, 0x3F, 0xFF, 0x7F, 0xFE, 0x18, 0x60, 0x30, 0xC0, 0x63,
  0x81, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0C, 0x30, 0xFF, 0xFF, 0xFF, 0xFC,
  0x61, 0x80, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x30, 0x18, 0x60, 0x30,
  0xC0, 0x61, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0xC3, 0xFF, 0x9F,
  0xFD, 0xCC, 0x4C, 0x60, 0xE3, 0x07, 0x18, 0x18, 0xC0, 0xE6, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x19, 0xC0, 0xC6, 0x06, 0x30,
  0x31, 0x81, 0x9D, 0x0C, 0xEF, 0x7E, 0x7F, 0xE1, 0xFE, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xF8, 0x0E, 0x07, 0xF0, 0x30,
  0x1C, 0xC0, 0xC0, 0x63, 0x87, 0x01, 0x8E, 0x18, 0x06, 0x18, 0x60, 0x38,
  0x63, 0x80, 0xE1, 0x8C, 0x01, 0x86, 0x30, 0x06, 0x39, 0xC0, 0x18, 0xE6,
  0x3C, 0x63, 0xB9, 0xF9, 0xCC, 0xEE, 0x63, 0xF3, 0x31, 0xCF, 0x9C, 0xC7,
  0x1C, 0x73, 0x1C, 0x01, 0x8C, 0x30, 0x0E, 0x70, 0xC0, 0x31, 0xC3, 0x00,
  0xC3, 0x0C, 0x07, 0x0C, 0x70, 0x18, 0x31, 0xC0, 0x60, 0xC7, 0x03, 0x83,
  0x98, 0x0C, 0x07, 0xE0, 0x70, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x0E, 0x60, 0x07, 0x70, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xFE, 0x1C, 0xF7, 0x0E, 0x71, 0xCE, 0x78, 0xE7, 0x38, 0x3B, 0x9C,
  0x1F, 0xCE, 0x07, 0xC7, 0x01, 0xE3, 0x80, 0xF1, 0xE0, 0xF8, 0x7D, 0xEE,
  0x1F, 0xE7, 0x87, 0xE1, 0xE0, 0xFF, 0xEE, 0xE6, 0x66, 0x60, 0x07, 0x0E,
  0x0C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0x70, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x04, 0x71, 0x7E, 0xFF,
  0xFF, 0x0F, 0x80, 0xF8, 0x1D, 0x83, 0x9C, 0x38, 0xE1, 0x0C, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x39, 0xCE, 0xF7, 0x39, 0xCC, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xF8, 0x3F, 0xC7, 0x9E, 0x70, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xE7, 0x0E, 0x7F, 0xC3,
  0xFC, 0x1F, 0x80, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xBF, 0x9D, 0x8E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x0F, 0x01, 0xFE,
  0x3F, 0xF8, 0xE1, 0xE2, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x01, 0xFF, 0x3F, 0xF8, 0xE1, 0xE4,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x03,
  0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0E, 0xF3, 0xF7, 0xFF, 0x1F,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0D, 0xC0,
  0x77, 0x01, 0x9C, 0x0E, 0x70, 0x31, 0xC0, 0xC7, 0x07, 0x1C, 0x18, 0x70,
  0xE1, 0xC3, 0x07, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCC, 0x07, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x8F, 0xFC, 0x77, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x81, 0xEE,
  0x3E, 0xFF, 0xCF, 0xF0, 0x03, 0xE0, 0xFE, 0x1F, 0xE3, 0xC0, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0x0E, 0xFC, 0xFF, 0xEF,
  0x8E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x77, 0x0F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF,
  0x1E, 0x1C, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x38, 0xE1,
  0xC3, 0x8F, 0x07, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xFE, 0x0F, 0x3C, 0x78,
  0x79, 0xC0, 0xEF, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x03, 0x9C,
  0x0E, 0x7C, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x07, 0x80, 0xFE, 0x0F, 0xF8,
  0xF1, 0xE7, 0x07, 0x38, 0x39, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xFC,
  0x0E, 0xE0, 0x77, 0x07, 0xBC, 0x3D, 0xF7, 0xE7, 0xF7, 0x1F, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x27, 0xC1,
  0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF7, 0x3B, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39,
  0xCE, 0xF7, 0x39, 0xCC, 0xE0, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x0E, 0x1F, 0xF1, 0xFF, 0x30,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x0E,
  0x30, 0x00, 0xE7, 0x00, 0x06, 0x70, 0xFE, 0x76, 0x1F, 0xC3, 0xE3, 0x8C,
  0x3E, 0x38, 0xC3, 0xC3, 0x0C, 0x3C, 0x30, 0xC3, 0xC7, 0x0C, 0x3C, 0x70,
  0xC3, 0xC7, 0x1C, 0x3C, 0x71, 0xC3, 0xC3, 0x1C, 0x7C, 0x31, 0x47, 0xE3,
  0xF6, 0xEE, 0x1F, 0x7E, 0xE0, 0xE3, 0x87, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x60, 0x0F, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x76, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0x87, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x70, 0x3F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFF, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x79, 0xC0,
  0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xC0, 0xFF, 0xC7, 0xFF, 0x38,
  0x7D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x03,
  0xB8, 0x39, 0xFF, 0x8F, 0xFC, 0x7F, 0xFB, 0x81, 0xDC, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xDF, 0xFE, 0xFF,
  0xE7, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0x86, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xFF, 0x8E, 0x3F, 0x38, 0x3C, 0xE0, 0x7B,
  0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x07, 0xFE, 0x0F,
  0xFF, 0x1E, 0x06, 0x3C, 0x02, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70,
  0x07, 0x78, 0x07, 0x38, 0x07, 0x3C, 0x07, 0x1F, 0xBF, 0x0F, 0xFF, 0x07,
  0xFE, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0xFF,
  0x7F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0xFE, 0xFC, 0xF8, 0xE0, 0x7B,
  0x81, 0xCE, 0x0F, 0x38, 0x38, 0xE1, 0xE3, 0x87, 0x0E, 0x3C, 0x38, 0xE0,
  0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0x70,
  0x39, 0xE0, 0xE3, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83,
  0xCE, 0x07, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFD, 0xC0, 0x1F, 0xFE, 0x00, 0xDF, 0xF0, 0x06, 0xFD,
  0x80, 0x77, 0xEE, 0x03, 0xBF, 0x70, 0x19, 0xFB, 0x81, 0xCF, 0xCE, 0x0E,
  0x7E, 0x70, 0x63, 0xF3, 0x83, 0x1F, 0x8C, 0x38, 0xFC, 0x71, 0xC7, 0xE3,
  0x8C, 0x3F, 0x1C, 0xE1, 0xF8, 0x67, 0x0F, 0xC3, 0xB8, 0x7E, 0x1D, 0x83,
  0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x03,
  0x81, 0xC0, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7D, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xF7, 0x07, 0xEE, 0x0F, 0xCE, 0x1F, 0x9C, 0x3F, 0x1C,
  0x7E, 0x38, 0xFC, 0x71, 0xF8, 0x73, 0xF0, 0xE7, 0xE0, 0xEF, 0xC1, 0xDF,
  0x83, 0xFF, 0x03, 0xBE, 0x07, 0x7C, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3C, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0x87, 0x87,
  0x81, 0xE3, 0x80, 0x71, 0xC0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDE, 0x00, 0xE7, 0x00, 0xF3,
  0x80, 0x71, 0xE0, 0x38, 0x78, 0x3C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0x8F, 0xFC, 0xE3, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F,
  0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x07, 0x87,
  0x87, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0x70,
  0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDE, 0x00, 0xE7, 0x00,
  0xF3, 0x80, 0x71, 0xE0, 0x38, 0x78, 0x3C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01,
  0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0xFF, 0x83, 0xFF, 0x0E, 0x3E, 0x38, 0x3C, 0xE0, 0x73,
  0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x78,
  0xFF, 0xE3, 0xFE, 0x0F, 0xF0, 0x38, 0xE0, 0xE3, 0x83, 0x87, 0x0E, 0x1C,
  0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x7B, 0x80,
  0xF0, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xF8, 0x67, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xD0, 0x1E, 0xFF, 0xF7, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xEE, 0x03,
  0x9E, 0x0F, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0xE0, 0x07, 0xF0, 0x07,
  0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x0E, 0x38, 0x1E, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x70, 0x07, 0x70,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0xE0, 0x0E, 0x01, 0xDC, 0x07, 0x80, 0x77, 0x01, 0xE0, 0x1D, 0xC0, 0x7C,
  0x07, 0x70, 0x1F, 0x03, 0x9C, 0x06, 0xC0, 0xE3, 0x83, 0xB0, 0x38, 0xE0,
  0xEC, 0x0E, 0x38, 0x3B, 0x83, 0x8E, 0x0E, 0xE1, 0xC3, 0x83, 0x38, 0x70,
  0x71, 0xCE, 0x1C, 0x1C, 0x71, 0x87, 0x07, 0x1C, 0x71, 0xC1, 0xC7, 0x1C,
  0xE0, 0x71, 0x87, 0x38, 0x0E, 0xE1, 0xCE, 0x03, 0xB8, 0x33, 0x80, 0xEE,
  0x0C, 0xE0, 0x3B, 0x83, 0xF0, 0x0E, 0xC0, 0xFC, 0x01, 0xB0, 0x3F, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xE0, 0x1E,
  0x00, 0x70, 0x1C, 0x70, 0x78, 0xE0, 0xE1, 0xE1, 0xC1, 0xC7, 0x03, 0x8E,
  0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x71,
  0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x07, 0x0E, 0x0E, 0x38, 0x1E, 0x70, 0x1D,
  0xE0, 0x3C, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0xE3, 0xC1, 0xC3, 0x83, 0x87,
  0x0E, 0x0F, 0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xFE, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xEC, 0x03, 0x9C,
  0x07, 0x18, 0x0C, 0x38, 0x38, 0x30, 0x60, 0x71, 0xC0, 0xE3, 0x00, 0xEE,
  0x01, 0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0xF0, 0xE0,
  0xE0, 0xC0, 0x1F, 0xC3, 0xFE, 0x38, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x0F, 0xF3, 0xFF, 0x7C, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0xF7, 0x1F, 0x7F, 0x33, 0xE3, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE7, 0xC3,
  0xBF, 0x8E, 0xFF, 0x3E, 0x1E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0xC0, 0xEF, 0x03,
  0xBC, 0x0E, 0xF8, 0x7B, 0xF3, 0xCE, 0xFF, 0x39, 0xF8, 0x1F, 0xCF, 0xF7,
  0xD9, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x33, 0xFC, 0x7F, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x1F,
  0x39, 0xFD, 0xDF, 0xFE, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xF0, 0x7B, 0xCF, 0xDF, 0xEE, 0x3E, 0x70, 0x1F, 0x83, 0xFC, 0x79,
  0xE7, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x17, 0xC6, 0x3F,
  0xE1, 0xFC, 0x07, 0xC3, 0xF1, 0xE4, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x3F, 0xBF, 0xEF, 0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1F, 0x39, 0xFD, 0xDF, 0xFE, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xF0, 0x7B, 0xCF, 0xCF, 0xEE, 0x7E, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x72, 0x07, 0x9F, 0xF8, 0xFF, 0x83, 0xF0,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE7, 0xC7, 0x7F, 0x3B, 0xFD, 0xF0, 0xEF, 0x07, 0x78, 0x3F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xEF,
  0xF6, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xE0, 0x38, 0xF3, 0xC6, 0x00, 0x00, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x3B, 0xEF, 0x38, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC3, 0x8E,
  0x3C, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xEF, 0x07, 0x78, 0x3E, 0xE1, 0xE7,
  0x0F, 0x38, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0xE7, 0x07, 0xB8, 0x1D,
  0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE7, 0xC3, 0xE7, 0x7F, 0x3F, 0xBF, 0x7B, 0xBD, 0xF0, 0xF0, 0xFF,
  0x07, 0x83, 0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70,
  0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0,
  0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81,
  0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x70, 0xE7, 0xC7, 0x7F, 0x3F, 0xFD, 0xF0,
  0xEF, 0x07, 0x78, 0x3F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x70, 0x1F, 0x81, 0xFE, 0x1F, 0x78, 0xE1, 0xEE, 0x07, 0x70,
  0x3B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xDC, 0x0E, 0x70, 0x73, 0xCF, 0x0F, 0xF8, 0x3F, 0x00,
  0xE7, 0xC3, 0xBF, 0xCE, 0xCF, 0x3E, 0x1E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03,
  0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0xC0,
  0xEF, 0x03, 0xBC, 0x0E, 0xF8, 0x7B, 0xF3, 0xCE, 0xFF, 0x39, 0xF8, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFE, 0xE1, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0xFB, 0xCF, 0xCF, 0xEE, 0x7E, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0xE7, 0xF7, 0xFB, 0xFF, 0x0F, 0x87, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x00, 0x1F, 0x9F, 0xF7, 0x9F, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xFC,
  0xFF, 0xF9, 0xFC, 0x30, 0x30, 0x30, 0x30, 0x7F, 0xFF, 0xFF, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38,
  0x39, 0x3F, 0x1F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0x70, 0xF7, 0x9B, 0x3F, 0xB3, 0xF3, 0xE0, 0x3F, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x60, 0xE3, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x37, 0x00, 0xDC, 0x03,
  0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x78, 0x1D, 0xC1,
  0xE0, 0x77, 0x07, 0x81, 0xDC, 0x1F, 0x0E, 0x70, 0x7C, 0x39, 0xC3, 0xB0,
  0xE3, 0x8E, 0xC3, 0x8E, 0x3B, 0x0C, 0x38, 0xCE, 0x70, 0xE3, 0x39, 0xC1,
  0x9C, 0xE7, 0x07, 0x71, 0x9C, 0x1D, 0xC6, 0x60, 0x76, 0x1B, 0x81, 0xD8,
  0x7E, 0x03, 0x61, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0xE0, 0x7F, 0x0F, 0x70, 0xE7, 0x0E, 0x39, 0xC3, 0x9C,
  0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xB8,
  0x39, 0xC3, 0x9C, 0x70, 0xE7, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x3D, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x37, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x41, 0xF0, 0xFC, 0x3C, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC3, 0xE0, 0xE0, 0x3E, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0xFC, 0x1F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x3C, 0x0F, 0x80, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xE0, 0x3E, 0x03, 0xC1, 0xF0, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x0F, 0x83, 0xE0, 0xE0,
  0x00, 0x7E, 0x07, 0xFE, 0x7C, 0x7F, 0xE0, 0x7E,
};

const GFXglyph NotoSans_ExtraCondensed_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 26, 9, 2, -26 },
  { 14, 10, 9, 14, 2, -26 },
  { 26, 15, 26, 17, 1, -26 },
  { 75, 13, 30, 16, 1, -28 },
  { 124, 22, 27, 25, 1, -27 },
  { 199, 17, 27, 18, 1, -27 },
  { 257, 4, 9, 8, 2, -26 },
  { 262, 8, 33, 11, 2, -27 },
  { 295, 8, 33, 11, 1, -27 },
  { 328, 12, 12, 15, 1, -28 },
  { 346, 14, 18, 16, 1, -22 },
  { 378, 5, 9, 8, 1, -4 },
  { 384, 8, 3, 10, 1, -11 },
  { 387, 4, 4, 8, 2, -4 },
  { 389, 12, 27, 14, 1, -27 },
  { 430, 12, 27, 16, 2, -27 },
  { 471, 9, 26, 16, 2, -26 },
  { 501, 13, 27, 16, 1, -27 },
  { 545, 13, 27, 16, 1, -27 },
  { 589, 14, 27, 16, 1, -27 },
  { 637, 12, 26, 16, 2, -26 },
  { 676, 12, 27, 16, 2, -27 },
  { 717, 14, 26, 16, 1, -26 },
  { 763, 14, 27, 16, 1, -27 },
  { 811, 13, 27, 16, 1, -27 },
  { 855, 4, 20, 8, 2, -20 },
  { 865, 5, 25, 8, 1, -20 },
  { 881, 14, 16, 16, 1, -21 },
  { 909, 14, 10, 16, 1, -18 },
  { 927, 14, 16, 16, 1, -21 },
  { 955, 11, 27, 12, 0, -27 },
  { 993, 20, 30, 24, 2, -27 },
  { 1068, 17, 26, 17, 0, -26 },
  { 1124, 13, 26, 18, 3, -26 },
  { 1167, 14, 27, 17, 2, -27 },
  { 1215, 14, 26, 19, 3, -26 },
  { 1261, 10, 26, 15, 3, -26 },
  { 1294, 10, 26, 14, 3, -26 },
  { 1327, 16, 27, 20, 2, -27 },
  { 1381, 14, 26, 20, 3, -26 },
  { 1427, 8, 26, 10, 1, -26 },
  { 1453, 8, 33, 8, -2, -26 },
  { 1486, 14, 26, 17, 3, -26 },
  { 1532, 10, 26, 14, 3, -26 },
  { 1565, 21, 26, 27, 3, -26 },
  { 1634, 15, 26, 21, 3, -26 },
  { 1683, 17, 27, 20, 2, -27 },
  { 1741, 12, 26, 16, 3, -26 },
  { 1780, 17, 33, 20, 2, -27 },
  { 1851, 14, 26, 17, 3, -26 },
  { 1897, 13, 27, 15, 1, -27 },
  { 1941, 14, 26, 14, 0, -26 },
  { 1987, 15, 26, 19, 2, -26 },
  { 2036, 16, 26, 16, 0, -26 },
  { 2088, 26, 26, 27, 0, -26 },
  { 2173, 15, 26, 15, 0, -26 },
  { 2222, 15, 26, 15, 0, -26 },
  { 2271, 12, 26, 13, 1, -26 },
  { 2310, 7, 33, 12, 3, -27 },
  { 2339, 12, 27, 14, 1, -27 },
  { 2380, 8, 33, 12, 1, -27 },
  { 2413, 15, 14, 16, 1, -26 },
  { 2440, 16, 2, 16, 0, 3 },
  { 2444, 7, 6, 10, 1, -28 },
  { 2450, 12, 20, 15, 1, -20 },
  { 2480, 14, 28, 17, 2, -28 },
  { 2529, 10, 20, 13, 2, -20 },
  { 2554, 13, 28, 17, 2, -28 },
  { 2600, 12, 20, 15, 2, -20 },
  { 2630, 10, 28, 9, 0, -28 },
  { 2665, 13, 29, 17, 2, -20 },
  { 2713, 13, 28, 17, 2, -28 },
  { 2759, 4, 27, 8, 2, -27 },
  { 2773, 6, 36, 8, 0, -27 },
  { 2800, 13, 28, 15, 2, -28 },
  { 2846, 3, 28, 8, 2, -28 },
  { 2857, 21, 20, 25, 2, -20 },
  { 2910, 13, 20, 17, 2, -20 },
  { 2943, 13, 20, 16, 2, -20 },
  { 2976, 14, 29, 17, 2, -20 },
  { 3027, 13, 29, 17, 2, -20 },
  { 3075, 9, 20, 11, 2, -20 },
  { 3098, 10, 20, 13, 1, -20 },
  { 3123, 8, 24, 10, 1, -24 },
  { 3147, 12, 20, 17, 2, -20 },
  { 3177, 14, 20, 14, 0, -20 },
  { 3212, 22, 20, 22, 0, -20 },
  { 3267, 12, 20, 14, 1, -20 },
  { 3297, 14, 29, 14, 0, -20 },
  { 3348, 9, 20, 11, 1, -20 },
  { 3371, 10, 33, 13, 2, -27 },
  { 3413, 3, 37, 15, 6, -28 },
  { 3427, 10, 33, 13, 2, -27 },
  { 3469, 14, 4, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Regular37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR37PT7B_H_
