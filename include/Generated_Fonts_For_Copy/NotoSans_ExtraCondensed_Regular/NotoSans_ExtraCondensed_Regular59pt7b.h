#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xF9, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFD, 0xE3, 0x00, 0xFC, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0F,
  0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFB, 0x8F, 0x1F, 0x1C, 0x08, 0xF0, 0xE0, 0x07,
  0x87, 0x00, 0x7C, 0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x0E, 0x00, 0xF8, 0x70,
  0x03, 0xC3, 0x80, 0x1F, 0x1C, 0x00, 0xFC, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xE7, 0xE0, 0x07, 0x1F, 0x00, 0x38, 0x7C, 0x01,
  0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x3F,
  0x00, 0xE1, 0xEE, 0x07, 0x1F, 0x7E, 0x3B, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x0F, 0x00, 0x1F,
  0xF8, 0x01, 0xE0, 0x03, 0xCF, 0x80, 0x3C, 0x00, 0xF0, 0xF0, 0x0F, 0x00,
  0x1E, 0x1E, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x0F,
  0x00, 0x0E, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x78, 0x1E,
  0x0F, 0x00, 0x0F, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x38, 0x00, 0x3C,
  0x0F, 0x0F, 0x00, 0x07, 0x81, 0xE1, 0xE0, 0x00, 0xF0, 0x3C, 0x78, 0x00,
  0x0E, 0x07, 0x8F, 0x07, 0x81, 0xE0, 0xF1, 0xE3, 0xFC, 0x3C, 0x1E, 0x78,
  0xFF, 0x87, 0x87, 0x8F, 0x1F, 0xF8, 0xF0, 0xF1, 0xE7, 0x8F, 0x8F, 0x1E,
  0x78, 0xF0, 0xF1, 0xFF, 0x8F, 0x1E, 0x1E, 0x1F, 0xF1, 0xE3, 0x83, 0xC1,
  0xFC, 0x78, 0xF0, 0x3C, 0x0E, 0x0F, 0x1E, 0x07, 0x80, 0x01, 0xE3, 0xC0,
  0xF0, 0x00, 0x78, 0x78, 0x1E, 0x00, 0x0F, 0x0F, 0x03, 0xC0, 0x01, 0xC1,
  0xE0, 0x78, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x81, 0xE0, 0x01,
  0xC0, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0x38, 0x3C, 0x00, 0x78, 0x07, 0x87, 0x80, 0x0F, 0x00, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x0F, 0x00,
  0x1F, 0xE0, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0x9F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x7C,
  0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7D, 0xF0, 0x3E, 0x3E, 0x7C, 0x0F, 0x1F, 0x8F, 0x87, 0xC7,
  0xC3, 0xF1, 0xF3, 0xE0, 0x7C, 0x7C, 0xF8, 0x0F, 0x9F, 0x3E, 0x03, 0xE7,
  0x8F, 0x80, 0x7F, 0xE3, 0xE0, 0x1F, 0xF8, 0xF8, 0x03, 0xFC, 0x3E, 0x00,
  0x7F, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xFC, 0x3F,
  0x01, 0xFF, 0x87, 0xE0, 0xFF, 0xE1, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0x1F,
  0x87, 0xFF, 0x83, 0xE0, 0xFF, 0xC0, 0xFC, 0x03, 0x00, 0x00, 0xFD, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x38,
  0x3B, 0xF7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xE7, 0x80, 0x78, 0xF8, 0x1F, 0x0F,
  0x87, 0xC1, 0xF0, 0x38, 0x18, 0x01, 0x02, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x1F,
  0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xF9, 0xFF, 0xF7,
  0xEF, 0xDF, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x03, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFD, 0xEF, 0xCF, 0xFC, 0x7F, 0xC3,
  0xDC, 0x3E, 0x41, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3E, 0x07, 0xF0, 0xC0, 0x1F, 0x84,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0x80,
  0x7E, 0x30, 0x03, 0xE2, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0xF0, 0x0F, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x07, 0x9F, 0x00, 0x0F,
  0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xE1, 0xF0, 0x03, 0xC3,
  0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xE0,
  0x78, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xFB, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x78, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x80, 0x0F, 0xCE, 0x01, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x30, 0x0F, 0x9F, 0xE0, 0xF3, 0xFF,
  0x0F, 0x7F, 0xF8, 0xF7, 0xFF, 0xCF, 0xE0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7E,
  0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0x81, 0xF8, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C,
  0x1F, 0x07, 0xE0, 0xFC, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x8F, 0xC1,
  0xF8, 0x3F, 0x1F, 0x80, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF8, 0x0F,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xF0, 0x7C, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x07, 0xF3,
  0xFF, 0xEF, 0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x07, 0xF9, 0xF0, 0x04, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x70, 0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xFF, 0x9C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xBF, 0xFF, 0xFF, 0xFE, 0x20, 0x1C, 0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0x81, 0xF9, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x1F, 0x81, 0xE1, 0xE0, 0x3F,
  0xF0, 0x79, 0xE0, 0x3F, 0xF8, 0x3C, 0xF0, 0x3E, 0x3C, 0x1E, 0x78, 0x3E,
  0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x03, 0xBC, 0x0F, 0x07, 0x81, 0xFE, 0x0F,
  0x03, 0xC0, 0xFF, 0x07, 0x81, 0xE0, 0x7F, 0x83, 0xC0, 0xF0, 0x3F, 0xC1,
  0xE0, 0x78, 0x1F, 0xE0, 0xF0, 0x3C, 0x0F, 0xF0, 0x78, 0x1E, 0x07, 0xF8,
  0x3C, 0x0F, 0x03, 0xFC, 0x1E, 0x0F, 0x81, 0xDE, 0x0F, 0x07, 0xC1, 0xEF,
  0x07, 0x83, 0xE0, 0xF7, 0x83, 0xC1, 0xF0, 0x7B, 0xC1, 0xE0, 0xF8, 0x3D,
  0xE0, 0x78, 0xFC, 0x3C, 0xF0, 0x3E, 0xF7, 0x3E, 0x7C, 0x1F, 0xF3, 0xFE,
  0x1E, 0x07, 0xF9, 0xFE, 0x0F, 0x01, 0xF8, 0x7E, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x40, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFC, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x0F, 0xF3, 0xE0, 0x0F,
  0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x3F, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0x80, 0xFF, 0x3E,
  0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8,
  0x03, 0xF3, 0xE0, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x80, 0xE1, 0xFC, 0x00, 0x87,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x03, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x01, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xF8, 0x3F, 0xE0, 0xF8, 0x07, 0xF0, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x7F, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x03, 0xC0, 0xFC, 0x00, 0x10, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC3,
  0xF0, 0x01, 0xF0, 0xFF, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x87, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFF, 0x00, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07,
  0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x3E,
  0x00, 0xFE, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xFD, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xEF, 0xFF, 0xC0, 0x00,
  0x7B, 0xFE, 0xF0, 0x00, 0x3F, 0xFF, 0xBC, 0x00, 0x0F, 0x7F, 0xEF, 0x80,
  0x03, 0xDF, 0xF9, 0xE0, 0x01, 0xF7, 0xFE, 0x78, 0x00, 0x79, 0xFF, 0x9E,
  0x00, 0x1E, 0x7F, 0xE7, 0xC0, 0x07, 0x9F, 0xF8, 0xF0, 0x03, 0xE7, 0xFE,
  0x3C, 0x00, 0xF1, 0xFF, 0x8F, 0x80, 0x3C, 0x7F, 0xE1, 0xE0, 0x1F, 0x1F,
  0xF8, 0x78, 0x07, 0x87, 0xFE, 0x1E, 0x01, 0xE1, 0xFF, 0x87, 0xC0, 0x78,
  0x7F, 0xE0, 0xF0, 0x3E, 0x1F, 0xF8, 0x3C, 0x0F, 0x07, 0xFE, 0x0F, 0x83,
  0xC1, 0xFF, 0x81, 0xE1, 0xF0, 0x7F, 0xE0, 0x78, 0x78, 0x1F, 0xF8, 0x1E,
  0x1E, 0x07, 0xFE, 0x07, 0xC7, 0x81, 0xFF, 0x80, 0xF3, 0xE0, 0x7F, 0xE0,
  0x3C, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0xFE, 0x01, 0xEF, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x07,
  0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFD, 0xE0, 0x03, 0xFE, 0xF8, 0x01, 0xFF, 0x3C, 0x00, 0xFF,
  0x9F, 0x00, 0x7F, 0xCF, 0x80, 0x3F, 0xE3, 0xE0, 0x1F, 0xF1, 0xF0, 0x0F,
  0xF8, 0x78, 0x07, 0xFC, 0x3E, 0x03, 0xFE, 0x1F, 0x01, 0xFF, 0x07, 0xC0,
  0xFF, 0x83, 0xE0, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0, 0x7C, 0x1F, 0xF0, 0x1E,
  0x0F, 0xF8, 0x0F, 0x87, 0xFC, 0x07, 0xC3, 0xFE, 0x01, 0xF1, 0xFF, 0x00,
  0xF8, 0xFF, 0x80, 0x3E, 0x7F, 0xC0, 0x1F, 0x3F, 0xE0, 0x0F, 0x9F, 0xF0,
  0x03, 0xEF, 0xF8, 0x01, 0xF7, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00,
  0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x81,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xF8, 0x3F, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x7F,
  0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x7E, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0x1E, 0x7E, 0x00,
  0x47, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xEC, 0x00, 0x7E, 0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xF0,
  0x7F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0x9F,
  0x00, 0x0F, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xFE, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x8F, 0x80, 0x1E, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xBC, 0x01, 0xF0, 0x7C, 0x01, 0xEF, 0x00, 0x7C,
  0x1F, 0x00, 0xFB, 0xC0, 0x1F, 0x07, 0xC0, 0x3C, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x3C, 0x03, 0xE0, 0x7C, 0x03, 0xCF, 0x80, 0xF8, 0x0F, 0x80, 0xF1,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x78, 0x0F, 0x80, 0xF8, 0x1E, 0x1E, 0x07,
  0xC0, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0x07, 0x81, 0xE1, 0xF0, 0x7C, 0x01,
  0xF0, 0x78, 0x3C, 0x1F, 0x00, 0x7C, 0x3E, 0x0F, 0x07, 0xC0, 0x1F, 0x0F,
  0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x3E,
  0x3E, 0x00, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0x0F, 0x9F, 0x01, 0xE3, 0xE0,
  0x03, 0xE7, 0x80, 0x79, 0xF0, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x00, 0x1E,
  0x78, 0x07, 0xDF, 0x00, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x01, 0xE7, 0x80,
  0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x03, 0xDE,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x1E,
  0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0x9E, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7F,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x03, 0xE7, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x81,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC1, 0xC0, 0xFC, 0x20, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF,
  0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xE3, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xBE, 0x07, 0xF7, 0xF3, 0xDE,
  0x7F, 0xF3, 0xCF, 0xFC, 0x78, 0xFF, 0x0F, 0x03, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x7F, 0x03, 0xE7,
  0xFE, 0x1F, 0x7F, 0xF0, 0xF7, 0xFF, 0xC7, 0xF8, 0x3F, 0x3F, 0x80, 0xF9,
  0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E,
  0x00, 0xFB, 0xF0, 0x07, 0xDF, 0xC0, 0x7C, 0xFF, 0x07, 0xE7, 0xBF, 0xFE,
  0x3C, 0xFF, 0xF1, 0xE3, 0xFF, 0x0F, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x03,
  0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0x06, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x81, 0xFC, 0x3C, 0x1F, 0xF1, 0xE1, 0xFF, 0xCF, 0x1F,
  0xFF, 0x78, 0xFC, 0x3F, 0xCF, 0xC0, 0xFE, 0x7C, 0x03, 0xF7, 0xE0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x07, 0xE7,
  0xC0, 0x3F, 0x3F, 0x03, 0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0xDE, 0x1F, 0xFC,
  0xF0, 0x3F, 0xC3, 0x80, 0x30, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xC0,
  0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0x1F, 0x80,
  0x63, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x78,
  0x00, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFC, 0x41, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x03, 0xF8, 0x78, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE,
  0xF1, 0xF8, 0x7F, 0x9F, 0x81, 0xFC, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07,
  0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80,
  0x7E, 0x7E, 0x07, 0xF1, 0xFF, 0xF7, 0x87, 0xFF, 0xBC, 0x3F, 0xF9, 0xE0,
  0x7F, 0x0F, 0x00, 0x40, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x30,
  0x03, 0xF1, 0xE0, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0xFC,
  0x3E, 0x7F, 0xC7, 0xDF, 0xFC, 0xF7, 0xFF, 0xDE, 0xE1, 0xFB, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3E, 0x11, 0xE7, 0xFF, 0x7D, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x01,
  0x01, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0xA3, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFE, 0x01, 0xF7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x7C, 0x03, 0xCF, 0xC0, 0x7B, 0xF8, 0x0F, 0x7F, 0x01, 0xFF, 0xF0, 0x3F,
  0xBE, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xFE, 0x03, 0xF8, 0x78, 0xFF, 0x87, 0xFE,
  0x3C, 0xFF, 0xE7, 0xFF, 0x9E, 0xFF, 0xF3, 0xFF, 0xCF, 0x70, 0xFF, 0xC3,
  0xF7, 0xF0, 0x3F, 0x80, 0xFB, 0xF0, 0x1F, 0xC0, 0x7D, 0xF0, 0x0F, 0xC0,
  0x3E, 0xF8, 0x03, 0xE0, 0x0F, 0x7C, 0x01, 0xF0, 0x07, 0xBE, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03,
  0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0,
  0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC,
  0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F,
  0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0xFE, 0x1E, 0x3F, 0xE3, 0xCF, 0xFE, 0x7B,
  0xFF, 0xEF, 0x70, 0xFD, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x07, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x30, 0x00, 0xF0, 0xFE, 0x07, 0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEF,
  0xFF, 0x8F, 0x70, 0x7E, 0x7F, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF,
  0x80, 0xF9, 0xFE, 0x0F, 0xCF, 0x7F, 0xFC, 0x7D, 0xFF, 0xE3, 0xE7, 0xFE,
  0x1F, 0x1F, 0xE0, 0xF8, 0x30, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E,
  0x3F, 0xFE, 0xF1, 0xF8, 0x7F, 0x9F, 0x81, 0xFC, 0xF8, 0x07, 0xEF, 0xC0,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x0F,
  0xCF, 0x80, 0x7E, 0x7E, 0x07, 0xF1, 0xFF, 0xF7, 0x87, 0xFF, 0x3C, 0x3F,
  0xF9, 0xE0, 0x7F, 0x0F, 0x00, 0x40, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xE7, 0xFF,
  0x7F, 0xFB, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xF8, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7C, 0x0E, 0xF8, 0x02, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x03, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x1C, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xBE, 0x0F, 0xF7, 0xFF, 0xDE, 0x7F, 0xF3, 0xCF, 0xFE, 0x78, 0xFF, 0x0F,
  0x01, 0x00, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xFE,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1E,
  0xF8, 0x07, 0xF0, 0x07, 0x9E, 0x01, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x80,
  0xF9, 0xF0, 0x1F, 0xE0, 0x3E, 0x7C, 0x07, 0x78, 0x0F, 0x1F, 0x03, 0xDE,
  0x03, 0xC3, 0xC0, 0xF3, 0xC1, 0xF0, 0xF8, 0x3C, 0xF0, 0x7C, 0x3E, 0x0F,
  0x3C, 0x1E, 0x0F, 0x87, 0xCF, 0x07, 0x81, 0xE1, 0xE3, 0xC1, 0xE0, 0x78,
  0x78, 0x78, 0xF8, 0x1F, 0x1E, 0x1E, 0x3E, 0x07, 0xC7, 0x87, 0x8F, 0x01,
  0xF3, 0xE1, 0xE3, 0xC0, 0x3C, 0xF0, 0x78, 0xF0, 0x0F, 0x3C, 0x1F, 0x7C,
  0x03, 0xCF, 0x03, 0xDF, 0x00, 0xFB, 0xC0, 0xF7, 0x80, 0x3E, 0xF0, 0x3D,
  0xE0, 0x07, 0xB8, 0x0F, 0x78, 0x01, 0xFE, 0x03, 0xDE, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x07, 0xDE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF0, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x02,
  0x1F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x04, 0xFF, 0x00, 0x17,
  0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE8, 0x01,
  0xFF, 0x20, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 43, 14, 4, -42 },
  { 34, 16, 15, 22, 3, -42 },
  { 64, 25, 42, 27, 1, -42 },
  { 196, 21, 48, 25, 2, -45 },
  { 322, 35, 44, 39, 2, -43 },
  { 515, 26, 44, 28, 2, -43 },
  { 658, 6, 15, 12, 3, -42 },
  { 670, 12, 51, 17, 3, -42 },
  { 747, 12, 51, 17, 2, -42 },
  { 824, 19, 20, 23, 2, -45 },
  { 872, 21, 28, 25, 2, -35 },
  { 946, 8, 15, 13, 2, -7 },
  { 961, 13, 4, 16, 2, -18 },
  { 968, 7, 8, 13, 3, -7 },
  { 975, 20, 42, 22, 1, -42 },
  { 1080, 21, 44, 25, 2, -43 },
  { 1196, 13, 42, 25, 4, -42 },
  { 1265, 21, 43, 25, 2, -43 },
  { 1378, 20, 44, 25, 2, -43 },
  { 1488, 23, 42, 25, 1, -42 },
  { 1609, 20, 43, 25, 3, -42 },
  { 1717, 20, 44, 25, 3, -43 },
  { 1827, 21, 42, 25, 2, -42 },
  { 1938, 21, 44, 25, 2, -43 },
  { 2054, 20, 44, 25, 2, -43 },
  { 2164, 6, 33, 13, 4, -32 },
  { 2189, 8, 40, 13, 2, -32 },
  { 2229, 22, 26, 25, 2, -34 },
  { 2301, 21, 17, 25, 2, -29 },
  { 2346, 22, 26, 25, 2, -34 },
  { 2418, 17, 44, 19, 1, -43 },
  { 2512, 33, 48, 38, 3, -43 },
  { 2710, 27, 42, 27, 0, -42 },
  { 2852, 22, 42, 28, 4, -42 },
  { 2968, 22, 44, 26, 3, -43 },
  { 3089, 24, 42, 30, 4, -42 },
  { 3215, 17, 42, 24, 4, -42 },
  { 3305, 17, 42, 22, 4, -42 },
  { 3395, 26, 44, 32, 3, -43 },
  { 3538, 23, 42, 31, 4, -42 },
  { 3659, 13, 42, 17, 2, -42 },
  { 3728, 12, 53, 13, -3, -42 },
  { 3808, 23, 42, 26, 4, -42 },
  { 3929, 17, 42, 22, 4, -42 },
  { 4019, 34, 42, 42, 4, -42 },
  { 4198, 25, 42, 34, 4, -42 },
  { 4330, 27, 44, 32, 3, -43 },
  { 4479, 20, 42, 26, 4, -42 },
  { 4584, 27, 53, 32, 3, -43 },
  { 4763, 22, 42, 27, 4, -42 },
  { 4879, 20, 44, 24, 2, -43 },
  { 4989, 21, 42, 22, 1, -42 },
  { 5100, 23, 43, 31, 4, -42 },
  { 5224, 26, 42, 26, 0, -42 },
  { 5361, 42, 42, 42, 0, -42 },
  { 5582, 23, 42, 24, 0, -42 },
  { 5703, 23, 42, 23, 0, -42 },
  { 5824, 18, 42, 21, 2, -42 },
  { 5919, 13, 52, 18, 4, -42 },
  { 6004, 20, 42, 22, 1, -42 },
  { 6109, 12, 52, 18, 2, -42 },
  { 6187, 24, 22, 26, 1, -42 },
  { 6253, 26, 4, 26, 0, 5 },
  { 6266, 11, 9, 16, 2, -45 },
  { 6279, 19, 33, 25, 2, -32 },
  { 6358, 21, 46, 27, 4, -45 },
  { 6479, 16, 33, 20, 3, -32 },
  { 6545, 21, 46, 27, 2, -45 },
  { 6666, 19, 33, 25, 3, -32 },
  { 6745, 15, 45, 15, 1, -45 },
  { 6830, 21, 46, 27, 2, -32 },
  { 6951, 19, 45, 27, 4, -45 },
  { 7058, 6, 44, 12, 3, -44 },
  { 7091, 10, 58, 12, -1, -44 },
  { 7164, 19, 45, 24, 4, -45 },
  { 7271, 5, 45, 12, 4, -45 },
  { 7300, 33, 32, 40, 4, -32 },
  { 7432, 19, 32, 27, 4, -32 },
  { 7508, 22, 33, 26, 2, -32 },
  { 7599, 21, 46, 27, 4, -32 },
  { 7720, 21, 46, 27, 2, -32 },
  { 7841, 13, 32, 18, 4, -32 },
  { 7893, 16, 33, 20, 2, -32 },
  { 7959, 13, 40, 15, 1, -39 },
  { 8024, 19, 33, 27, 4, -32 },
  { 8103, 22, 32, 22, 0, -32 },
  { 8191, 34, 32, 36, 1, -32 },
  { 8327, 20, 32, 22, 1, -32 },
  { 8407, 22, 46, 22, 0, -32 },
  { 8534, 16, 32, 18, 1, -32 },
  { 8598, 17, 52, 21, 2, -42 },
  { 8709, 4, 59, 24, 10, -45 },
  { 8739, 17, 52, 21, 2, -42 },
  { 8850, 22, 8, 25, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Regular59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR59PT7B_H_
