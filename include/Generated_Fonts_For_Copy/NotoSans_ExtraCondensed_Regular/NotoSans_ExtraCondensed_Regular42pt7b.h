#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xE6, 0x66, 0x66,
  0x00, 0x0E, 0xFF, 0xFF, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE0, 0x03, 0x06, 0x00,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0xC0, 0x1C, 0x30, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0x60, 0x0C, 0x18, 0x03,
  0x0E, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x0E, 0x01, 0xC3,
  0x00, 0x70, 0xC0, 0x18, 0x30, 0x06, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0,
  0x38, 0x70, 0x0E, 0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x1F, 0xF8, 0xFF, 0xF7, 0xFF, 0xBC, 0xC2, 0xE3, 0x03, 0x8C, 0x0E, 0x30,
  0x38, 0xC0, 0xE3, 0x03, 0xCC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0xDF, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0xC0, 0xC7, 0x03,
  0x1E, 0x0C, 0xFE, 0x37, 0xBF, 0xFC, 0xFF, 0xE0, 0x7E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xE0, 0x7F, 0x01, 0xC0, 0x77,
  0x01, 0xC0, 0xE3, 0x81, 0x80, 0xE3, 0x83, 0x80, 0xE3, 0x83, 0x80, 0xE1,
  0x87, 0x00, 0xE1, 0x87, 0x00, 0xE1, 0x87, 0x00, 0xE1, 0x8E, 0x00, 0xE1,
  0x8E, 0x00, 0xE1, 0x8E, 0x00, 0xE3, 0x9C, 0x7C, 0xE3, 0x9C, 0xFE, 0xE3,
  0x99, 0xCE, 0x77, 0x39, 0xC7, 0x7F, 0x39, 0xC7, 0x3E, 0x31, 0x87, 0x00,
  0x71, 0x87, 0x00, 0x73, 0x87, 0x00, 0x63, 0x87, 0x00, 0xE3, 0x87, 0x00,
  0xE3, 0x87, 0x00, 0xC1, 0x87, 0x01, 0xC1, 0x87, 0x01, 0xC1, 0xC7, 0x03,
  0x81, 0xC7, 0x03, 0x80, 0xEE, 0x03, 0x80, 0xFE, 0x07, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0x78,
  0x70, 0x0F, 0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x7B,
  0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x3D, 0xC3, 0xCF, 0x3C, 0x79, 0xC3, 0xCF, 0x38, 0x39, 0xCF, 0x07,
  0xB9, 0xE0, 0x7F, 0x3C, 0x0F, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x0E, 0x07,
  0xE1, 0xE1, 0xFE, 0x3F, 0xFD, 0xC3, 0xFF, 0x3C, 0x3F, 0x83, 0xC0, 0xF7,
  0x77, 0x77, 0x77, 0x77, 0x70, 0x07, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0,
  0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0xF0,
  0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0C,
  0x71, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0x80, 0xEE, 0x0F, 0x70, 0x71,
  0xC7, 0x8F, 0x08, 0x20, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7B, 0xDE, 0xF7, 0x3B,
  0xDC, 0xE7, 0x30, 0xFF, 0xFF, 0xFF, 0xE0, 0x73, 0xFE, 0xF7, 0x80, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1C, 0x78,
  0x79, 0xC0, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0x70, 0x39,
  0xE1, 0xE7, 0x87, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0x83, 0xC3,
  0xE3, 0xF3, 0xFB, 0xDF, 0xCF, 0xC7, 0x43, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xE3, 0x83, 0xE2, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xE3, 0x81, 0xE2,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x79, 0x01, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xB8, 0x03, 0xB8, 0x03, 0xB8, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E,
  0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xEC, 0x0F,
  0xBF, 0xFC, 0xFF, 0xE1, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x87,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0xF0, 0xE7, 0xF3, 0xBF, 0xEF, 0xC7, 0xBE, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0x70, 0x3D, 0xE0, 0xF7, 0x87, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x3C, 0x1E, 0x78, 0x1F,
  0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3C, 0x3C, 0x78,
  0x1E, 0x70, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x1C, 0xF0, 0x7B, 0xC0, 0xEE, 0x03, 0xB8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x07, 0xDE, 0x3F, 0x7F, 0xDC, 0xFE, 0xF1, 0xF3, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFC, 0x00, 0x6F, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xEF, 0xFF, 0xF0, 0x33, 0xDE, 0xF7, 0x98, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0xF7, 0xBD, 0xCE, 0xF7, 0x39, 0xCC, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x3F,
  0xCF, 0xFE, 0x7F, 0xF6, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0x0F, 0x80, 0x78, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x3F, 0x0E, 0xE0, 0xFF,
  0x1D, 0xC3, 0x8E, 0x3B, 0x0E, 0x1C, 0x7E, 0x1C, 0x38, 0x7C, 0x38, 0x70,
  0xF8, 0x60, 0xE1, 0xF1, 0xC3, 0x83, 0xE3, 0x87, 0x07, 0xC7, 0x0E, 0x0F,
  0x8E, 0x1C, 0x3F, 0x1C, 0x38, 0x7E, 0x18, 0x70, 0xFC, 0x38, 0xB1, 0xF8,
  0x7B, 0x67, 0x70, 0x7E, 0xFC, 0x70, 0x78, 0xF8, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x08, 0x03, 0xC0,
  0x60, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x3C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x07, 0x8E, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x03, 0x83, 0x80, 0x70, 0x70,
  0x1E, 0x0F, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x0F, 0x38, 0x00, 0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81, 0xEF, 0x07, 0x9F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xFC, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1,
  0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x1F, 0x06, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x02, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1E, 0x1F, 0x8F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0xEF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x01, 0xDE,
  0x00, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x1E, 0x3C, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0x80, 0xC1, 0xE0, 0x04, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xCF, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0xEF, 0xFF, 0xFC, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x8F, 0xFE, 0xFE, 0xF8, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xE0, 0xF1, 0xE0, 0xF1,
  0xC0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFB, 0xC0, 0xFB, 0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0xF0, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xEE, 0x00, 0x3F, 0xEE, 0x00, 0x77, 0xEE,
  0x00, 0x77, 0xEE, 0x00, 0x77, 0xE7, 0x00, 0xE7, 0xE7, 0x00, 0xE7, 0xE7,
  0x00, 0xE7, 0xE3, 0x80, 0xE7, 0xE3, 0x81, 0xC7, 0xE3, 0x81, 0xC7, 0xE3,
  0x81, 0xC7, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1,
  0xE3, 0x87, 0xE0, 0xE7, 0x07, 0xE0, 0xE7, 0x07, 0xE0, 0xE7, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0xE0, 0x1F,
  0xBC, 0x07, 0xE7, 0x01, 0xF9, 0xC0, 0x7E, 0x78, 0x1F, 0x8E, 0x07, 0xE3,
  0xC1, 0xF8, 0x70, 0x7E, 0x1E, 0x1F, 0x83, 0x87, 0xE0, 0xE1, 0xF8, 0x3C,
  0x7E, 0x07, 0x1F, 0x81, 0xE7, 0xE0, 0x39, 0xF8, 0x0F, 0x7E, 0x03, 0xDF,
  0x80, 0x77, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x07, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x70,
  0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x38, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x3E, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0x70, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xE0,
  0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x38, 0x03, 0xC7, 0x80, 0xF0, 0x78,
  0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF1,
  0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0xF0,
  0x78, 0xF0, 0x38, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0F, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0x9E, 0x06, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3A, 0x01, 0xEC, 0x0F,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x7C, 0x1E,
  0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xC0,
  0x0F, 0x38, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x07, 0x0E, 0x01, 0xE1, 0xC0,
  0x3C, 0x3C, 0x07, 0x07, 0x80, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0,
  0xE0, 0x3C, 0x1C, 0x07, 0x83, 0x80, 0x70, 0xF0, 0x0E, 0x1E, 0x01, 0xE3,
  0x80, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0xEE,
  0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E,
  0x00, 0xF7, 0x00, 0x78, 0x03, 0xDC, 0x01, 0xE0, 0x0E, 0x78, 0x07, 0xC0,
  0x39, 0xE0, 0x3F, 0x01, 0xE3, 0x80, 0xFC, 0x07, 0x8E, 0x03, 0xF0, 0x1E,
  0x38, 0x0E, 0xC0, 0x70, 0xF0, 0x3B, 0x81, 0xC3, 0xC1, 0xCE, 0x0F, 0x07,
  0x07, 0x38, 0x3C, 0x1C, 0x1C, 0xE0, 0xF0, 0x70, 0x73, 0x83, 0x81, 0xE1,
  0xC7, 0x0E, 0x07, 0x8E, 0x1C, 0x78, 0x0E, 0x38, 0x71, 0xE0, 0x38, 0xE1,
  0xC7, 0x80, 0xE3, 0x87, 0x1C, 0x03, 0xCE, 0x0E, 0x70, 0x0F, 0x70, 0x3B,
  0xC0, 0x1D, 0xC0, 0xEF, 0x00, 0x77, 0x03, 0xB8, 0x01, 0xDC, 0x0E, 0xE0,
  0x07, 0x70, 0x1B, 0x80, 0x1D, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x78,
  0x0F, 0x1C, 0x07, 0x8F, 0x03, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0xE0,
  0x38, 0xF0, 0x1C, 0x70, 0x0F, 0x38, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF8, 0x01, 0xDC, 0x00, 0xEF, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x78, 0xF0,
  0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0F, 0x0E, 0x03, 0x8F, 0x01, 0xE7, 0x80,
  0xF7, 0x80, 0x3C, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x38,
  0x1E, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x38, 0x0E,
  0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xF8, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x39, 0xC0,
  0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC7, 0x80,
  0xE3, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0xF1, 0xE1, 0xE1, 0xC1, 0xC1, 0x80, 0x07, 0xE0, 0xFF,
  0xC3, 0xFF, 0x86, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x03, 0xF0, 0xFF, 0xCF, 0xFF, 0x3C, 0x3D, 0xE0, 0xF7, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDE, 0x1F, 0x7D, 0xDC, 0xFF, 0x71,
  0xF9, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC7, 0x83, 0x9F, 0xC7, 0x7F,
  0xCF, 0xC7, 0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1D, 0xC0, 0x3B, 0xC0, 0x77, 0x81, 0xEF, 0x83, 0x9F, 0xFF, 0x3B, 0xFC,
  0x73, 0xF0, 0x07, 0xC1, 0xFF, 0x3F, 0xE7, 0xC2, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x81, 0x3F, 0xE3, 0xFE, 0x0F,
  0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x1E, 0x3C, 0x7F, 0x79, 0xFF, 0xF7,
  0xC7, 0xEF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7B, 0x81, 0xF7, 0x83, 0xEF, 0xFD, 0xCF, 0xF3, 0x8F,
  0xC7, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1C, 0x70, 0x39, 0xC0, 0xEF,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x02,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFC, 0xFF, 0xCF, 0xFC,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x8E, 0x3F, 0x9C, 0xFF, 0xBB,
  0xE3, 0xF7, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0xFB, 0xC1, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7,
  0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xCC, 0x0F, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x8F, 0x0E, 0xFF, 0x3B, 0xFC, 0xFC, 0x7B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E,
  0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0x77, 0xF7, 0x70, 0x00, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x0E, 0x1C, 0x78, 0x70,
  0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xFF, 0x7E, 0xF8, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0xEE, 0x07, 0xB8, 0x3C, 0xE0, 0xE3, 0x87, 0x8E, 0x3C, 0x38, 0xE0,
  0xE7, 0x83, 0x9C, 0x0E, 0xF0, 0x3B, 0xC0, 0xFF, 0x83, 0xEE, 0x0F, 0x3C,
  0x38, 0xF0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x81,
  0xEE, 0x07, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC1, 0xF1, 0xDF, 0xC7, 0xF3, 0xBF, 0xDF,
  0xF7, 0xC7, 0xB1, 0xEF, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xF8, 0x0E, 0x07,
  0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F,
  0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0,
  0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01,
  0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0x80, 0xC3,
  0xC3, 0xBF, 0xCE, 0xFF, 0x3E, 0x1E, 0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xB8,
  0x0E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xC7,
  0x83, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1D,
  0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00,
  0xE3, 0xC1, 0xCF, 0xE3, 0xBF, 0xE7, 0xC3, 0xCF, 0x03, 0xDE, 0x07, 0xBC,
  0x07, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0E, 0xF0, 0x1D, 0xE0, 0x3B, 0xC0, 0xF7,
  0xC3, 0xCF, 0xFF, 0x9D, 0xFE, 0x39, 0xF8, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x0F, 0x8E, 0x3F, 0x9C, 0xFF, 0xBB, 0xE3, 0xF7, 0x83, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D,
  0xC0, 0xFB, 0xC1, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7, 0xE7, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0xC3, 0xE3, 0xFB, 0xFF, 0xFF, 0x87, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x0F, 0xC3, 0xFF, 0x7F, 0xE7, 0x86,
  0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFC, 0x0F,
  0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1F, 0xC7, 0xE3,
  0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xFC, 0x1F, 0xE1, 0xF7, 0xFF, 0xBF,
  0xCC, 0xFC, 0x60, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xF7, 0x81,
  0xCF, 0x03, 0x8E, 0x0F, 0x1C, 0x1E, 0x38, 0x38, 0x78, 0x70, 0x70, 0xE0,
  0xE3, 0xC1, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1D,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x1E, 0x03, 0xB8, 0x0F, 0x03, 0xDC, 0x0F, 0x81, 0xEE, 0x07, 0xC0, 0xE7,
  0x83, 0xE0, 0x73, 0xC1, 0xF8, 0x38, 0xE0, 0xDC, 0x3C, 0x70, 0xEE, 0x1C,
  0x38, 0x77, 0x0E, 0x1E, 0x39, 0x87, 0x07, 0x1C, 0xE3, 0x83, 0x8C, 0x73,
  0xC1, 0xCE, 0x39, 0xC0, 0xE7, 0x1C, 0xE0, 0x7B, 0x86, 0x70, 0x1D, 0xC3,
  0xB8, 0x0E, 0xC1, 0xFC, 0x07, 0x60, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0xF0,
  0x3F, 0xC0, 0xE7, 0x07, 0x9E, 0x1E, 0x38, 0x70, 0xF3, 0xC1, 0xCE, 0x07,
  0x78, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x01,
  0xFC, 0x07, 0x78, 0x1C, 0xE0, 0xE3, 0xC3, 0x87, 0x1E, 0x1E, 0x70, 0x7B,
  0xC0, 0xEE, 0x03, 0xC0, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xF7,
  0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1E, 0x3C, 0x38, 0x38, 0x70, 0x70,
  0xE0, 0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x3C, 0x1F, 0x03, 0xC0, 0x7E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x1F, 0x81, 0xF0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x1F, 0x03,
  0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0x83,
  0xF0, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xC3, 0xF0, 0x7C, 0x0C, 0x00,
  0x00, 0x01, 0x7F, 0x01, 0xFF, 0xC3, 0xF7, 0xFF, 0xC1, 0xFE, 0x80, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 30, 10, 3, -30 },
  { 16, 12, 11, 16, 2, -30 },
  { 33, 18, 30, 19, 1, -30 },
  { 101, 14, 34, 18, 2, -32 },
  { 161, 24, 30, 28, 2, -30 },
  { 251, 19, 30, 20, 1, -30 },
  { 323, 4, 11, 9, 2, -30 },
  { 329, 9, 37, 12, 2, -30 },
  { 371, 9, 37, 12, 1, -30 },
  { 413, 13, 14, 17, 2, -32 },
  { 436, 16, 20, 18, 1, -25 },
  { 476, 5, 11, 9, 2, -5 },
  { 483, 9, 3, 12, 1, -13 },
  { 487, 5, 5, 9, 2, -5 },
  { 491, 14, 30, 16, 1, -30 },
  { 544, 14, 30, 18, 2, -30 },
  { 597, 9, 30, 18, 3, -30 },
  { 631, 15, 30, 18, 1, -30 },
  { 688, 15, 30, 18, 1, -30 },
  { 745, 16, 30, 18, 1, -30 },
  { 805, 14, 30, 18, 2, -30 },
  { 858, 14, 30, 18, 2, -30 },
  { 911, 16, 30, 18, 1, -30 },
  { 971, 16, 30, 18, 1, -30 },
  { 1031, 14, 30, 18, 2, -30 },
  { 1084, 4, 23, 10, 3, -23 },
  { 1096, 5, 29, 10, 2, -23 },
  { 1115, 16, 18, 18, 1, -24 },
  { 1151, 16, 12, 18, 1, -21 },
  { 1175, 16, 18, 18, 1, -24 },
  { 1211, 12, 30, 13, 0, -30 },
  { 1256, 23, 34, 27, 2, -30 },
  { 1354, 19, 30, 19, 0, -30 },
  { 1426, 15, 30, 20, 3, -30 },
  { 1483, 16, 30, 19, 2, -30 },
  { 1543, 17, 30, 22, 3, -30 },
  { 1607, 12, 30, 17, 3, -30 },
  { 1652, 12, 30, 16, 3, -30 },
  { 1697, 19, 30, 23, 2, -30 },
  { 1769, 16, 30, 22, 3, -30 },
  { 1829, 9, 30, 12, 1, -30 },
  { 1863, 8, 38, 9, -2, -30 },
  { 1901, 16, 30, 19, 3, -30 },
  { 1961, 12, 30, 16, 3, -30 },
  { 2006, 24, 30, 30, 3, -30 },
  { 2096, 18, 30, 24, 3, -30 },
  { 2164, 19, 30, 23, 2, -30 },
  { 2236, 14, 30, 19, 3, -30 },
  { 2289, 19, 37, 23, 2, -30 },
  { 2377, 16, 30, 19, 3, -30 },
  { 2437, 14, 30, 17, 2, -30 },
  { 2490, 16, 30, 16, 0, -30 },
  { 2550, 16, 30, 22, 3, -30 },
  { 2610, 19, 30, 19, 0, -30 },
  { 2682, 30, 30, 30, 0, -30 },
  { 2795, 17, 30, 17, 0, -30 },
  { 2859, 16, 30, 16, 0, -30 },
  { 2919, 13, 30, 15, 1, -30 },
  { 2968, 9, 37, 13, 3, -30 },
  { 3010, 14, 30, 16, 1, -30 },
  { 3063, 9, 37, 13, 1, -30 },
  { 3105, 17, 16, 19, 1, -30 },
  { 3139, 18, 3, 18, 0, 3 },
  { 3146, 7, 7, 11, 2, -32 },
  { 3153, 14, 23, 17, 1, -23 },
  { 3194, 15, 32, 19, 3, -32 },
  { 3254, 12, 23, 15, 2, -23 },
  { 3289, 15, 32, 19, 2, -32 },
  { 3349, 14, 23, 18, 2, -23 },
  { 3390, 12, 32, 11, 0, -32 },
  { 3438, 15, 33, 19, 2, -23 },
  { 3500, 14, 32, 19, 3, -32 },
  { 3556, 4, 31, 9, 2, -31 },
  { 3572, 7, 41, 9, -1, -31 },
  { 3608, 14, 32, 17, 3, -32 },
  { 3664, 3, 32, 9, 3, -32 },
  { 3676, 23, 23, 29, 3, -23 },
  { 3743, 14, 23, 19, 3, -23 },
  { 3784, 15, 23, 19, 2, -23 },
  { 3828, 15, 33, 19, 3, -23 },
  { 3890, 15, 33, 19, 2, -23 },
  { 3952, 9, 23, 13, 3, -23 },
  { 3978, 12, 23, 14, 1, -23 },
  { 4013, 9, 28, 11, 1, -28 },
  { 4045, 13, 23, 19, 3, -23 },
  { 4083, 15, 23, 16, 0, -23 },
  { 4127, 25, 23, 25, 0, -23 },
  { 4199, 14, 23, 16, 1, -23 },
  { 4240, 15, 33, 16, 0, -23 },
  { 4302, 11, 23, 13, 1, -23 },
  { 4334, 11, 37, 15, 2, -30 },
  { 4385, 3, 42, 17, 7, -32 },
  { 4401, 11, 37, 15, 2, -30 },
  { 4452, 16, 6, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Regular42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR42PT7B_H_
