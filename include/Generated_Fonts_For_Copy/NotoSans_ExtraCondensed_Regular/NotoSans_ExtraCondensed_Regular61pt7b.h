#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0x30, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38,
  0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0,
  0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x1C,
  0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFC, 0xE3, 0xC7, 0xC3, 0x81,
  0x1F, 0x0E, 0x00, 0x78, 0x38, 0x03, 0xE0, 0xE0, 0x0F, 0x83, 0x80, 0x3E,
  0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0xC3, 0x80, 0x1F, 0x8E,
  0x00, 0x3F, 0xB8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0E, 0xFC, 0x00,
  0x38, 0xF8, 0x00, 0xE3, 0xE0, 0x03, 0x87, 0xC0, 0x0E, 0x1F, 0x00, 0x38,
  0x7C, 0x00, 0xE1, 0xF0, 0x03, 0x87, 0xC0, 0x0E, 0x1E, 0x80, 0x38, 0xFB,
  0xC0, 0xE7, 0xEF, 0xF3, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x01,
  0xE0, 0x03, 0xFF, 0x80, 0x1E, 0x00, 0x3C, 0x78, 0x03, 0xC0, 0x07, 0x83,
  0xC0, 0x3C, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x78, 0x00,
  0x78, 0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x78, 0x00, 0x78, 0x3E, 0x0F,
  0x00, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0xF8, 0x3E, 0x0F, 0x00, 0x0F, 0x83,
  0xE1, 0xE0, 0x00, 0xF8, 0x3E, 0x1E, 0x00, 0x0F, 0x83, 0xE1, 0xE0, 0x00,
  0x78, 0x3E, 0x3C, 0x00, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x78, 0x3C, 0x7C,
  0x7F, 0x87, 0x83, 0xC7, 0x8F, 0xF8, 0x78, 0x3C, 0x78, 0xFF, 0xC7, 0x83,
  0xCF, 0x1F, 0x3E, 0x3C, 0x78, 0xF1, 0xE1, 0xE3, 0xFF, 0x8F, 0x1E, 0x1E,
  0x1F, 0xF1, 0xE3, 0xC1, 0xF0, 0xFE, 0x1E, 0x3C, 0x0F, 0x07, 0xC1, 0xE3,
  0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0xF0, 0x00,
  0x3C, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x1C, 0x1E, 0x00, 0x3E, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0x1E, 0x1E,
  0x00, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x80, 0x0F, 0xFC, 0x00, 0x78, 0x00,
  0x7F, 0x80, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x7E, 0x3F, 0x7E, 0x0F, 0x87,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x3E, 0x3E, 0x0F, 0x87, 0xCF, 0x80, 0xF8,
  0xF9, 0xF0, 0x1F, 0xBE, 0x3E, 0x01, 0xF7, 0xC7, 0xC0, 0x1F, 0xF8, 0xF8,
  0x03, 0xFE, 0x1F, 0x00, 0x3F, 0xC3, 0xE0, 0x07, 0xF8, 0x7C, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xFC, 0x1F, 0x00, 0xFF, 0xC3, 0xF8,
  0x7F, 0xF8, 0x7F, 0xFF, 0xDF, 0x87, 0xFF, 0xF1, 0xF8, 0x7F, 0xFC, 0x3F,
  0x07, 0xFE, 0x03, 0xF0, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xCE, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x04, 0x0F, 0x02, 0x78, 0xF1, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7D, 0xE0,
  0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x0E, 0x07,
  0x00, 0x20, 0x40, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x8F, 0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F,
  0x07, 0x83, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0x8C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1,
  0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F,
  0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xDF, 0x7E, 0x7F, 0xF1,
  0xFF, 0x87, 0xDC, 0x1F, 0x20, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFB,
  0xFE, 0x3C, 0x03, 0xF0, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xF1, 0xFE, 0x3C, 0x03, 0xF8,
  0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFB,
  0x00, 0x0F, 0xDE, 0x01, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x79, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF1,
  0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xC1,
  0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xBF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x20, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x80, 0x0F, 0xEF, 0x01, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x05, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0x8C, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x10, 0x07, 0xC7, 0xF8, 0x3E,
  0x7F, 0xE1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x83, 0xF3, 0xF8, 0x0F,
  0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xF1, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x87, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7E,
  0x1F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0x83,
  0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F,
  0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFD, 0xFC, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0x8F, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBF,
  0x01, 0xFC, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFE, 0xF8, 0x7F, 0xF7,
  0xC1, 0xFF, 0x3E, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x04, 0x07,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x1E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3,
  0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xC1,
  0xE0, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xCF, 0xF3, 0x00, 0xF9, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x01, 0xFC, 0x0F, 0x8F, 0x01, 0xFF, 0xC1, 0xE7, 0xC0, 0xFF, 0xF0,
  0x79, 0xE0, 0x3E, 0x3C, 0x1E, 0x78, 0x1F, 0x0F, 0x07, 0xDE, 0x07, 0x83,
  0xC0, 0xF7, 0x83, 0xC0, 0xF0, 0x3F, 0xC0, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0x03, 0xFC, 0x1F, 0x03, 0xC0, 0xFF, 0x07, 0xC1, 0xF0, 0x3F, 0xC1,
  0xE0, 0x7C, 0x0F, 0xF0, 0x78, 0x1F, 0x03, 0xFC, 0x1E, 0x07, 0xC0, 0xFF,
  0x07, 0x81, 0xF0, 0x3F, 0xC1, 0xE0, 0x7C, 0x0F, 0xF0, 0x78, 0x1F, 0x07,
  0xBC, 0x1F, 0x07, 0xC1, 0xEF, 0x03, 0xC1, 0xF0, 0x7B, 0xC0, 0xF0, 0xFC,
  0x1E, 0xF0, 0x3E, 0x3F, 0x0F, 0x3E, 0x07, 0xFC, 0xFF, 0xC7, 0x81, 0xFF,
  0x3F, 0xE1, 0xE0, 0x3F, 0x87, 0xF0, 0x78, 0x07, 0xC0, 0xF8, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x03, 0x80, 0x00, 0xFF, 0x8F, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xE0, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x80, 0xFF,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xE3, 0xF0,
  0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x7E, 0x0F, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0x7E,
  0x07, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xCF, 0xC1, 0xFC, 0x03, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0x03, 0xFC, 0x0E, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFC, 0x0F,
  0xE0, 0x07, 0x03, 0xF0, 0x00, 0x20, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3F,
  0x80, 0x07, 0xC3, 0xF8, 0x00, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF,
  0x87, 0xC0, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0xFD,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x7C, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFB, 0xC0, 0x00, 0x3D, 0xFF, 0x78, 0x00, 0x07,
  0xBF, 0xEF, 0x80, 0x01, 0xF7, 0xFD, 0xF0, 0x00, 0x3C, 0xFF, 0x9E, 0x00,
  0x07, 0x9F, 0xF3, 0xC0, 0x01, 0xF7, 0xFE, 0x7C, 0x00, 0x3E, 0xFF, 0xCF,
  0x80, 0x07, 0x9F, 0xF8, 0xF0, 0x00, 0xF3, 0xFF, 0x1F, 0x00, 0x3E, 0x7F,
  0xE3, 0xE0, 0x07, 0x8F, 0xFC, 0x3C, 0x00, 0xF1, 0xFF, 0x87, 0x80, 0x3E,
  0x3F, 0xF0, 0xF8, 0x07, 0xC7, 0xFE, 0x1F, 0x00, 0xF0, 0xFF, 0xC1, 0xE0,
  0x1E, 0x1F, 0xF8, 0x3E, 0x07, 0xC3, 0xFF, 0x07, 0xC0, 0xF0, 0x7F, 0xE0,
  0x78, 0x1E, 0x0F, 0xFC, 0x0F, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0xF8, 0x3F,
  0xF0, 0x3E, 0x1E, 0x07, 0xFE, 0x03, 0xC3, 0xC0, 0xFF, 0xC0, 0x7C, 0xF8,
  0x1F, 0xF8, 0x0F, 0x9E, 0x03, 0xFF, 0x00, 0xF3, 0xC0, 0x7F, 0xE0, 0x1E,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F,
  0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x07, 0xE0,
  0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFE,
  0xF8, 0x01, 0xFF, 0xBE, 0x00, 0x7F, 0xEF, 0x80, 0x1F, 0xF9, 0xF0, 0x07,
  0xFE, 0x7C, 0x01, 0xFF, 0x8F, 0x80, 0x7F, 0xE3, 0xE0, 0x1F, 0xF8, 0x7C,
  0x07, 0xFE, 0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xE0, 0xF8, 0x1F, 0xF8,
  0x3E, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F,
  0xF8, 0x0F, 0x87, 0xFE, 0x03, 0xE1, 0xFF, 0x80, 0x7C, 0x7F, 0xE0, 0x1F,
  0x1F, 0xF8, 0x03, 0xE7, 0xFE, 0x00, 0xF9, 0xFF, 0x80, 0x3E, 0x3F, 0xE0,
  0x07, 0xCF, 0xF8, 0x01, 0xF3, 0xFE, 0x00, 0x3E, 0xFF, 0x80, 0x0F, 0xBF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x07, 0xF3, 0xF0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xEF,
  0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF3, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0x83, 0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0xC0,
  0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x00,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F,
  0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0x43, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC0, 0x71, 0xF8,
  0x00, 0x8F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x40, 0x01, 0xFB, 0x80,
  0x1F, 0x9F, 0x83, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x0F,
  0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x3E,
  0x00, 0x3F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x3F, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xBE, 0x00, 0xF8, 0x1F, 0x00, 0x79,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x9E, 0x00, 0xF8, 0x1F, 0x00, 0x79, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0x9E, 0x01, 0xF8, 0x0F, 0x80, 0xF9, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0xF0, 0x3F, 0x00, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x07,
  0x87, 0xE0, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xC0, 0x3C, 0x7C, 0x00, 0x3E, 0x3C, 0x03, 0xC7, 0xC0,
  0x03, 0xE3, 0xC0, 0x3C, 0xFC, 0x00, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x00, 0x1F, 0x78, 0x01, 0xEF, 0x80, 0x01, 0xF7,
  0x80, 0x1E, 0xF8, 0x00, 0x1F, 0x78, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3F,
  0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC1, 0xF0, 0x07,
  0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xE3, 0xE0, 0x01,
  0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xF7, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xE3, 0xC0, 0x03,
  0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xFC, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x3C,
  0x07, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0E, 0x07, 0xE0, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x1F, 0x7E,
  0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0x7C, 0x0F, 0xF7, 0xFB, 0xDF, 0x3F, 0xFD, 0xF3, 0xFF, 0x8F, 0x0F, 0xE0,
  0xF0, 0x18, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE1, 0xFC, 0x0F, 0x9F, 0xF8, 0x3E, 0xFF, 0xF0, 0xFB,
  0xFF, 0xE3, 0xFE, 0x1F, 0x8F, 0xE0, 0x3F, 0x3F, 0x80, 0x7C, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x7C, 0xFE, 0x01, 0xF3, 0xFC, 0x0F, 0xCF, 0xFF,
  0xFE, 0x3C, 0xFF, 0xF0, 0xF1, 0xFF, 0xC3, 0xC3, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xF8, 0x31,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x19, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFE, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x83, 0xFC, 0x7C, 0x3F, 0xF3, 0xE3, 0xFF, 0xDF, 0x3F, 0xFF, 0xF9, 0xF8,
  0x7F, 0xDF, 0x80, 0xFE, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7E,
  0x03, 0xF9, 0xF8, 0x3F, 0xCF, 0xFF, 0xDE, 0x3F, 0xFC, 0xF0, 0xFF, 0xC7,
  0x83, 0xFC, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x02, 0x3F, 0x00, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x38, 0x01, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xE3, 0xC7, 0xFF,
  0x9E, 0x7F, 0xFE, 0xF3, 0xF0, 0xF7, 0xBF, 0x01, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xF3, 0xF0, 0x77, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFB, 0xE1, 0xFF, 0x9F, 0x07, 0xF8, 0xF8, 0x0E, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF2, 0x00, 0x1F, 0x9C, 0x01, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x18, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF,
  0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF8, 0x7E, 0xFE, 0x03, 0xEF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x77, 0xFF, 0xFF, 0xFD, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF,
  0xE0, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x3F, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8,
  0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x7C, 0x0F, 0xE7, 0xC0, 0xFC, 0x7C,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0xFE, 0x03, 0xFC, 0x3C, 0x7F, 0xE1, 0xFF, 0x8F, 0x3F,
  0xF8, 0xFF, 0xF3, 0xDF, 0xFF, 0x7F, 0xFC, 0xF7, 0x0F, 0xDE, 0x3F, 0xBF,
  0x81, 0xFE, 0x03, 0xEF, 0xC0, 0x3F, 0x80, 0xFB, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00,
  0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x03,
  0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0,
  0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x07,
  0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xF0,
  0xFF, 0x0F, 0x1F, 0xF8, 0xF3, 0xFF, 0xCF, 0x7F, 0xFE, 0xF7, 0x87, 0xEF,
  0xE0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x07, 0xE1,
  0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x7F, 0x03, 0xC7,
  0xFE, 0x0F, 0x3F, 0xFC, 0x3C, 0xFF, 0xF8, 0xFF, 0x87, 0xF3, 0xF8, 0x0F,
  0xCF, 0xE0, 0x1F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0x3F, 0x80,
  0xFC, 0xFF, 0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0xBF, 0xFC, 0x3E, 0x7F, 0xF0,
  0xF8, 0xFF, 0x03, 0xE0, 0x60, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x7F,
  0xE3, 0xC7, 0xFF, 0x9E, 0x7F, 0xFE, 0xF3, 0xF0, 0xF7, 0xBF, 0x01, 0xFD,
  0xF0, 0x07, 0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xF3, 0xF0, 0x77,
  0x9F, 0xFF, 0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0x9F, 0x07, 0xF8, 0xF8, 0x0E,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0xFB, 0xDE,
  0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x07, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE7, 0xE0, 0xE7, 0xE0,
  0x13, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xEE,
  0x03, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00,
  0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x7E,
  0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFC, 0xF1, 0xFF, 0x8F, 0x0F, 0xF0, 0xF0,
  0x18, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C,
  0x3E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x83,
  0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80,
  0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x3C, 0xF8, 0x07, 0xF0, 0x0F, 0x9F,
  0x01, 0xEE, 0x01, 0xF3, 0xE0, 0x3D, 0xE0, 0x3E, 0x7C, 0x07, 0xBC, 0x07,
  0xC7, 0x80, 0xF7, 0x80, 0xF0, 0xF8, 0x1E, 0xF0, 0x3E, 0x1F, 0x07, 0xDE,
  0x07, 0xC3, 0xE0, 0xF1, 0xE0, 0xF8, 0x7C, 0x1E, 0x3C, 0x1E, 0x07, 0x83,
  0xC7, 0x83, 0xC0, 0xF8, 0x78, 0xF0, 0xF8, 0x1F, 0x1F, 0x1F, 0x1F, 0x03,
  0xE3, 0xC3, 0xE3, 0xE0, 0x7C, 0x78, 0x3C, 0x78, 0x07, 0x8F, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0xF3, 0xE0, 0x1F, 0x7C, 0x1E, 0x7C, 0x03, 0xEF, 0x03,
  0xEF, 0x00, 0x3D, 0xE0, 0x3D, 0xE0, 0x07, 0xBC, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0xF7, 0x80, 0x1E, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x78,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x07, 0x87, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xC0,
  0x02, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xD8, 0x03, 0xFF, 0x20, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 45, 14, 4, -44 },
  { 35, 16, 16, 23, 4, -44 },
  { 67, 26, 44, 28, 1, -44 },
  { 210, 22, 50, 26, 2, -46 },
  { 348, 36, 45, 41, 2, -44 },
  { 551, 27, 45, 29, 2, -44 },
  { 703, 5, 16, 13, 4, -44 },
  { 713, 13, 54, 18, 3, -44 },
  { 801, 13, 54, 18, 2, -44 },
  { 889, 20, 20, 24, 2, -46 },
  { 939, 22, 29, 26, 2, -36 },
  { 1019, 9, 15, 14, 2, -7 },
  { 1036, 13, 5, 17, 2, -19 },
  { 1045, 6, 8, 14, 4, -7 },
  { 1051, 21, 44, 23, 1, -44 },
  { 1167, 22, 45, 26, 2, -44 },
  { 1291, 14, 44, 26, 4, -44 },
  { 1368, 21, 44, 26, 2, -44 },
  { 1484, 21, 45, 26, 2, -44 },
  { 1603, 24, 44, 26, 1, -44 },
  { 1735, 20, 45, 26, 3, -44 },
  { 1848, 21, 45, 26, 3, -44 },
  { 1967, 22, 44, 26, 2, -44 },
  { 2088, 22, 45, 26, 2, -44 },
  { 2212, 21, 45, 26, 2, -44 },
  { 2331, 6, 34, 14, 4, -33 },
  { 2357, 9, 41, 14, 2, -33 },
  { 2404, 22, 27, 26, 2, -35 },
  { 2479, 22, 17, 26, 2, -30 },
  { 2526, 22, 27, 26, 2, -35 },
  { 2601, 17, 45, 19, 1, -44 },
  { 2697, 34, 49, 40, 3, -44 },
  { 2906, 27, 44, 27, 0, -44 },
  { 3055, 23, 44, 29, 4, -44 },
  { 3182, 23, 45, 27, 3, -44 },
  { 3312, 24, 44, 31, 4, -44 },
  { 3444, 18, 44, 25, 4, -44 },
  { 3543, 18, 44, 23, 4, -44 },
  { 3642, 27, 45, 33, 3, -44 },
  { 3794, 24, 44, 33, 4, -44 },
  { 3926, 13, 44, 17, 2, -44 },
  { 3998, 12, 56, 14, -3, -44 },
  { 4082, 24, 44, 27, 4, -44 },
  { 4214, 18, 44, 23, 4, -44 },
  { 4313, 35, 44, 44, 4, -44 },
  { 4506, 26, 44, 35, 4, -44 },
  { 4649, 28, 45, 34, 3, -44 },
  { 4807, 21, 44, 27, 4, -44 },
  { 4923, 28, 54, 34, 3, -44 },
  { 5112, 23, 44, 28, 4, -44 },
  { 5239, 21, 45, 25, 2, -44 },
  { 5358, 22, 44, 23, 1, -44 },
  { 5479, 24, 45, 32, 4, -44 },
  { 5614, 27, 44, 27, 0, -44 },
  { 5763, 44, 44, 44, 0, -44 },
  { 6005, 24, 44, 24, 0, -44 },
  { 6137, 24, 44, 24, 0, -44 },
  { 6269, 19, 44, 22, 2, -44 },
  { 6374, 13, 54, 19, 4, -44 },
  { 6462, 21, 44, 23, 1, -44 },
  { 6578, 13, 54, 19, 2, -44 },
  { 6666, 25, 24, 27, 1, -44 },
  { 6741, 27, 4, 27, 0, 5 },
  { 6755, 12, 10, 16, 2, -47 },
  { 6770, 20, 34, 25, 2, -33 },
  { 6855, 22, 47, 28, 4, -46 },
  { 6985, 17, 34, 21, 3, -33 },
  { 7058, 21, 47, 28, 3, -46 },
  { 7182, 20, 34, 26, 3, -33 },
  { 7267, 16, 47, 15, 1, -47 },
  { 7361, 21, 48, 28, 3, -33 },
  { 7487, 20, 46, 28, 4, -46 },
  { 7602, 5, 45, 13, 4, -45 },
  { 7631, 10, 60, 13, -1, -45 },
  { 7706, 20, 46, 24, 4, -46 },
  { 7821, 5, 46, 13, 4, -46 },
  { 7850, 34, 33, 42, 4, -33 },
  { 7991, 20, 33, 28, 4, -33 },
  { 8074, 22, 34, 27, 3, -33 },
  { 8168, 22, 48, 28, 4, -33 },
  { 8300, 21, 48, 28, 3, -33 },
  { 8426, 14, 33, 19, 4, -33 },
  { 8484, 17, 34, 21, 2, -33 },
  { 8557, 14, 41, 16, 1, -40 },
  { 8629, 20, 34, 28, 4, -33 },
  { 8714, 22, 33, 23, 0, -33 },
  { 8805, 35, 33, 37, 1, -33 },
  { 8950, 21, 33, 23, 1, -33 },
  { 9037, 22, 48, 23, 0, -33 },
  { 9169, 15, 33, 18, 2, -33 },
  { 9231, 18, 54, 22, 2, -44 },
  { 9353, 5, 61, 25, 10, -47 },
  { 9392, 18, 54, 22, 2, -44 },
  { 9514, 23, 7, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Regular61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR61PT7B_H_
