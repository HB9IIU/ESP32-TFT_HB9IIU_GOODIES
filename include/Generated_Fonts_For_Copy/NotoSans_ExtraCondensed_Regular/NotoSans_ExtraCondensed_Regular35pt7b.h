#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x00, 0x07,
  0xFF, 0x70, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xC7, 0x61,
  0x80, 0x06, 0x30, 0x1C, 0x60, 0x38, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86,
  0x03, 0x0C, 0x7F, 0xFF, 0xFF, 0xFE, 0x18, 0xC0, 0x71, 0x80, 0xC3, 0x01,
  0x86, 0x03, 0x0C, 0x06, 0x18, 0x7F, 0xFE, 0xFF, 0xFC, 0x31, 0x80, 0xE3,
  0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x31, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0F, 0x01, 0xFF, 0x1F, 0xF9, 0xC8, 0x4C,
  0x40, 0xE2, 0x07, 0x10, 0x18, 0x80, 0xE4, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x02, 0xF0, 0x11, 0x80, 0x8E, 0x04, 0x70, 0x23, 0xC1, 0x3B,
  0xCB, 0xDF, 0xFC, 0x3F, 0x80, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x3E, 0x03, 0x01, 0xF0, 0x38, 0x19, 0xC1, 0x80, 0xC6, 0x0C, 0x06, 0x30,
  0xE0, 0x71, 0x86, 0x03, 0x8E, 0x30, 0x1C, 0x73, 0x80, 0xE3, 0x98, 0x07,
  0x19, 0xC0, 0x18, 0xCC, 0x78, 0xC6, 0x67, 0xE6, 0x77, 0x73, 0x1F, 0x33,
  0x18, 0xF9, 0x98, 0xE0, 0x1C, 0xC7, 0x00, 0xC6, 0x38, 0x06, 0x31, 0xC0,
  0x71, 0x8E, 0x03, 0x0C, 0x70, 0x18, 0x63, 0x81, 0xC3, 0x18, 0x0C, 0x1C,
  0xC0, 0x60, 0x7E, 0x07, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x39, 0xC0,
  0x38, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x39, 0xC0, 0x39, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x0E, 0x73, 0x8E,
  0x71, 0xCC, 0xE1, 0xDC, 0xE0, 0xFC, 0xE0, 0xFC, 0xE0, 0x78, 0xE0, 0x78,
  0xF0, 0xF8, 0x79, 0xFC, 0x7F, 0xDE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFB, 0x60,
  0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0,
  0xC1, 0xC1, 0x81, 0x80, 0xE0, 0xE0, 0xC1, 0xC3, 0x83, 0x87, 0x06, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0xC1, 0x83, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x8E, 0x1C, 0x30, 0xE1, 0xC7, 0x0C, 0x38, 0x00, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x76, 0xEF, 0xFE, 0x7F, 0xD0, 0xF0, 0x1F, 0x83, 0x9C, 0x79,
  0xC1, 0x08, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x39, 0xDE, 0xE7, 0x39, 0x8C, 0xE0,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0xFE, 0x0F, 0x78,
  0x71, 0xC7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x01, 0xB8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x06, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x70, 0xF7, 0x83, 0xF8, 0x0F, 0x80,
  0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x3F, 0x87, 0xFC, 0xF9, 0xE4, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x87, 0xFE, 0xF1, 0xE4, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0xC1, 0xF8, 0x1F, 0x80, 0x3E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x0F,
  0xE1, 0xEF, 0xFC, 0x7F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x1B, 0x80, 0x6E, 0x03, 0x38, 0x0C, 0xE0, 0x73, 0x81, 0x8E,
  0x0E, 0x38, 0x30, 0xE1, 0xC3, 0x86, 0x0E, 0x38, 0x38, 0xC0, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x7F, 0xCF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xFE, 0x7F, 0xE4, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x03, 0xF0, 0xF7, 0xFC, 0xFF, 0x00,
  0x0F, 0xC1, 0xFC, 0x3C, 0x47, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x70, 0xDF, 0xCD, 0xFC, 0xF1, 0xEE, 0x0E, 0xE0, 0xEE, 0x06,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xE7, 0x0E, 0x7B, 0xC3, 0xFC,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x71, 0xC7, 0x07,
  0x70, 0x1F, 0x00, 0xF8, 0x1E, 0xE1, 0xE3, 0x8E, 0x0E, 0xE0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x39, 0xE3, 0xC7, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x07, 0x70, 0xF3, 0xFF, 0x3F, 0x70, 0xE7,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x43, 0xC7, 0xF8,
  0x7F, 0x00, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xF0,
  0x33, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x39, 0xDC,
  0xE7, 0x31, 0x9C, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x1C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x00, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x78, 0x03, 0x00, 0x00, 0x3F, 0x3F,
  0xE7, 0x3D, 0x07, 0x01, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x1C, 0x0F, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x78, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x38,
  0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x9C, 0x00, 0x33, 0x0F,
  0xE7, 0xE3, 0xFC, 0xFC, 0x63, 0x8F, 0x0C, 0x61, 0xE3, 0x8C, 0x3C, 0x61,
  0x87, 0x8C, 0x30, 0xF1, 0x86, 0x1E, 0x30, 0xC3, 0xC6, 0x18, 0x78, 0xE7,
  0x1F, 0x0C, 0xF3, 0x71, 0xF7, 0xEE, 0x1C, 0x78, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC1, 0x80, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06,
  0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C,
  0x30, 0x1C, 0x38, 0x1C, 0x38, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x38,
  0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0,
  0x0E, 0xE0, 0x07, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE3, 0xCF, 0xF8, 0xFF, 0xCE, 0x1E,
  0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0xCF, 0x8C, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF8, 0xC3, 0xFE, 0x07, 0xF0, 0xFF, 0x07,
  0xFE, 0x3F, 0xF9, 0xC3, 0xCE, 0x0F, 0x70, 0x3B, 0x81, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xEE, 0x0F, 0x70, 0xF3, 0xFF, 0x9F,
  0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x7C,
  0x71, 0xE0, 0x27, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x80, 0xE7, 0x81,
  0xCF, 0xC7, 0x8F, 0xFF, 0x07, 0xFC, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x38, 0xFF,
  0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xFF, 0xFF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xFF, 0xFF, 0x38, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xC3, 0xCE, 0x1C,
  0x71, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x81, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0x9C, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0x71, 0xC3,
  0x8E, 0x1E, 0x70, 0x73, 0x83, 0xDC, 0x0E, 0xE0, 0x78, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFD, 0x80, 0x37, 0xDC, 0x03, 0x7D, 0xC0, 0x77, 0xCC, 0x07,
  0x7C, 0xC0, 0x67, 0xCE, 0x0E, 0x7C, 0xE0, 0xE7, 0xC6, 0x0C, 0x7C, 0x70,
  0xC7, 0xC7, 0x1C, 0x7C, 0x31, 0xC7, 0xC3, 0x18, 0x7C, 0x3B, 0x87, 0xC3,
  0xB8, 0x7C, 0x1B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x7C,
  0x0E, 0x07, 0xC0, 0xE0, 0x70, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0x60, 0x3D, 0xC0, 0xF7, 0x03, 0xCE, 0x0F, 0x38, 0x3C, 0x70,
  0xF1, 0xC3, 0xC3, 0x0F, 0x0E, 0x3C, 0x38, 0xF0, 0x73, 0xC1, 0xCF, 0x03,
  0xBC, 0x0E, 0xF0, 0x1B, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1C, 0x0F, 0xE0, 0x1F, 0xF0, 0x3E, 0x78, 0x78, 0x3C, 0x70, 0x1C, 0x70,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x38, 0x3C, 0x3E, 0xF8, 0x1F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x7D, 0xFF, 0x3F, 0xC7,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x3E, 0x78, 0x78, 0x3C, 0x70, 0x1C,
  0x70, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x38, 0x3C, 0x3E, 0xF8,
  0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0xFE, 0x07, 0xFC, 0x3F, 0xF1, 0xC3, 0xCE, 0x0E,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8F,
  0xFC, 0x7F, 0x83, 0xFC, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0x71, 0xC3,
  0x8E, 0x0E, 0x70, 0x73, 0x83, 0xDC, 0x0E, 0xE0, 0x78, 0x0F, 0xE3, 0xFF,
  0x7F, 0xE7, 0x02, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x78, 0x0E, 0xFB, 0xEF, 0xFC, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0x70, 0x3D, 0xC0, 0xE7, 0xCF, 0x8F, 0xFC, 0x1F, 0xE0,
  0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE1, 0xC1, 0xC3,
  0x03, 0x8E, 0x07, 0x1C, 0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x3B, 0x80,
  0x37, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xE0,
  0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xDC, 0x07, 0x00, 0xEE, 0x03, 0xC0, 0xE7,
  0x03, 0xE0, 0x73, 0x81, 0xB0, 0x39, 0xC0, 0xD8, 0x1C, 0x70, 0x6C, 0x0E,
  0x38, 0x37, 0x0E, 0x1C, 0x3B, 0x87, 0x0E, 0x1C, 0xC3, 0x83, 0x0C, 0x61,
  0xC1, 0xC6, 0x30, 0xE0, 0xE7, 0x1C, 0xE0, 0x73, 0x8E, 0x70, 0x39, 0xC3,
  0x38, 0x0C, 0xC1, 0x9C, 0x07, 0x60, 0xCE, 0x03, 0xB0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x3D, 0xC0, 0xE3, 0x83, 0x8E,
  0x1C, 0x18, 0x70, 0x71, 0x81, 0xCE, 0x03, 0xB8, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0E, 0xE0,
  0x73, 0x81, 0xCE, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x03, 0x9C, 0x0E,
  0xF0, 0x3C, 0xE0, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x38, 0x70, 0xE1,
  0xC3, 0x86, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x00, 0xDC, 0x03, 0xF0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xFF,
  0x80, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x78,
  0x03, 0xE0, 0x0D, 0xC0, 0x73, 0x01, 0x8E, 0x0E, 0x38, 0x38, 0x71, 0xC1,
  0xC7, 0x03, 0xB8, 0x0E, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE0,
  0xE0, 0xE0, 0xC0, 0xC0, 0x1F, 0x87, 0xF8, 0xC7, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x1F, 0xE7, 0xFD, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0x71, 0xEF, 0xEC, 0xF9, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0xC7, 0x7F, 0x3F,
  0x79, 0xE0, 0xEF, 0x07, 0x70, 0x3B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3B, 0xC1, 0xDE, 0x0E, 0xF8, 0xE7,
  0x7F, 0x39, 0xF0, 0x0F, 0xC7, 0xF3, 0xCC, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x3C,
  0x4F, 0xF0, 0xFC, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x0F, 0x39, 0xFD, 0xCF, 0x7E, 0xF0, 0xF7, 0x07,
  0xB8, 0x1D, 0xC0, 0xEC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x77,
  0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0F, 0x38, 0xF9, 0xFF, 0xC7, 0xE6, 0x0F,
  0x81, 0xFC, 0x38, 0xE7, 0x06, 0x70, 0x77, 0x07, 0x60, 0x76, 0x03, 0x7F,
  0xFF, 0xFF, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x31, 0xFF, 0x0F, 0xE0, 0x07, 0xC3, 0xE1, 0xF8, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x3F, 0x3F, 0xCF, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x0F, 0x18, 0xFD, 0xCF, 0x7E, 0xF0, 0xF7, 0x07, 0xB8, 0x1D,
  0xC0, 0xEC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x77, 0x03, 0xB8,
  0x1D, 0xC0, 0xEE, 0x0F, 0x38, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x60, 0xF3, 0xFF, 0x0F, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0xCE,
  0xFE, 0xFD, 0xEF, 0x0E, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x19, 0xCE, 0x70, 0x00, 0x07, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xF7, 0x80, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFE, 0x0E, 0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE,
  0x0F, 0xF0, 0xF7, 0x0F, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE7, 0x87, 0xCE, 0xFC, 0xFE, 0xFD, 0xFD, 0xEF, 0x0F,
  0x0E, 0xF0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0,
  0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E,
  0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07,
  0xE0, 0x60, 0x70, 0xE7, 0xCE, 0xFE, 0xFD, 0xEF, 0x0E, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x0F, 0xC0, 0xFF, 0x0F,
  0x3C, 0xF0, 0xE7, 0x03, 0x38, 0x1D, 0xC0, 0xEC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0E, 0xC0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x38, 0xF0,
  0xFF, 0x03, 0xF0, 0xE7, 0xC7, 0x7F, 0x3F, 0x79, 0xE0, 0xEF, 0x07, 0x70,
  0x3B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3B, 0xC1, 0xDE, 0x0E, 0xF8, 0xE7, 0x7F, 0x39, 0xF1, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F,
  0x19, 0xFD, 0xCF, 0x7E, 0xF0, 0xF7, 0x07, 0xB8, 0x1D, 0xC0, 0xEC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE,
  0x0F, 0x38, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x1F, 0x9F, 0xF7, 0x1B, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0xE3, 0xBF,
  0xEF, 0xF0, 0x30, 0x30, 0x30, 0x30, 0x7E, 0xFE, 0xFE, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x39, 0x3F,
  0x1F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF,
  0x0F, 0x71, 0xF7, 0xF7, 0x3E, 0x70, 0xE0, 0x3F, 0x01, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x38, 0x30, 0xC3, 0x87, 0x1C, 0x38, 0xE1, 0xC6, 0x06, 0x30,
  0x3B, 0x81, 0xDC, 0x0E, 0xC0, 0x36, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x01,
  0xC0, 0xE0, 0x70, 0x3B, 0x03, 0x81, 0xDC, 0x1E, 0x0C, 0xE1, 0xF0, 0xE7,
  0x0D, 0x87, 0x38, 0x6C, 0x38, 0xC3, 0x61, 0x87, 0x1B, 0x8C, 0x39, 0xDC,
  0xE1, 0xCE, 0x67, 0x06, 0x63, 0x38, 0x33, 0x19, 0x81, 0xD8, 0xEC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x70, 0x73, 0x83, 0x8E, 0x38, 0x71, 0xC1, 0xCC, 0x0E,
  0xE0, 0x37, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xDC,
  0x0E, 0xE0, 0x63, 0x87, 0x1C, 0x38, 0x63, 0x83, 0xBC, 0x1E, 0xE0, 0x3F,
  0x01, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x18, 0x30, 0xE3, 0x87, 0x1C, 0x38,
  0xE0, 0xC6, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x06, 0xC0, 0x36, 0x01, 0xF0,
  0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x07, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0,
  0xE0, 0x7F, 0xFF, 0xE0, 0x01, 0xC1, 0xF0, 0x78, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x0F, 0x83, 0xC0,
  0x7C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x7C, 0x07,
  0x07, 0x83, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0xFC, 0x3E, 0x0C, 0x00, 0x10, 0x0B, 0xF0, 0x7F, 0xFF,
  0x87, 0xF8, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 25, 8, 2, -25 },
  { 14, 9, 9, 13, 2, -25 },
  { 25, 15, 25, 16, 1, -25 },
  { 72, 13, 29, 15, 1, -27 },
  { 120, 21, 25, 23, 1, -25 },
  { 186, 16, 25, 17, 1, -25 },
  { 236, 3, 9, 7, 2, -25 },
  { 240, 7, 31, 10, 2, -25 },
  { 268, 7, 31, 10, 1, -25 },
  { 296, 12, 12, 14, 1, -27 },
  { 314, 13, 17, 15, 1, -21 },
  { 342, 5, 9, 8, 1, -4 },
  { 348, 8, 3, 10, 1, -11 },
  { 351, 4, 4, 8, 2, -4 },
  { 353, 12, 25, 13, 1, -25 },
  { 391, 13, 25, 15, 1, -25 },
  { 432, 8, 25, 15, 2, -25 },
  { 457, 12, 25, 15, 1, -25 },
  { 495, 12, 25, 15, 1, -25 },
  { 533, 14, 25, 15, 1, -25 },
  { 577, 11, 25, 15, 2, -25 },
  { 612, 12, 25, 15, 2, -25 },
  { 650, 13, 25, 15, 1, -25 },
  { 691, 13, 25, 15, 1, -25 },
  { 732, 12, 25, 15, 1, -25 },
  { 770, 4, 19, 8, 2, -19 },
  { 780, 5, 24, 8, 1, -19 },
  { 795, 13, 15, 15, 1, -20 },
  { 820, 13, 10, 15, 1, -17 },
  { 837, 13, 15, 15, 1, -20 },
  { 862, 10, 25, 11, 0, -25 },
  { 894, 19, 28, 23, 2, -25 },
  { 961, 16, 25, 16, 0, -25 },
  { 1011, 12, 25, 17, 3, -25 },
  { 1049, 13, 25, 16, 2, -25 },
  { 1090, 13, 25, 18, 3, -25 },
  { 1131, 10, 25, 14, 3, -25 },
  { 1163, 10, 25, 13, 3, -25 },
  { 1195, 15, 25, 19, 2, -25 },
  { 1242, 13, 25, 19, 3, -25 },
  { 1283, 8, 25, 10, 1, -25 },
  { 1308, 7, 32, 8, -2, -25 },
  { 1336, 13, 25, 16, 3, -25 },
  { 1377, 9, 25, 13, 3, -25 },
  { 1406, 20, 25, 25, 3, -25 },
  { 1469, 14, 25, 20, 3, -25 },
  { 1513, 16, 25, 19, 2, -25 },
  { 1563, 11, 25, 16, 3, -25 },
  { 1598, 16, 31, 19, 2, -25 },
  { 1660, 13, 25, 16, 3, -25 },
  { 1701, 12, 25, 14, 1, -25 },
  { 1739, 13, 25, 13, 0, -25 },
  { 1780, 14, 25, 18, 2, -25 },
  { 1824, 15, 25, 15, 0, -25 },
  { 1871, 25, 25, 25, 0, -25 },
  { 1950, 14, 25, 14, 0, -25 },
  { 1994, 14, 25, 14, 0, -25 },
  { 2038, 11, 25, 13, 1, -25 },
  { 2073, 7, 31, 11, 3, -25 },
  { 2101, 12, 25, 13, 1, -25 },
  { 2139, 7, 31, 11, 1, -25 },
  { 2167, 14, 13, 15, 1, -25 },
  { 2190, 15, 2, 15, 0, 3 },
  { 2194, 7, 6, 9, 1, -27 },
  { 2200, 11, 19, 15, 1, -19 },
  { 2227, 13, 27, 16, 2, -27 },
  { 2271, 10, 19, 12, 1, -19 },
  { 2295, 13, 27, 16, 1, -27 },
  { 2339, 12, 19, 15, 1, -19 },
  { 2368, 10, 27, 9, 0, -27 },
  { 2402, 13, 27, 16, 1, -19 },
  { 2446, 12, 27, 16, 2, -27 },
  { 2487, 3, 26, 7, 2, -26 },
  { 2497, 5, 34, 7, 0, -26 },
  { 2519, 12, 27, 14, 2, -27 },
  { 2560, 3, 27, 7, 2, -27 },
  { 2571, 20, 19, 24, 2, -19 },
  { 2619, 12, 19, 16, 2, -19 },
  { 2648, 13, 19, 16, 1, -19 },
  { 2679, 13, 27, 16, 2, -19 },
  { 2723, 13, 27, 16, 1, -19 },
  { 2767, 8, 19, 11, 2, -19 },
  { 2786, 10, 19, 12, 1, -19 },
  { 2810, 8, 23, 9, 1, -23 },
  { 2833, 12, 19, 16, 2, -19 },
  { 2862, 13, 19, 13, 0, -19 },
  { 2893, 21, 19, 21, 0, -19 },
  { 2943, 13, 19, 13, 0, -19 },
  { 2974, 13, 27, 13, 0, -19 },
  { 3018, 9, 19, 11, 1, -19 },
  { 3040, 10, 31, 13, 1, -25 },
  { 3079, 2, 35, 14, 6, -27 },
  { 3088, 10, 31, 13, 1, -25 },
  { 3127, 13, 5, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Regular35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR35PT7B_H_
