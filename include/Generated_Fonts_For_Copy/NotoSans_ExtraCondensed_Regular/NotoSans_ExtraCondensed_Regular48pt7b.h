#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFB, 0xC0, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x77, 0x07, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0x83,
  0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38,
  0x38, 0x03, 0x87, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C,
  0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1,
  0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFC, 0xF3, 0x0C, 0xF1,
  0x80, 0x78, 0xC0, 0x38, 0x60, 0x1C, 0x30, 0x0E, 0x18, 0x07, 0x8C, 0x03,
  0xC6, 0x00, 0xFB, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0C, 0xF8, 0x06, 0x3C, 0x03, 0x0F, 0x01, 0x87, 0x80,
  0xC3, 0xC0, 0x61, 0xE0, 0x30, 0xE8, 0x18, 0xF7, 0x0C, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x80,
  0x3F, 0x80, 0x38, 0x07, 0xBC, 0x07, 0x80, 0x71, 0xC0, 0x70, 0x0F, 0x1E,
  0x07, 0x00, 0xE0, 0xE0, 0xE0, 0x0E, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0xE0,
  0x0E, 0x0E, 0x1C, 0x00, 0xE0, 0xE1, 0xC0, 0x0E, 0x0E, 0x1C, 0x00, 0xE0,
  0xE3, 0x80, 0x0E, 0x0E, 0x38, 0x00, 0xE0, 0xE7, 0x8F, 0x8E, 0x0E, 0x71,
  0xFC, 0xF1, 0xE7, 0x3F, 0xC7, 0x1C, 0xF3, 0x8E, 0x7B, 0xCE, 0x78, 0xE3,
  0xF8, 0xE7, 0x0E, 0x3F, 0x1E, 0x70, 0xF0, 0xE1, 0xC7, 0x07, 0x00, 0x1C,
  0x70, 0x70, 0x03, 0xC7, 0x07, 0x00, 0x38, 0x70, 0x70, 0x03, 0x87, 0x07,
  0x00, 0x70, 0x70, 0x70, 0x07, 0x07, 0x07, 0x00, 0x70, 0x70, 0xF0, 0x0E,
  0x07, 0x0F, 0x00, 0xE0, 0x78, 0xE0, 0x0E, 0x03, 0x8E, 0x01, 0xC0, 0x3F,
  0xE0, 0x1C, 0x01, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xBC, 0x1E, 0x3C, 0xF8, 0x71, 0xE1, 0xE3, 0xC7, 0x83, 0xCF, 0x1E,
  0x0F, 0x3C, 0xF0, 0x1E, 0xF3, 0xC0, 0x7F, 0x8F, 0x00, 0xFE, 0x3C, 0x01,
  0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x3F, 0x07, 0xC1, 0xFE, 0x1F, 0x8F, 0xFC,
  0x3F, 0xFC, 0xF0, 0x7F, 0xE3, 0xE0, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0F,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x18, 0x70, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x3F, 0x80,
  0x77, 0x01, 0xEF, 0x07, 0x8F, 0x1F, 0x1F, 0x0C, 0x18, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3C,
  0xF3, 0xDE, 0x79, 0xE7, 0x9C, 0xF3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xE3,
  0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x7C, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE,
  0x7B, 0xDF, 0x7F, 0xCF, 0x71, 0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC,
  0x70, 0x3E, 0x60, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFC, 0xF0, 0x3E,
  0x40, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x80, 0x3E, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xDE, 0x00, 0x3B, 0xC0,
  0x0E, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80,
  0x70, 0xF0, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x1C, 0x0F, 0x03,
  0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x38, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x3E,
  0xE0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7C, 0x01, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x83, 0x03, 0xCF, 0xE1, 0xEF, 0xF8, 0xFF, 0xFE, 0x7E, 0x0F, 0x3E, 0x07,
  0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x78,
  0xF0, 0x78, 0x7C, 0x7C, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x38,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xE1, 0xF0, 0x79, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xCF, 0x87, 0xC3,
  0xE3, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3C, 0xF8, 0x3E,
  0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x3F,
  0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x41, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0x80, 0x39, 0xF7,
  0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF3, 0xCF, 0x79, 0xE7, 0x9E, 0x73, 0xCE, 0x38, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x03,
  0xFE, 0x3F, 0xFD, 0xFF, 0xE6, 0x0F, 0xA0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x78, 0xE0, 0x3F, 0x87, 0x1C, 0x1F, 0xF0, 0xE7,
  0x83, 0xDE, 0x1E, 0xE0, 0xE1, 0xC1, 0xDC, 0x3C, 0x38, 0x3B, 0x87, 0x87,
  0x07, 0x70, 0xE0, 0xE0, 0xFE, 0x1C, 0x1C, 0x1F, 0xC3, 0x83, 0x83, 0xF8,
  0x70, 0x70, 0x7E, 0x0E, 0x0E, 0x0F, 0xC1, 0xC3, 0xC1, 0xFC, 0x38, 0x78,
  0x3F, 0x87, 0x0F, 0x0F, 0xF0, 0xE1, 0xE1, 0xCE, 0x1E, 0x3C, 0x39, 0xC1,
  0xFD, 0xDF, 0x38, 0x3F, 0x9F, 0xC7, 0x03, 0xE3, 0xF0, 0xF0, 0x18, 0x08,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x40, 0x03, 0xE0, 0x18, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x78, 0x00,
  0x1D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x3C, 0x00, 0x38,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0x80,
  0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF8,
  0x00, 0x7B, 0xC0, 0x01, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8,
  0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x07,
  0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0x81, 0xFB,
  0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03,
  0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0x81, 0x87, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x86, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7C, 0x3F, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0xF9, 0xF0, 0x3E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xC0, 0x70, 0x7E, 0x00, 0x41, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFD,
  0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0x7C, 0x00,
  0xF1, 0xF8, 0x03, 0xC3, 0xF8, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3C,
  0xFF, 0xFF, 0xF7, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE3, 0xFE, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x3F, 0x3F, 0xFF, 0x7F, 0x3F, 0x00, 0xF8, 0x07, 0xDF, 0x00,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9E, 0x01, 0xF7, 0xC0, 0x3E, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x78, 0x0F, 0x8F, 0x01, 0xF0, 0xF0,
  0x3E, 0x1E, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC3, 0xE0, 0x78,
  0x7C, 0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xE7, 0xC0, 0x3C,
  0xF8, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xF7, 0x00, 0x0F, 0xFF, 0x70, 0x00, 0xFF, 0xF7, 0x80, 0x0E,
  0xFF, 0x78, 0x00, 0xEF, 0xF3, 0x80, 0x1E, 0xFF, 0x3C, 0x01, 0xCF, 0xF3,
  0xC0, 0x1C, 0xFF, 0x1C, 0x03, 0xCF, 0xF1, 0xC0, 0x3C, 0xFF, 0x1E, 0x03,
  0x8F, 0xF1, 0xE0, 0x38, 0xFF, 0x0E, 0x07, 0x8F, 0xF0, 0xF0, 0x70, 0xFF,
  0x0F, 0x07, 0x0F, 0xF0, 0x70, 0xF0, 0xFF, 0x07, 0x0F, 0x0F, 0xF0, 0x78,
  0xE0, 0xFF, 0x07, 0x8E, 0x0F, 0xF0, 0x39, 0xE0, 0xFF, 0x03, 0xDC, 0x0F,
  0xF0, 0x3D, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01,
  0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFE, 0xF0,
  0x0F, 0xF7, 0x80, 0x7F, 0x9E, 0x03, 0xFC, 0xF0, 0x1F, 0xE3, 0x80, 0xFF,
  0x1E, 0x07, 0xF8, 0xF0, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0x78,
  0x7F, 0x83, 0xC3, 0xFC, 0x1E, 0x1F, 0xE0, 0x78, 0xFF, 0x03, 0xC7, 0xF8,
  0x0F, 0x3F, 0xC0, 0x79, 0xFE, 0x01, 0xEF, 0xF0, 0x0F, 0x7F, 0x80, 0x7B,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0x83, 0xE0,
  0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3E, 0x7C, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x07,
  0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1E, 0x03,
  0xF1, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0x1F, 0xCF, 0x81, 0xF7, 0xC0, 0x7B,
  0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x3E, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0x83, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3E, 0x7C, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7,
  0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xF0,
  0x1F, 0x03, 0xF1, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x7F, 0x0F, 0x81, 0xF1, 0xF0,
  0x1E, 0x3E, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xE0,
  0x1E, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC1,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x8F,
  0x01, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07,
  0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x01,
  0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0xDF, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xFE,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7E, 0x0E, 0x78, 0x02, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x80, 0x3E, 0xF8, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0xC7,
  0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3E, 0x00, 0x78,
  0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80,
  0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xDE, 0x00, 0x7C, 0x00, 0xF7, 0x80,
  0x1F, 0x00, 0x3D, 0xE0, 0x07, 0xC0, 0x0F, 0x78, 0x03, 0xF0, 0x07, 0x9E,
  0x00, 0xFC, 0x01, 0xE3, 0xC0, 0x3F, 0x80, 0x78, 0xF0, 0x0E, 0xE0, 0x1E,
  0x3C, 0x03, 0xB8, 0x07, 0x8F, 0x01, 0xEE, 0x03, 0xC3, 0xC0, 0x7B, 0x80,
  0xF0, 0x78, 0x1C, 0xF0, 0x3C, 0x1E, 0x07, 0x3C, 0x0F, 0x07, 0x81, 0xCF,
  0x07, 0xC1, 0xE0, 0xF1, 0xC1, 0xE0, 0x78, 0x3C, 0x70, 0x78, 0x0F, 0x0E,
  0x1E, 0x1E, 0x03, 0xC3, 0x87, 0x87, 0x80, 0xF0, 0xE1, 0xE3, 0xE0, 0x3C,
  0x78, 0x38, 0xF0, 0x0F, 0x1E, 0x0E, 0x3C, 0x01, 0xE7, 0x03, 0xCF, 0x00,
  0x79, 0xC0, 0xF3, 0xC0, 0x1E, 0x70, 0x3C, 0xF0, 0x07, 0xBC, 0x07, 0x78,
  0x00, 0xEF, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x77, 0x80, 0x0F, 0xE0, 0x1D,
  0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x07, 0x1E,
  0x00, 0xF3, 0xC0, 0x1E, 0x70, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x01, 0xE7, 0x00, 0x38, 0xF0,
  0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7C,
  0xF0, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3B, 0xC0, 0x07, 0xBC, 0x00, 0x71, 0xC0, 0x0F,
  0x1E, 0x00, 0xE0, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x70, 0x3C, 0x07, 0x83,
  0xC0, 0x38, 0x78, 0x03, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF1, 0xC3,
  0xE2, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x01, 0xF8, 0x7F, 0xF3, 0xFF, 0xEF, 0xE3, 0xDE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x1F,
  0xBF, 0xF7, 0x7F, 0xCE, 0x7F, 0x1C, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x7E, 0x1E, 0x7F, 0x8F, 0x7F, 0xE7, 0xF1, 0xF3,
  0xF0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3D,
  0xF8, 0x1E, 0xFE, 0x1F, 0x7B, 0xFF, 0x3D, 0xFF, 0x1C, 0x7F, 0x00, 0x07,
  0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0x86, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x8F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC3, 0xF1, 0xE3, 0xFE, 0xF3, 0xFF,
  0xF9, 0xF1, 0xFD, 0xF0, 0x7E, 0xF0, 0x1F, 0x78, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0xC0,
  0x3D, 0xE0, 0x3E, 0xF8, 0x1F, 0x3C, 0x1F, 0x9F, 0xFD, 0xC7, 0xFC, 0xE1,
  0xFC, 0x70, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3C, 0x3C, 0x1E,
  0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x01, 0x3E, 0x06,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F,
  0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3F, 0xEF, 0xFF, 0x7F, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xC3, 0x8F, 0xF9, 0xCF,
  0xFC, 0xE7, 0xC7, 0xF7, 0xC1, 0xFB, 0xC0, 0x7D, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x7E, 0x7F, 0xFF, 0x1F, 0xF7,
  0x87, 0xF3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x40, 0x0F, 0x38, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF1, 0xF8, 0xF7, 0xFC, 0xF7, 0xFE, 0xFE, 0x3E, 0xFC, 0x1E, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x0F,
  0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE, 0xFE, 0xFC, 0x20, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF3,
  0xC0, 0xF7, 0x80, 0xF7, 0xC0, 0xFF, 0xC0, 0xFD, 0xE0, 0xFD, 0xE0, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0x1C, 0xFF, 0x9F, 0xF3, 0xFF, 0xF3,
  0xFF, 0x7F, 0x3F, 0xE3, 0xEF, 0xC1, 0xF8, 0x3D, 0xF0, 0x3E, 0x07, 0xBE,
  0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xC0,
  0x3F, 0xC0, 0x78, 0x07, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xE0,
  0x3C, 0x03, 0xFC, 0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x1E, 0x01,
  0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x07, 0xF8, 0x0F, 0x00, 0xFF, 0x01,
  0xE0, 0x1F, 0xE0, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F,
  0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x3C, 0xE1, 0xF8, 0xE7, 0xFC, 0xF7,
  0xFE, 0xFE, 0x3E, 0xFC, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x07,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC7, 0xC7, 0xC0, 0xF3, 0xC0, 0x79,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xDC, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF3, 0xE0, 0x78, 0xF8, 0x78,
  0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xE1, 0xF8, 0x71, 0xFE, 0x3D,
  0xFF, 0x9F, 0xC7, 0xCF, 0xC0, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xF7, 0xE0, 0x7B, 0xF8, 0x7D, 0xEF, 0xFC, 0xF7, 0xFC,
  0x79, 0xFC, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC3, 0x8F, 0xF9, 0xCF, 0xFC, 0xE7, 0xC7,
  0xF7, 0xC1, 0xFB, 0xC0, 0x7D, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0xFB, 0xE0, 0x7C, 0xF8, 0x7E, 0x7F, 0xFF, 0x1F, 0xF7, 0x87, 0xF3, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0xE1, 0xFC, 0x7F, 0x9F, 0xFF, 0xFF, 0xE1, 0xF8, 0x3E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x00, 0x1F, 0xE1, 0xFF, 0xDF, 0xFD, 0xF0, 0xEF, 0x01, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x7B, 0x07, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x00, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0xF7, 0xFE, 0xFF, 0xC7, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x3F, 0xC7, 0xF8, 0x7F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0x7C, 0x7F, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xC7, 0xF0, 0x03, 0xDC, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x0E, 0x03, 0xC3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x0E, 0x07, 0x07, 0x81, 0xC1, 0xE0, 0x78, 0x78, 0x1E,
  0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x01, 0xCE,
  0x00, 0x77, 0x80, 0x1D, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x80, 0x7B, 0xC0,
  0x7C, 0x03, 0x9E, 0x03, 0xE0, 0x3C, 0xF0, 0x1F, 0x01, 0xE7, 0x81, 0xFC,
  0x0F, 0x1C, 0x0E, 0xE0, 0x70, 0xF0, 0x77, 0x07, 0x87, 0x83, 0xB8, 0x3C,
  0x3C, 0x1D, 0xC1, 0xE1, 0xE1, 0xEF, 0x0F, 0x07, 0x0F, 0x78, 0x70, 0x3C,
  0x71, 0xC7, 0x81, 0xE3, 0x8E, 0x3C, 0x0F, 0x1C, 0x71, 0xE0, 0x79, 0xE3,
  0xCE, 0x01, 0xCF, 0x1E, 0x70, 0x0F, 0x70, 0x77, 0x80, 0x7B, 0x83, 0xBC,
  0x03, 0xDC, 0x1D, 0xE0, 0x0E, 0xE0, 0xEE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x0E, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0E, 0x07, 0x07, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0x77, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xFE,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0xC1, 0xFC, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0xF8, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xF0, 0x07, 0x80, 0xFC, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x5F, 0xF0, 0x1F, 0xFF, 0x1F, 0xCF, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 34, 11, 3, -34 },
  { 23, 12, 12, 18, 3, -34 },
  { 41, 20, 34, 22, 1, -34 },
  { 126, 17, 39, 21, 2, -36 },
  { 209, 28, 35, 32, 2, -35 },
  { 332, 22, 35, 23, 1, -35 },
  { 429, 4, 12, 10, 3, -34 },
  { 435, 11, 43, 14, 2, -35 },
  { 495, 11, 43, 14, 1, -35 },
  { 555, 15, 16, 19, 2, -37 },
  { 585, 18, 22, 21, 1, -28 },
  { 635, 6, 11, 11, 2, -5 },
  { 644, 11, 4, 13, 1, -15 },
  { 650, 5, 6, 11, 3, -6 },
  { 654, 16, 34, 18, 1, -34 },
  { 722, 17, 35, 21, 2, -35 },
  { 797, 11, 34, 21, 3, -34 },
  { 844, 16, 35, 21, 2, -35 },
  { 914, 16, 35, 21, 2, -35 },
  { 984, 19, 35, 21, 1, -35 },
  { 1068, 16, 34, 21, 2, -34 },
  { 1136, 17, 35, 21, 2, -35 },
  { 1211, 18, 34, 21, 1, -34 },
  { 1288, 17, 35, 21, 2, -35 },
  { 1363, 16, 35, 21, 2, -35 },
  { 1433, 5, 26, 11, 3, -26 },
  { 1450, 6, 32, 11, 2, -26 },
  { 1474, 18, 22, 21, 1, -28 },
  { 1524, 18, 14, 21, 1, -24 },
  { 1556, 18, 22, 21, 1, -28 },
  { 1606, 13, 35, 15, 1, -35 },
  { 1663, 27, 39, 31, 2, -35 },
  { 1795, 22, 34, 22, 0, -34 },
  { 1889, 18, 34, 23, 3, -34 },
  { 1966, 18, 35, 21, 2, -35 },
  { 2045, 19, 34, 25, 3, -34 },
  { 2126, 14, 34, 19, 3, -34 },
  { 2186, 14, 34, 18, 3, -34 },
  { 2246, 22, 35, 26, 2, -35 },
  { 2343, 19, 34, 26, 3, -34 },
  { 2424, 10, 34, 14, 2, -34 },
  { 2467, 9, 43, 11, -2, -34 },
  { 2516, 19, 34, 21, 3, -34 },
  { 2597, 14, 34, 18, 3, -34 },
  { 2657, 28, 34, 34, 3, -34 },
  { 2776, 21, 34, 27, 3, -34 },
  { 2866, 22, 35, 26, 2, -35 },
  { 2963, 17, 34, 21, 3, -34 },
  { 3036, 22, 43, 26, 2, -35 },
  { 3155, 19, 34, 22, 3, -34 },
  { 3236, 16, 35, 20, 2, -35 },
  { 3306, 18, 34, 18, 0, -34 },
  { 3383, 19, 34, 25, 3, -34 },
  { 3464, 21, 34, 21, 0, -34 },
  { 3554, 34, 34, 35, 0, -34 },
  { 3699, 19, 34, 19, 0, -34 },
  { 3780, 19, 34, 19, 0, -34 },
  { 3861, 15, 34, 17, 1, -34 },
  { 3925, 10, 43, 15, 3, -35 },
  { 3979, 16, 34, 18, 1, -34 },
  { 4047, 11, 43, 15, 1, -35 },
  { 4107, 20, 18, 21, 1, -34 },
  { 4152, 21, 3, 21, 0, 4 },
  { 4160, 9, 8, 13, 2, -37 },
  { 4169, 15, 26, 20, 2, -26 },
  { 4218, 17, 36, 22, 3, -36 },
  { 4295, 14, 26, 17, 2, -26 },
  { 4341, 17, 36, 22, 2, -36 },
  { 4418, 16, 26, 20, 2, -26 },
  { 4470, 13, 37, 12, 0, -37 },
  { 4531, 17, 38, 22, 2, -26 },
  { 4612, 16, 36, 22, 3, -36 },
  { 4684, 4, 35, 10, 3, -35 },
  { 4702, 8, 47, 10, -1, -35 },
  { 4749, 16, 36, 19, 3, -36 },
  { 4821, 4, 36, 10, 3, -36 },
  { 4839, 27, 26, 33, 3, -26 },
  { 4927, 16, 26, 22, 3, -26 },
  { 4979, 17, 26, 21, 2, -26 },
  { 5035, 17, 38, 22, 3, -26 },
  { 5116, 17, 38, 22, 2, -26 },
  { 5197, 11, 26, 15, 3, -26 },
  { 5233, 13, 26, 16, 2, -26 },
  { 5276, 11, 32, 12, 1, -32 },
  { 5320, 16, 26, 22, 3, -26 },
  { 5372, 18, 26, 18, 0, -26 },
  { 5431, 29, 26, 29, 0, -26 },
  { 5526, 16, 26, 18, 1, -26 },
  { 5578, 18, 38, 18, 0, -26 },
  { 5664, 13, 26, 15, 1, -26 },
  { 5707, 13, 42, 17, 2, -34 },
  { 5776, 4, 48, 19, 8, -37 },
  { 5800, 13, 42, 17, 2, -34 },
  { 5869, 18, 6, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Regular48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR48PT7B_H_
