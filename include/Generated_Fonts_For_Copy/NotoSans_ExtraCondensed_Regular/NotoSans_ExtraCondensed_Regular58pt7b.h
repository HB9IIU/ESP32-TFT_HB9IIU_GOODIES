#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x00, 0x00, 0x07, 0xBE, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x78,
  0x3C, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0F, 0x00,
  0x0E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x70, 0x3C, 0x00, 0x38, 0x1E,
  0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x81,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70,
  0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xF3, 0x87, 0x1F, 0x1C, 0x08, 0xF0, 0xE0, 0x0F, 0x87, 0x00, 0x7C, 0x38,
  0x03, 0xE1, 0xC0, 0x1F, 0x0E, 0x00, 0xF8, 0x70, 0x03, 0xC3, 0x80, 0x1F,
  0x1C, 0x00, 0x7E, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1D, 0xF8, 0x00,
  0xE3, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x7C, 0x01, 0xC3, 0xE0, 0x0E, 0x1F,
  0x00, 0x70, 0xF8, 0x03, 0x87, 0x80, 0x1C, 0x3D, 0x80, 0xE3, 0xEF, 0x87,
  0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xF0,
  0x03, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0x78, 0x07,
  0x80, 0x1E, 0x1E, 0x01, 0xE0, 0x07, 0x87, 0x80, 0xF0, 0x01, 0xE0, 0xE0,
  0x3C, 0x00, 0x70, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x07, 0x80, 0x0F, 0x03,
  0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x3C,
  0x0F, 0x0F, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x03, 0xC0, 0xF1, 0xE0, 0x00,
  0xF0, 0x3C, 0x78, 0x00, 0x1C, 0x0F, 0x1C, 0x3F, 0x87, 0x83, 0x8F, 0x1F,
  0xF1, 0xE1, 0xE3, 0xC7, 0xFC, 0x78, 0x78, 0xE3, 0xCF, 0x8E, 0x1E, 0x78,
  0xF1, 0xE3, 0xFF, 0x1E, 0x78, 0x38, 0x7F, 0x8F, 0x1E, 0x0F, 0x1F, 0xE3,
  0xC7, 0x83, 0xC1, 0xE0, 0xF1, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x3C, 0x00,
  0x1E, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x83,
  0xC0, 0x07, 0x81, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x3C, 0x00, 0xF0, 0x1E,
  0x0F, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x0E, 0x00, 0xF1, 0xE0, 0x07, 0x80,
  0x3C, 0x78, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x3C,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xF0, 0xF9, 0xF0,
  0x7C, 0x7E, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xCF, 0x81, 0xF1, 0xF3, 0xE0,
  0x7C, 0x78, 0xF8, 0x0F, 0xBE, 0x3E, 0x03, 0xEF, 0x8F, 0x80, 0x7F, 0xC3,
  0xE0, 0x0F, 0xF0, 0xF8, 0x03, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x83, 0xE0, 0x0F, 0xE0, 0xFC, 0x07, 0xFC, 0x1F, 0x83, 0xFF, 0x87, 0xFF,
  0xFB, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0xFE, 0x1F, 0x83, 0xFE, 0x03, 0xF0,
  0x08, 0x00, 0x00, 0xFF, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x80, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x81, 0xC0, 0x9E, 0x38, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xC7,
  0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xE0, 0x10, 0x10, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0x1F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xF9, 0xFF,
  0xFF, 0xEF, 0x9F, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xDF, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7,
  0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE7,
  0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3F, 0x07, 0xC1, 0xF0, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEF, 0xDF, 0xFC, 0xFF, 0xC7, 0xDC, 0x3E, 0x41, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xFF,
  0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x3F, 0xC7, 0x80, 0xFC, 0x30,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFE, 0x1F, 0xC7, 0x80, 0x7E, 0x20, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x80,
  0x07, 0xEE, 0x00, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF,
  0x80, 0x07, 0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8,
  0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0,
  0x1F, 0x0F, 0x00, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC2, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x40, 0x07, 0xEE, 0x01, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xF1, 0x81, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0xFC, 0x0F, 0x3F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xF8,
  0xFF, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF8, 0x01, 0xFF, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0xFE, 0x1F,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8,
  0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF3,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0x03, 0xEF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F,
  0x01, 0xF8, 0xFF, 0x7F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0x9F, 0x83, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x7C,
  0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0xFF, 0x9F, 0x01, 0xE1, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x7C, 0xF9, 0xFF, 0xF7, 0xEF, 0x8F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xF9, 0xFF, 0xF7, 0xEF, 0xDF, 0x08, 0x3E, 0x3E, 0x3F, 0x7F, 0x3F,
  0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x78, 0xFE, 0x60,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x3C, 0x07, 0xFE, 0x1E, 0x78, 0x0F, 0xFE, 0x1E, 0x78,
  0x1F, 0xFE, 0x0E, 0x78, 0x3E, 0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0x0F, 0xF0,
  0x3C, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x3E, 0x0F, 0xF0,
  0x78, 0x3E, 0x0F, 0xF0, 0x78, 0x3E, 0x0F, 0xF0, 0x78, 0x3E, 0x0F, 0xF0,
  0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x3C, 0x0F, 0xF0,
  0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x3C, 0x0E, 0xF0,
  0x78, 0x7C, 0x1E, 0xF0, 0x78, 0x7E, 0x1E, 0xF0, 0x3C, 0xEF, 0x3C, 0xF0,
  0x3F, 0xE7, 0xFC, 0x78, 0x1F, 0xC7, 0xF8, 0x78, 0x0F, 0xC3, 0xF0, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0x80, 0x7F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x7C, 0x1F, 0xF3, 0xE0,
  0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF,
  0x80, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0x8F, 0x07, 0xE0, 0x08, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x18, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0xFE, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0,
  0x3F, 0x0F, 0x83, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xE7, 0xF0, 0x7F, 0x00, 0x38, 0x7F, 0x00, 0x04, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00,
  0x1E, 0xFC, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0xC0,
  0x01, 0xE3, 0xF0, 0x00, 0xF1, 0xFC, 0x00, 0x78, 0x7F, 0x80, 0x7C, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xE8, 0x7E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0x9F, 0x00, 0xFC, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFC,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xDF, 0xFF, 0xC0, 0x00, 0xF7, 0xFE, 0xF0, 0x00, 0x3D,
  0xFF, 0xBC, 0x00, 0x1F, 0x7F, 0xEF, 0x80, 0x07, 0x9F, 0xF9, 0xE0, 0x01,
  0xE7, 0xFE, 0x78, 0x00, 0x79, 0xFF, 0x9E, 0x00, 0x3E, 0x7F, 0xE7, 0xC0,
  0x0F, 0x1F, 0xF8, 0xF0, 0x03, 0xC7, 0xFE, 0x3C, 0x01, 0xF1, 0xFF, 0x8F,
  0x80, 0x78, 0x7F, 0xE1, 0xE0, 0x1E, 0x1F, 0xF8, 0x78, 0x07, 0x87, 0xFE,
  0x1E, 0x03, 0xE1, 0xFF, 0x87, 0xC0, 0xF0, 0x7F, 0xE0, 0xF0, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1F, 0x07, 0xFE, 0x0F, 0x87, 0x81, 0xFF, 0x81, 0xE1, 0xE0,
  0x7F, 0xE0, 0x78, 0x78, 0x1F, 0xF8, 0x1E, 0x3E, 0x07, 0xFE, 0x07, 0xCF,
  0x01, 0xFF, 0x80, 0xF3, 0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFD, 0xE0, 0x07, 0xFE, 0xF8, 0x03, 0xFF,
  0x3C, 0x01, 0xFF, 0x9F, 0x00, 0xFF, 0xCF, 0x80, 0x7F, 0xE3, 0xE0, 0x3F,
  0xF1, 0xF0, 0x1F, 0xF8, 0x78, 0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F, 0x03,
  0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC0, 0xF0, 0x7F, 0xE0, 0x7C,
  0x3F, 0xF0, 0x1E, 0x1F, 0xF8, 0x0F, 0x8F, 0xFC, 0x07, 0xC7, 0xFE, 0x01,
  0xF3, 0xFF, 0x00, 0xF9, 0xFF, 0x80, 0x3C, 0xFF, 0xC0, 0x1F, 0x7F, 0xE0,
  0x07, 0xBF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFB, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xF8, 0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFC,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0xFC, 0x3E, 0x1F, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x0C, 0x7E, 0x00,
  0x47, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0xC0, 0x07, 0xEF, 0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x3F, 0x03, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00,
  0x1F, 0x3C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x9F, 0x00, 0x1F, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x0F,
  0x80, 0x1D, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x78, 0x03, 0xE0, 0x7C, 0x03,
  0xCF, 0x00, 0xF8, 0x1F, 0x00, 0xF3, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xCF, 0x01, 0xF0,
  0x0F, 0x01, 0xE3, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x78, 0x1F, 0x00, 0xF8,
  0x1E, 0x1E, 0x07, 0xC0, 0x3E, 0x07, 0x87, 0x81, 0xE0, 0x07, 0x83, 0xE1,
  0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x0F, 0x0F,
  0x80, 0x1F, 0x0F, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x00,
  0xF1, 0xF0, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x0F, 0x9F, 0x00, 0x0F, 0x9E,
  0x01, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x79, 0xF0, 0x00, 0xF9, 0xE0, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0x07, 0xBC, 0x01, 0xEF, 0x80,
  0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xDF, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x3C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xE7, 0x80,
  0x03, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x83, 0xE0,
  0x0F, 0x81, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF8,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0x1F, 0x86, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1F,
  0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xC0, 0xF7, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFD, 0xF0, 0x3F, 0x7E, 0x3F, 0xDF, 0xFE,
  0xF3, 0xFF, 0x1C, 0x7F, 0x87, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x38, 0x0F, 0x1F, 0xE0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC,
  0xF7, 0xDF, 0xCF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xE0, 0x7E,
  0xF7, 0xFF, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF, 0x8F, 0x0F, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x7C, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xFE, 0xF0,
  0xF8, 0x08, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x11, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0E, 0x0F, 0x83, 0xFC,
  0x7C, 0x3F, 0xFB, 0xE3, 0xFF, 0xFF, 0x1F, 0xDF, 0x79, 0xF8, 0x1F, 0xCF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00, 0x1F,
  0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0x1F, 0xDF, 0x78,
  0xFF, 0xF3, 0xC3, 0xFF, 0x9E, 0x07, 0xF0, 0xF0, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0x8F, 0xC3,
  0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E,
  0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x21, 0xF0, 0x06, 0x1F, 0xE7, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x01, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xFF,
  0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFC, 0xF1, 0xFD, 0xF7, 0x9F, 0x81,
  0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF0,
  0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0x80, 0xFE, 0x7E, 0x07, 0xF1, 0xFF,
  0xF7, 0x8F, 0xFF, 0x7C, 0x3F, 0xF3, 0xE0, 0xFF, 0x1F, 0x00, 0x40, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x30, 0x03, 0xE1, 0xF0, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x07, 0x81, 0xE3, 0xFE, 0x3C, 0xFF, 0xE7, 0xBF, 0xFC,
  0xF7, 0xFF, 0xDF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x39, 0xEF, 0xFF, 0x7D, 0xE3,
  0x80, 0x00, 0x00, 0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x03, 0x81, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x9F, 0xBF, 0xEF,
  0xF3, 0xF8, 0xF8, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0xBC, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0,
  0xF8, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0x8F,
  0x80, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xDF, 0xC0, 0x7B, 0xF8, 0x0F, 0xFF,
  0x01, 0xFD, 0xF0, 0x3F, 0x3E, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x03,
  0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x01, 0xE0, 0xF1, 0xFE, 0x0F, 0xF8, 0xF3, 0xFF, 0x1F, 0xFC, 0xF7,
  0xFF, 0x9F, 0xFC, 0xF7, 0xBF, 0xBF, 0xFE, 0xFE, 0x0F, 0xF0, 0x3E, 0xFC,
  0x07, 0xF0, 0x3E, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8,
  0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0,
  0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0,
  0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0,
  0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0,
  0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0,
  0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0,
  0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x1E, 0x3F, 0xC3,
  0xCF, 0xFE, 0x7B, 0xFF, 0xCF, 0x7F, 0xFD, 0xFC, 0x0F, 0xBF, 0x01, 0xF7,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x00,
  0x70, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFC, 0xFE,
  0x1F, 0x81, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x00, 0xF3, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x07,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x78, 0x0F, 0x1F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC,
  0xF7, 0x9F, 0xCF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xE0, 0x7E,
  0xF7, 0xFF, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF, 0x8F, 0x0F, 0xE0, 0xF0, 0x10,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFC, 0xF1, 0xFD, 0xF7, 0x9F, 0x81,
  0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF0,
  0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0x80, 0xFE, 0x7E, 0x07, 0xF1, 0xFF,
  0xF7, 0x8F, 0xFF, 0x7C, 0x3F, 0xF3, 0xE0, 0xFF, 0x1F, 0x00, 0x60, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x77,
  0x8F, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xFB, 0xC7, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E, 0x3E,
  0xF8, 0x04, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x03, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0x9E, 0x7F, 0xE3, 0xC7,
  0xF8, 0x78, 0x0C, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3C, 0x3E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0x81,
  0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x7C, 0xF0, 0x01,
  0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xEF, 0x80,
  0x7F, 0x00, 0xFB, 0xE0, 0x1F, 0xC0, 0x3E, 0x78, 0x07, 0xF0, 0x0F, 0x9E,
  0x01, 0xFC, 0x03, 0xC7, 0xC0, 0x77, 0x80, 0xF1, 0xF0, 0x3D, 0xE0, 0x7C,
  0x7C, 0x0F, 0x78, 0x1F, 0x0F, 0x03, 0xDE, 0x07, 0x83, 0xC0, 0xF7, 0x81,
  0xE0, 0xF8, 0x3C, 0xF0, 0x78, 0x3E, 0x1E, 0x3C, 0x3E, 0x0F, 0x87, 0x8F,
  0x0F, 0x81, 0xE1, 0xE3, 0xC3, 0xC0, 0x78, 0x78, 0xF0, 0xF0, 0x1F, 0x1E,
  0x3E, 0x3C, 0x07, 0xCF, 0x07, 0x9F, 0x00, 0xF3, 0xC1, 0xE7, 0x80, 0x3C,
  0xF0, 0x79, 0xE0, 0x0F, 0x3C, 0x1E, 0x78, 0x03, 0xCF, 0x07, 0x9E, 0x00,
  0xFB, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x9F,
  0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xBE, 0x00, 0xF9, 0xF0, 0x0F, 0x1F, 0x01,
  0xF0, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0x3E, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x4F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFA, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 42, 14, 4, -41 },
  { 33, 16, 15, 22, 3, -41 },
  { 63, 25, 41, 27, 1, -41 },
  { 192, 21, 47, 25, 2, -44 },
  { 316, 34, 43, 39, 2, -42 },
  { 499, 26, 43, 28, 2, -42 },
  { 639, 6, 15, 12, 3, -41 },
  { 651, 12, 51, 17, 3, -42 },
  { 728, 12, 51, 17, 2, -42 },
  { 805, 19, 19, 23, 2, -44 },
  { 851, 21, 27, 25, 2, -34 },
  { 922, 8, 15, 13, 2, -7 },
  { 937, 12, 5, 16, 2, -18 },
  { 945, 7, 8, 13, 3, -7 },
  { 952, 20, 42, 22, 1, -42 },
  { 1057, 20, 43, 25, 2, -42 },
  { 1165, 13, 41, 25, 4, -41 },
  { 1232, 20, 42, 25, 2, -42 },
  { 1337, 20, 43, 25, 2, -42 },
  { 1445, 23, 42, 25, 1, -42 },
  { 1566, 19, 42, 25, 3, -41 },
  { 1666, 20, 43, 25, 3, -42 },
  { 1774, 21, 41, 25, 2, -41 },
  { 1882, 21, 43, 25, 2, -42 },
  { 1995, 20, 43, 25, 2, -42 },
  { 2103, 7, 32, 13, 3, -31 },
  { 2131, 8, 39, 13, 2, -31 },
  { 2170, 21, 26, 25, 2, -34 },
  { 2239, 21, 17, 25, 2, -29 },
  { 2284, 21, 26, 25, 2, -34 },
  { 2353, 16, 43, 18, 1, -42 },
  { 2439, 32, 47, 38, 3, -42 },
  { 2627, 26, 41, 26, 0, -41 },
  { 2761, 21, 41, 28, 4, -41 },
  { 2869, 21, 43, 26, 3, -42 },
  { 2982, 23, 41, 30, 4, -41 },
  { 3100, 17, 41, 23, 4, -41 },
  { 3188, 17, 41, 22, 4, -41 },
  { 3276, 25, 43, 32, 3, -42 },
  { 3411, 23, 41, 31, 4, -41 },
  { 3529, 12, 41, 16, 2, -41 },
  { 3591, 12, 52, 13, -3, -41 },
  { 3669, 22, 41, 26, 4, -41 },
  { 3782, 17, 41, 22, 4, -41 },
  { 3870, 34, 41, 42, 4, -41 },
  { 4045, 25, 41, 33, 4, -41 },
  { 4174, 26, 43, 32, 3, -42 },
  { 4314, 20, 41, 26, 4, -41 },
  { 4417, 26, 52, 32, 3, -42 },
  { 4586, 22, 41, 27, 4, -41 },
  { 4699, 20, 43, 24, 2, -42 },
  { 4807, 20, 41, 22, 1, -41 },
  { 4910, 22, 42, 30, 4, -41 },
  { 5026, 26, 41, 26, 0, -41 },
  { 5160, 42, 41, 42, 0, -41 },
  { 5376, 23, 41, 23, 0, -41 },
  { 5494, 23, 41, 23, 0, -41 },
  { 5612, 18, 41, 21, 2, -41 },
  { 5705, 12, 51, 18, 4, -42 },
  { 5782, 20, 42, 22, 1, -42 },
  { 5887, 12, 51, 18, 2, -42 },
  { 5964, 24, 22, 26, 1, -41 },
  { 6030, 25, 3, 25, 0, 5 },
  { 6040, 11, 9, 15, 2, -44 },
  { 6053, 18, 33, 24, 2, -32 },
  { 6128, 20, 45, 27, 4, -44 },
  { 6241, 17, 33, 20, 2, -32 },
  { 6312, 21, 45, 27, 2, -44 },
  { 6431, 20, 33, 24, 2, -32 },
  { 6514, 15, 44, 15, 1, -44 },
  { 6597, 21, 46, 27, 2, -32 },
  { 6718, 19, 44, 26, 4, -44 },
  { 6823, 6, 43, 12, 3, -43 },
  { 6856, 10, 57, 12, -1, -43 },
  { 6928, 19, 44, 23, 4, -44 },
  { 7033, 4, 44, 12, 4, -44 },
  { 7055, 32, 32, 40, 4, -32 },
  { 7183, 19, 32, 26, 4, -32 },
  { 7259, 21, 33, 26, 2, -32 },
  { 7346, 20, 46, 27, 4, -32 },
  { 7461, 21, 46, 27, 2, -32 },
  { 7582, 13, 32, 18, 4, -32 },
  { 7634, 16, 33, 20, 2, -32 },
  { 7700, 13, 39, 15, 1, -38 },
  { 7764, 19, 32, 26, 4, -31 },
  { 7840, 21, 31, 21, 0, -31 },
  { 7922, 34, 31, 35, 1, -31 },
  { 8054, 20, 31, 22, 1, -31 },
  { 8132, 21, 45, 21, 0, -31 },
  { 8251, 15, 31, 18, 1, -31 },
  { 8310, 17, 51, 21, 2, -42 },
  { 8419, 4, 58, 23, 10, -44 },
  { 8448, 17, 51, 21, 2, -42 },
  { 8557, 21, 7, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Regular58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR58PT7B_H_
