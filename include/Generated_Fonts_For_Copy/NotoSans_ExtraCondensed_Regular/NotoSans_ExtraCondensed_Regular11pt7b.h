#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x32, 0xBE, 0xA5, 0x7D, 0x4C, 0x27, 0xA6, 0x33,
  0xB6, 0x20, 0x69, 0x52, 0xA5, 0xA7, 0xA3, 0x4A, 0x93, 0x62, 0x94, 0xC6,
  0xCE, 0x4D, 0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x12, 0x4A, 0x50, 0x2F, 0x70,
  0x22, 0xF2, 0x20, 0x70, 0xE0, 0x80, 0x11, 0x22, 0x44, 0x48, 0x65, 0x99,
  0x99, 0x57, 0x75, 0x55, 0xE1, 0x11, 0x22, 0x4F, 0xF1, 0x16, 0x31, 0x1F,
  0x11, 0x94, 0xA5, 0x7C, 0x42, 0xF2, 0x62, 0x4F, 0x34, 0x4B, 0xD9, 0x57,
  0xF1, 0x12, 0x22, 0x44, 0x75, 0x56, 0x59, 0x97, 0x65, 0x99, 0x71, 0x16,
  0x84, 0x40, 0x1C, 0x16, 0xC3, 0x10, 0xF0, 0xF0, 0xC3, 0x34, 0x80, 0xE4,
  0x94, 0x82, 0x72, 0x2B, 0x75, 0xD7, 0x5A, 0xA0, 0x70, 0x23, 0x14, 0xA5,
  0x3A, 0x31, 0xE9, 0x9E, 0xB9, 0x9E, 0x78, 0x88, 0x88, 0x86, 0xE9, 0x99,
  0x99, 0x9E, 0xF2, 0x79, 0x27, 0xF2, 0x4F, 0x24, 0x78, 0x88, 0xB9, 0x97,
  0x99, 0x9F, 0x99, 0x99, 0xE9, 0x24, 0x97, 0x24, 0x92, 0x49, 0x38, 0x9A,
  0xAC, 0xCA, 0xA9, 0x92, 0x49, 0x27, 0x86, 0x3C, 0xF3, 0xD6, 0xDB, 0x6D,
  0x9D, 0xDD, 0xBB, 0x99, 0x64, 0xA5, 0x18, 0xCA, 0x4E, 0xEA, 0x9A, 0xE8,
  0x88, 0x64, 0xA5, 0x18, 0xCA, 0x4E, 0x20, 0x80, 0xEA, 0x9A, 0xCA, 0xA9,
  0x74, 0x84, 0x31, 0x1F, 0xF2, 0x22, 0x22, 0x22, 0x99, 0x99, 0x99, 0x9E,
  0x8C, 0x54, 0xA5, 0x28, 0x84, 0x91, 0x99, 0x9A, 0x5A, 0x5A, 0x66, 0x66,
  0x24, 0x95, 0x62, 0x66, 0x59, 0x99, 0x56, 0x22, 0x22, 0xF2, 0x22, 0x44,
  0x4F, 0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0x3C,
  0x23, 0x15, 0x30, 0xF8, 0xC0, 0x71, 0x35, 0x97, 0x88, 0xEA, 0x99, 0x9E,
  0x74, 0x88, 0x47, 0x11, 0x75, 0x99, 0x57, 0x75, 0xF8, 0x47, 0x6B, 0xA4,
  0x92, 0x75, 0x99, 0x57, 0x19, 0x60, 0x93, 0xDB, 0x6D, 0xBF, 0x45, 0x55,
  0x58, 0x92, 0xED, 0xAD, 0xFF, 0xFA, 0x9A, 0x69, 0xA6, 0x90, 0xF6, 0xDB,
  0x40, 0x75, 0x99, 0x57, 0xEA, 0x99, 0x9E, 0x88, 0x80, 0x75, 0x99, 0x57,
  0x11, 0x10, 0xEA, 0xA0, 0x71, 0x13, 0xC0, 0x5D, 0x24, 0x98, 0xB6, 0xDB,
  0xC0, 0x99, 0x66, 0x66, 0x93, 0x29, 0xD3, 0x66, 0xC9, 0x00, 0x96, 0x66,
  0x69, 0x99, 0x66, 0x66, 0x44, 0x80, 0xE5, 0x25, 0xC0, 0x32, 0x44, 0xC4,
  0x44, 0x23, 0xFF, 0xE0, 0xC4, 0x44, 0x32, 0x44, 0x4C, 0x5B,
};

const GFXglyph NotoSans_ExtraCondensed_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 1, -8 },
  { 4, 5, 8, 5, 0, -8 },
  { 9, 4, 9, 5, 0, -8 },
  { 14, 7, 8, 7, 0, -8 },
  { 21, 5, 8, 5, 0, -8 },
  { 26, 1, 3, 2, 1, -8 },
  { 27, 2, 10, 3, 1, -8 },
  { 30, 3, 10, 3, 0, -8 },
  { 34, 4, 3, 4, 0, -8 },
  { 36, 4, 5, 5, 0, -6 },
  { 39, 2, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 1, -1 },
  { 42, 4, 8, 4, 0, -8 },
  { 46, 4, 8, 5, 0, -8 },
  { 50, 2, 8, 5, 1, -8 },
  { 52, 4, 8, 5, 0, -8 },
  { 56, 4, 8, 5, 0, -8 },
  { 60, 5, 8, 5, 0, -8 },
  { 65, 3, 8, 5, 1, -8 },
  { 68, 4, 8, 5, 0, -8 },
  { 72, 4, 8, 5, 0, -8 },
  { 76, 4, 8, 5, 0, -8 },
  { 80, 4, 8, 5, 0, -8 },
  { 84, 1, 6, 3, 1, -6 },
  { 85, 2, 7, 3, 0, -6 },
  { 87, 4, 5, 5, 0, -6 },
  { 90, 4, 3, 5, 0, -5 },
  { 92, 4, 5, 5, 0, -6 },
  { 95, 3, 8, 4, 0, -8 },
  { 98, 6, 9, 7, 1, -8 },
  { 105, 5, 8, 5, 0, -8 },
  { 110, 4, 8, 5, 1, -8 },
  { 114, 4, 8, 5, 1, -8 },
  { 118, 4, 8, 6, 1, -8 },
  { 122, 3, 8, 4, 1, -8 },
  { 125, 3, 8, 4, 1, -8 },
  { 128, 4, 8, 6, 1, -8 },
  { 132, 4, 8, 6, 1, -8 },
  { 136, 3, 8, 3, 0, -8 },
  { 139, 3, 10, 2, -1, -8 },
  { 143, 4, 8, 5, 1, -8 },
  { 147, 3, 8, 4, 1, -8 },
  { 150, 6, 8, 8, 1, -8 },
  { 156, 4, 8, 6, 1, -8 },
  { 160, 5, 8, 6, 1, -8 },
  { 165, 4, 8, 5, 1, -8 },
  { 169, 5, 10, 6, 1, -8 },
  { 176, 4, 8, 5, 1, -8 },
  { 180, 4, 8, 5, 0, -8 },
  { 184, 4, 8, 4, 0, -8 },
  { 188, 4, 8, 6, 1, -8 },
  { 192, 5, 8, 5, 0, -8 },
  { 197, 8, 8, 8, 0, -8 },
  { 205, 4, 8, 4, 0, -8 },
  { 209, 4, 8, 4, 0, -8 },
  { 213, 4, 8, 4, 0, -8 },
  { 217, 2, 10, 3, 1, -8 },
  { 220, 4, 8, 4, 0, -8 },
  { 224, 3, 10, 3, 0, -8 },
  { 228, 5, 4, 5, 0, -8 },
  { 231, 5, 1, 5, 0, 1 },
  { 232, 2, 1, 3, 0, -8 },
  { 233, 4, 6, 5, 0, -6 },
  { 236, 4, 8, 5, 1, -8 },
  { 240, 4, 6, 4, 0, -6 },
  { 243, 4, 8, 5, 0, -8 },
  { 247, 4, 6, 5, 0, -6 },
  { 250, 3, 8, 3, 0, -8 },
  { 253, 4, 9, 5, 0, -6 },
  { 258, 3, 8, 5, 1, -8 },
  { 261, 1, 8, 2, 1, -8 },
  { 262, 2, 11, 2, 0, -8 },
  { 265, 3, 8, 4, 1, -8 },
  { 268, 1, 8, 2, 1, -8 },
  { 269, 6, 6, 8, 1, -6 },
  { 274, 3, 6, 5, 1, -6 },
  { 277, 4, 6, 5, 0, -6 },
  { 280, 4, 9, 5, 1, -6 },
  { 285, 4, 9, 5, 0, -6 },
  { 290, 2, 6, 3, 1, -6 },
  { 292, 3, 6, 4, 0, -6 },
  { 295, 3, 7, 3, 0, -7 },
  { 298, 3, 6, 5, 1, -6 },
  { 301, 4, 6, 4, 0, -6 },
  { 304, 7, 6, 7, 0, -6 },
  { 310, 4, 6, 4, 0, -6 },
  { 313, 4, 9, 4, 0, -6 },
  { 318, 3, 6, 3, 0, -6 },
  { 321, 4, 10, 4, 0, -8 },
  { 326, 1, 11, 4, 2, -8 },
  { 328, 4, 10, 4, 0, -8 },
  { 333, 4, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Regular11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR11PT7B_H_
