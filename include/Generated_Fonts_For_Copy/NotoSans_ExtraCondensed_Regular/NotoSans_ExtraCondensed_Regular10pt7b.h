#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x55, 0xF5, 0xF6, 0x60, 0x27, 0xAA, 0x63, 0xB6, 0x20,
  0xEA, 0xCB, 0x3F, 0x2C, 0xB2, 0xC0, 0x63, 0x18, 0xDB, 0x49, 0xE0, 0xC0,
  0x69, 0x49, 0x12, 0x20, 0xD5, 0x55, 0x80, 0x4D, 0x66, 0x22, 0xF2, 0x20,
  0x60, 0xC0, 0x80, 0x32, 0x24, 0x44, 0x80, 0x69, 0x99, 0x99, 0x60, 0x75,
  0x54, 0xE1, 0x12, 0x24, 0xF0, 0xE1, 0x16, 0x11, 0xE0, 0x22, 0x66, 0xA7,
  0x20, 0x64, 0x87, 0x11, 0xE0, 0x74, 0xAD, 0x95, 0x60, 0xF1, 0x22, 0x24,
  0x40, 0x79, 0x56, 0x99, 0x70, 0x69, 0x97, 0x11, 0x60, 0x88, 0x40, 0x60,
  0x12, 0xC2, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4, 0xA4, 0x10, 0x39,
  0x1B, 0xEB, 0xB6, 0xF4, 0x0E, 0x23, 0x18, 0xA7, 0x4A, 0x60, 0xF6, 0xFB,
  0x78, 0x74, 0x88, 0x44, 0x70, 0xEA, 0x99, 0x9A, 0xE0, 0xF2, 0x69, 0x38,
  0xF2, 0x69, 0x20, 0x7A, 0x21, 0x34, 0xA5, 0xE0, 0x99, 0x9F, 0x99, 0x90,
  0xD5, 0x5C, 0x55, 0x55, 0x80, 0xAA, 0xCC, 0xCA, 0xB0, 0x92, 0x49, 0x38,
  0x8C, 0x77, 0xBD, 0xD6, 0xA0, 0x99, 0xDD, 0xBB, 0x90, 0x72, 0x63, 0x18,
  0xA5, 0xC0, 0xF6, 0xF9, 0x20, 0x72, 0x63, 0x18, 0xA5, 0xC2, 0x08, 0xF6,
  0xFD, 0x68, 0x78, 0x46, 0x11, 0xE0, 0xF4, 0x44, 0x44, 0x40, 0x99, 0x99,
  0x99, 0xE0, 0x99, 0x55, 0x66, 0x20, 0x93, 0x26, 0x6B, 0x66, 0xCD, 0x99,
  0x00, 0x96, 0x66, 0x66, 0x90, 0x9A, 0x66, 0x44, 0x40, 0xE4, 0xA4, 0xB8,
  0xEA, 0xAA, 0xC0, 0x84, 0x44, 0x22, 0x30, 0xD5, 0x55, 0xC0, 0x26, 0x59,
  0xF0, 0x90, 0xE1, 0x79, 0x70, 0x93, 0x5B, 0x6F, 0x72, 0x46, 0x11, 0x35,
  0x99, 0x97, 0x79, 0xE8, 0x70, 0x69, 0x64, 0x92, 0x79, 0x99, 0x71, 0xF0,
  0x93, 0x5B, 0x6D, 0xBE, 0x45, 0x55, 0x80, 0x92, 0xED, 0xB5, 0xFF, 0xFD,
  0x6B, 0x5A, 0x80, 0xF6, 0xDA, 0x79, 0x99, 0x60, 0xF6, 0xDF, 0x20, 0x79,
  0x99, 0x71, 0x10, 0xEA, 0x80, 0xF1, 0x9E, 0x5D, 0x54, 0xB6, 0xDE, 0x9A,
  0x66, 0x40, 0xB6, 0xD7, 0x92, 0x48, 0xF6, 0x46, 0xB0, 0x9A, 0x66, 0x44,
  0xC0, 0xE9, 0x2E, 0x29, 0x2C, 0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92,
  0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 4, 1, -7 },
  { 3, 4, 7, 5, 0, -7 },
  { 7, 4, 9, 4, 0, -8 },
  { 12, 6, 7, 7, 0, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 2, 1, -7 },
  { 24, 3, 9, 3, 0, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 4, 4, 4, 0, -8 },
  { 33, 4, 5, 4, 0, -6 },
  { 36, 2, 2, 2, 0, -1 },
  { 37, 2, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 1, -1 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 2, 7, 4, 1, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 7, 4, 0, -7 },
  { 57, 4, 7, 4, 0, -7 },
  { 61, 4, 7, 4, 0, -7 },
  { 65, 4, 7, 4, 0, -7 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 4, 7, 4, 0, -7 },
  { 77, 4, 7, 4, 0, -7 },
  { 81, 1, 5, 2, 1, -5 },
  { 82, 2, 6, 2, 0, -5 },
  { 84, 4, 5, 4, 0, -6 },
  { 87, 4, 3, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -6 },
  { 92, 3, 7, 3, 0, -7 },
  { 95, 6, 8, 7, 0, -7 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 3, 7, 5, 1, -7 },
  { 109, 4, 7, 4, 0, -7 },
  { 113, 4, 7, 5, 1, -7 },
  { 117, 3, 7, 4, 1, -7 },
  { 120, 3, 7, 4, 1, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 4, 7, 5, 1, -7 },
  { 132, 2, 7, 3, 0, -7 },
  { 134, 2, 9, 2, 0, -7 },
  { 137, 4, 7, 4, 1, -7 },
  { 141, 3, 7, 4, 1, -7 },
  { 144, 5, 7, 7, 1, -7 },
  { 149, 4, 7, 6, 1, -7 },
  { 153, 5, 7, 6, 0, -7 },
  { 158, 3, 7, 4, 1, -7 },
  { 161, 5, 9, 6, 0, -7 },
  { 167, 3, 7, 5, 1, -7 },
  { 170, 4, 7, 4, 0, -7 },
  { 174, 4, 7, 4, 0, -7 },
  { 178, 4, 7, 5, 1, -7 },
  { 182, 4, 7, 4, 0, -7 },
  { 186, 7, 7, 7, 0, -7 },
  { 193, 4, 7, 4, 0, -7 },
  { 197, 4, 7, 4, 0, -7 },
  { 201, 3, 7, 4, 0, -7 },
  { 204, 2, 9, 3, 1, -7 },
  { 207, 4, 7, 4, 0, -7 },
  { 211, 2, 9, 3, 0, -7 },
  { 214, 4, 4, 4, 0, -7 },
  { 216, 4, 1, 4, 0, 1 },
  { 217, 2, 2, 3, 0, -8 },
  { 218, 4, 5, 4, 0, -5 },
  { 221, 3, 8, 5, 1, -8 },
  { 224, 3, 5, 3, 0, -5 },
  { 226, 4, 8, 5, 0, -8 },
  { 230, 4, 5, 4, 0, -5 },
  { 233, 3, 8, 3, 0, -8 },
  { 236, 4, 7, 5, 0, -5 },
  { 240, 3, 8, 5, 1, -8 },
  { 243, 1, 7, 2, 1, -7 },
  { 244, 2, 9, 2, 0, -7 },
  { 247, 3, 8, 4, 1, -8 },
  { 250, 1, 8, 2, 1, -8 },
  { 251, 5, 5, 7, 1, -5 },
  { 255, 3, 5, 5, 1, -5 },
  { 257, 4, 5, 4, 0, -5 },
  { 260, 3, 7, 5, 1, -5 },
  { 263, 4, 7, 5, 0, -5 },
  { 267, 2, 5, 3, 1, -5 },
  { 269, 3, 5, 3, 0, -5 },
  { 271, 2, 7, 3, 0, -7 },
  { 273, 3, 5, 5, 1, -5 },
  { 275, 4, 5, 4, 0, -5 },
  { 278, 6, 5, 6, 0, -5 },
  { 282, 4, 5, 4, 0, -5 },
  { 285, 4, 7, 4, 0, -5 },
  { 289, 3, 5, 3, 0, -5 },
  { 291, 3, 9, 4, 0, -7 },
  { 295, 1, 10, 4, 2, -8 },
  { 297, 3, 9, 4, 0, -7 },
  { 301, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Regular10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR10PT7B_H_
