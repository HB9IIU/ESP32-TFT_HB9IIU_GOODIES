#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0x7E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x43, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x80, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF0,
  0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x3E, 0x7C, 0x03, 0xCF, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1E,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x78, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x01,
  0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x1F,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFB,
  0x9F, 0xC7, 0xF1, 0xC0, 0xE3, 0xF0, 0xE0, 0x03, 0xF0, 0x70, 0x01, 0xF0,
  0x38, 0x00, 0xF8, 0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x3E, 0x07, 0x00, 0x1F,
  0x03, 0x80, 0x0F, 0x81, 0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xF0, 0x70, 0x00,
  0xFE, 0x38, 0x00, 0x7F, 0x9C, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1D, 0xFE, 0x00, 0x0E, 0x7F, 0x80, 0x07,
  0x0F, 0xC0, 0x03, 0x83, 0xF0, 0x01, 0xC1, 0xF8, 0x00, 0xE0, 0x7C, 0x00,
  0x70, 0x3E, 0x00, 0x38, 0x1F, 0x00, 0x1C, 0x0F, 0x80, 0x0E, 0x07, 0xC0,
  0x07, 0x07, 0xF0, 0x03, 0x83, 0xEC, 0x01, 0xC3, 0xF7, 0xC0, 0xE7, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC1, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x1E, 0x00, 0x03,
  0xE0, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x03,
  0xE0, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x0F, 0x80, 0x40, 0x3E, 0x07, 0xC3, 0xE0, 0xFE,
  0x0F, 0x81, 0xF0, 0xF8, 0x7F, 0xC1, 0xE0, 0x7C, 0x7C, 0x3F, 0xF8, 0x78,
  0x1F, 0x1F, 0x1F, 0xFF, 0x1F, 0x07, 0x87, 0xC7, 0xC7, 0xC7, 0xC3, 0xE3,
  0xE3, 0xE0, 0xF8, 0xF9, 0xF8, 0xF8, 0xF8, 0x3E, 0x3F, 0xFC, 0x3C, 0x3E,
  0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0x01, 0xE0, 0xFF, 0x87, 0xC3, 0xC0, 0x7C,
  0x1F, 0x81, 0xE1, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xDF, 0x80, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xF0, 0xFC, 0x7E, 0x03, 0xF0, 0xFC,
  0x7E, 0x01, 0xF9, 0xF8, 0xFC, 0x01, 0xFD, 0xF8, 0xFC, 0x00, 0xFD, 0xF8,
  0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x3F, 0xF0,
  0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0xFF, 0xF0,
  0x7F, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0xF9, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBE, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x20, 0x3E, 0x06, 0xFC, 0x78, 0x7D, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x1F,
  0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xC0, 0x70,
  0x01, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE,
  0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xDF, 0x9F, 0xCF, 0xFF, 0xC7, 0xEF, 0xC3, 0xF3, 0xC1,
  0xF8, 0xC0, 0xFC, 0x40, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xE0, 0x0F, 0xE0, 0x60, 0x01, 0xFC,
  0x10, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0x07, 0xFC, 0x78, 0x01, 0xFC, 0x30, 0x00, 0xFE, 0x20,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x80, 0x01, 0xFE, 0xF0, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBF, 0x00, 0x00,
  0x3D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1E, 0x7E, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0x80,
  0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF8,
  0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x70, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x20, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x80,
  0x03, 0xFC, 0xE0, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xF0, 0x60, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0xC0, 0x07, 0xC3, 0xFE, 0x03, 0xE3, 0xFF, 0x83, 0xF3, 0xFF, 0xE1, 0xFB,
  0xFF, 0xF8, 0xFD, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0x3F, 0xE0, 0x1F, 0x9F,
  0xE0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC,
  0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF8,
  0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF,
  0x7F, 0x01, 0xFF, 0x3F, 0xC3, 0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F,
  0x0F, 0xFF, 0x3F, 0x07, 0xFE, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x7E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x18, 0x1E, 0x0F, 0xC3, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0xFE, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE1,
  0xFE, 0x70, 0x07, 0xF2, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xFF, 0xF0, 0x7C, 0x3E, 0x00, 0xFF,
  0xF8, 0x1E, 0x1F, 0x00, 0xFF, 0xFC, 0x0F, 0x8F, 0x80, 0xFC, 0x3E, 0x07,
  0xC7, 0xC0, 0x7C, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0x0F, 0x81, 0xF3, 0xE0,
  0x3E, 0x07, 0xC0, 0x79, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0xBE, 0x07, 0xC0, 0x7C, 0x07,
  0xDE, 0x03, 0xE0, 0x3E, 0x03, 0xEF, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x81,
  0xF0, 0x1F, 0x80, 0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x7C, 0x07,
  0xE0, 0x3D, 0xF0, 0x3E, 0x03, 0xE0, 0x1E, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x9E, 0x03, 0xC0, 0x7C, 0x07, 0xCF, 0x01,
  0xF0, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0x3F, 0x81, 0xE3, 0xE0, 0x7C, 0x1D,
  0xC1, 0xF1, 0xF0, 0x1F, 0x1E, 0xE0, 0xF8, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8,
  0x7C, 0x07, 0xFF, 0x3F, 0xF8, 0x3E, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0x80,
  0x7F, 0x83, 0xFC, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xF8, 0x03, 0xFE, 0x3F, 0x00, 0x1F, 0xE7, 0xE0, 0x01, 0xFC,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0x0F, 0xF8, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xF9, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xCF, 0xC0, 0x07, 0xF9, 0xF8, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xC7, 0xE0, 0xFF, 0x80,
  0x38, 0x3F, 0x80, 0x02, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x20, 0x7F, 0xC0, 0x38, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7E, 0x01, 0xFF, 0x83, 0xF0, 0x03, 0xFC, 0x1F, 0x80, 0x0F, 0xF0,
  0xFC, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFF, 0x0F, 0xC0,
  0x1F, 0xF0, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0x81, 0xFF, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x0C, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFE,
  0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01,
  0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0xFD, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xF9, 0xF8, 0x01, 0xFE, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFB, 0xFF, 0xDF, 0x00, 0x00, 0x3E, 0xFF,
  0xF7, 0xC0, 0x00, 0x0F, 0xBF, 0xFD, 0xF8, 0x00, 0x07, 0xCF, 0xFF, 0x7E,
  0x00, 0x01, 0xF3, 0xFF, 0xCF, 0x80, 0x00, 0x7C, 0xFF, 0xF3, 0xE0, 0x00,
  0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x0F, 0x8F, 0xFF, 0x1F, 0x00, 0x03, 0xE3,
  0xFF, 0xC7, 0xC0, 0x00, 0xF8, 0xFF, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0xFC,
  0x7E, 0x00, 0x1F, 0x0F, 0xFF, 0x0F, 0x80, 0x07, 0xC3, 0xFF, 0xC3, 0xE0,
  0x03, 0xF0, 0xFF, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x00, 0x3E,
  0x0F, 0xFF, 0x07, 0xC0, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0xFF,
  0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0xFF, 0x03,
  0xE0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x03,
  0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0x01, 0xF0, 0x7E, 0x03,
  0xFF, 0xC0, 0x7E, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0xFC,
  0x03, 0xE3, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x3E, 0x00, 0xFF, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x01, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xEF, 0xC0, 0x03, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0x9F, 0x80, 0x0F,
  0xFF, 0x3F, 0x00, 0x1F, 0xFE, 0x3E, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F,
  0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xE1, 0xF8, 0x03, 0xFF,
  0xC1, 0xF8, 0x07, 0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0x07, 0xE0, 0x1F, 0xFE,
  0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0,
  0x1F, 0x81, 0xFF, 0xE0, 0x1F, 0x03, 0xFF, 0xC0, 0x3F, 0x07, 0xFF, 0x80,
  0x7E, 0x0F, 0xFF, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0xFC, 0x3F, 0xFC, 0x00,
  0xFC, 0x7F, 0xF8, 0x01, 0xF8, 0xFF, 0xF0, 0x01, 0xF1, 0xFF, 0xE0, 0x03,
  0xF3, 0xFF, 0xC0, 0x07, 0xE7, 0xFF, 0x80, 0x07, 0xEF, 0xFF, 0x00, 0x0F,
  0xDF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xE0, 0x3F, 0xF3, 0xF0, 0x07, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC,
  0x01, 0xFE, 0x7E, 0x0F, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xF8, 0x0F, 0xFC,
  0x3F, 0x00, 0x7F, 0x87, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00,
  0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x3F, 0xC0, 0x3C, 0x7F, 0x00, 0x04, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x80, 0x00, 0xFE,
  0xC0, 0x01, 0xFC, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xC3,
  0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x9F, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0xF9, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x9F,
  0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0,
  0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x00, 0xFD, 0xF0, 0x01, 0xF3,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x1E,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0x7F, 0xC0, 0xE0, 0x3F, 0x81, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0x03,
  0xE7, 0xF0, 0x07, 0xDF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFE,
  0x03, 0xFC, 0xFE, 0x1E, 0xF9, 0xFF, 0xFD, 0xF1, 0xFF, 0xF1, 0xE1, 0xFF,
  0xC3, 0xC1, 0xFF, 0x07, 0x80, 0x70, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0xC0,
  0x7C, 0x3F, 0xF8, 0x3E, 0x3F, 0xFE, 0x1F, 0x3F, 0xFF, 0x8F, 0xBF, 0xFF,
  0xC7, 0xFE, 0x0F, 0xF3, 0xFC, 0x01, 0xF9, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0xFE, 0xFF, 0x00, 0x7E, 0x7F, 0xC0, 0x7F, 0x3E, 0xF8, 0xFF, 0x1F, 0x7F,
  0xFF, 0x8F, 0x9F, 0xFF, 0x87, 0xC7, 0xFF, 0x83, 0xE0, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFE, 0x06, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x01, 0x1F, 0xFB, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xFE,
  0x0F, 0xC0, 0xFF, 0xE3, 0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF, 0xBF, 0x1F,
  0xFF, 0xEF, 0xC7, 0xF0, 0x3F, 0xF3, 0xF8, 0x07, 0xFC, 0xFC, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7,
  0xE0, 0x03, 0xFC, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x7F, 0xCF, 0xE0, 0x3F,
  0xF1, 0xFE, 0x3F, 0xFC, 0x7F, 0xFF, 0xBF, 0x0F, 0xFF, 0xC7, 0xC1, 0xFF,
  0xE1, 0xF0, 0x1F, 0xF0, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xF7, 0xF8, 0x1F,
  0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x1F,
  0xC0, 0x0E, 0x0F, 0xF0, 0x7E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x81, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xC0, 0xFF,
  0xE1, 0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xEF, 0xC7,
  0xF0, 0x7F, 0xF3, 0xF8, 0x07, 0xFC, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F,
  0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xFC,
  0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xCF, 0xE0, 0x3F, 0xF1, 0xFF, 0x3E,
  0xFC, 0x7F, 0xFF, 0xBF, 0x0F, 0xFF, 0xCF, 0xC1, 0xFF, 0xE3, 0xF0, 0x3F,
  0xF0, 0xFC, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x40, 0x00, 0x3F, 0x0C, 0x00,
  0x1F, 0xC3, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0xC1, 0xF1, 0xFF,
  0xE3, 0xE7, 0xFF, 0xE7, 0xCF, 0xFF, 0xCF, 0xBF, 0xFF, 0xDF, 0x78, 0x3F,
  0xBF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x80,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x01,
  0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x8F,
  0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F,
  0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x3F,
  0x00, 0x7C, 0xFE, 0x00, 0xF9, 0xFC, 0x01, 0xF7, 0xF8, 0x03, 0xEF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFB, 0xF0, 0x1F, 0xE7, 0xE0, 0x3F, 0x87, 0xC0,
  0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xF8, 0xFF,
  0xE0, 0x7F, 0xF0, 0xF9, 0xFF, 0xF0, 0xFF, 0xF8, 0xFB, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0x83, 0xFB, 0xC1, 0xFE, 0xFF,
  0x01, 0xFF, 0x80, 0xFE, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0xFF,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x3F, 0xC1, 0xF1,
  0xFF, 0xE3, 0xE7, 0xFF, 0xE7, 0xCF, 0xFF, 0xCF, 0xBF, 0xFF, 0xDF, 0xF8,
  0x3F, 0xBF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x3F, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x3F, 0xC0, 0x7C, 0x3F, 0xF8, 0x3E, 0x3F, 0xFE, 0x1F, 0x3F, 0xFF, 0x8F,
  0xBF, 0xFF, 0xC7, 0xDE, 0x07, 0xF3, 0xFC, 0x01, 0xF9, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD,
  0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7E, 0x7F, 0xC0, 0x7F, 0x3E, 0xFD, 0xFF,
  0x1F, 0x3F, 0xFF, 0x8F, 0x9F, 0xFF, 0x87, 0xC7, 0xFF, 0x83, 0xF0, 0xFF,
  0x81, 0xF8, 0x1E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xC0, 0xFF, 0xE1,
  0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xEF, 0xC7, 0xF0,
  0x7F, 0xF3, 0xF8, 0x07, 0xFC, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF,
  0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xFC, 0xFC,
  0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xCF, 0xE0, 0x3F, 0xF1, 0xFF, 0x7E, 0xFC,
  0x7F, 0xFF, 0xBF, 0x0F, 0xFF, 0xCF, 0xC1, 0xFF, 0xE3, 0xF0, 0x3F, 0xF0,
  0xFC, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xFB, 0xFE, 0xFB, 0xC0, 0xFF, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xF0, 0x1C, 0x7E, 0x00, 0x47, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0x1F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xF0,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0xFE,
  0x07, 0xFD, 0xFF, 0xFE, 0xFB, 0xFF, 0xFD, 0xF3, 0xFF, 0xF3, 0xE3, 0xFF,
  0xC7, 0xC3, 0xFF, 0x0F, 0x80, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x8F,
  0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x83, 0xE0,
  0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x7C,
  0x00, 0x7F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xE0, 0x07, 0xE7, 0xE0, 0x0F,
  0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x7E, 0x00, 0xFF, 0xC0,
  0x1F, 0x0F, 0x80, 0x3D, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x7C, 0x03, 0xF0,
  0xFC, 0x07, 0xCF, 0x00, 0xF8, 0x3F, 0x01, 0xF3, 0xE0, 0x3E, 0x0F, 0xC0,
  0x7C, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0x8F,
  0x81, 0xF8, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x1F, 0x0F, 0xC0, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0x0F,
  0xC7, 0xC1, 0xF0, 0xFC, 0x03, 0xF1, 0xF0, 0x7C, 0x3E, 0x00, 0xFC, 0x7C,
  0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x07, 0xC7, 0xC0, 0xF9,
  0xF8, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x00, 0x7E, 0xF8, 0x0F, 0x9F, 0x00,
  0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x79, 0xF0, 0x00, 0xFB,
  0xE0, 0x1F, 0xFC, 0x00, 0x3E, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xBC, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x8F, 0xC0, 0x1F,
  0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFF, 0x00, 0x05, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xF6, 0x00, 0x1F, 0xFC, 0x80, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 52, 17, 5, -51 },
  { 47, 19, 18, 27, 4, -51 },
  { 90, 31, 51, 33, 1, -51 },
  { 288, 25, 59, 31, 3, -55 },
  { 473, 42, 53, 48, 3, -52 },
  { 752, 32, 53, 34, 2, -52 },
  { 964, 7, 18, 15, 4, -51 },
  { 980, 15, 63, 21, 4, -52 },
  { 1099, 15, 63, 21, 2, -52 },
  { 1218, 23, 24, 29, 3, -55 },
  { 1287, 27, 33, 31, 2, -42 },
  { 1399, 10, 18, 16, 3, -8 },
  { 1422, 16, 6, 20, 2, -22 },
  { 1434, 8, 10, 16, 4, -9 },
  { 1444, 25, 52, 27, 1, -52 },
  { 1607, 25, 53, 31, 3, -52 },
  { 1773, 17, 51, 31, 4, -51 },
  { 1882, 26, 52, 31, 2, -52 },
  { 2051, 24, 53, 31, 3, -52 },
  { 2210, 29, 52, 31, 1, -52 },
  { 2399, 24, 52, 31, 4, -51 },
  { 2555, 25, 53, 31, 3, -52 },
  { 2721, 26, 51, 31, 2, -51 },
  { 2887, 27, 53, 31, 2, -52 },
  { 3066, 24, 53, 31, 3, -52 },
  { 3225, 8, 40, 16, 4, -39 },
  { 3265, 10, 49, 16, 3, -39 },
  { 3327, 27, 33, 31, 2, -42 },
  { 3439, 27, 21, 31, 2, -36 },
  { 3510, 27, 33, 31, 2, -42 },
  { 3622, 20, 53, 23, 1, -52 },
  { 3755, 41, 58, 47, 3, -52 },
  { 4053, 32, 51, 32, 0, -51 },
  { 4257, 27, 51, 34, 5, -51 },
  { 4430, 26, 53, 32, 4, -52 },
  { 4603, 29, 51, 37, 5, -51 },
  { 4788, 21, 51, 29, 5, -51 },
  { 4922, 21, 51, 27, 5, -51 },
  { 5056, 31, 53, 39, 4, -52 },
  { 5262, 28, 51, 38, 5, -51 },
  { 5441, 16, 51, 20, 2, -51 },
  { 5543, 15, 65, 16, -4, -51 },
  { 5665, 27, 51, 32, 5, -51 },
  { 5838, 20, 51, 27, 5, -51 },
  { 5966, 42, 51, 52, 5, -51 },
  { 6234, 31, 51, 41, 5, -51 },
  { 6432, 32, 53, 40, 4, -52 },
  { 6644, 25, 51, 32, 5, -51 },
  { 6804, 32, 64, 40, 4, -52 },
  { 7060, 27, 51, 33, 5, -51 },
  { 7233, 24, 53, 30, 3, -52 },
  { 7392, 26, 51, 27, 1, -51 },
  { 7558, 28, 52, 38, 5, -51 },
  { 7740, 32, 51, 32, 0, -51 },
  { 7944, 52, 51, 52, 0, -51 },
  { 8276, 28, 51, 29, 0, -51 },
  { 8455, 28, 51, 28, 0, -51 },
  { 8634, 23, 51, 26, 2, -51 },
  { 8781, 15, 64, 22, 5, -52 },
  { 8901, 25, 52, 27, 1, -52 },
  { 9064, 15, 64, 22, 2, -52 },
  { 9184, 30, 27, 32, 1, -51 },
  { 9286, 32, 5, 31, 0, 6 },
  { 9306, 13, 11, 19, 3, -55 },
  { 9324, 23, 40, 30, 2, -39 },
  { 9439, 25, 56, 33, 5, -55 },
  { 9614, 20, 40, 25, 3, -39 },
  { 9714, 26, 56, 33, 3, -55 },
  { 9896, 24, 40, 30, 3, -39 },
  { 10016, 19, 55, 18, 1, -55 },
  { 10147, 26, 56, 33, 3, -39 },
  { 10329, 23, 55, 33, 5, -55 },
  { 10488, 7, 53, 15, 4, -53 },
  { 10535, 12, 70, 15, -1, -53 },
  { 10640, 23, 55, 29, 5, -55 },
  { 10799, 6, 55, 15, 5, -55 },
  { 10841, 40, 39, 49, 5, -39 },
  { 11036, 23, 39, 33, 5, -39 },
  { 11149, 26, 40, 32, 3, -39 },
  { 11279, 25, 56, 33, 5, -39 },
  { 11454, 26, 56, 33, 3, -39 },
  { 11636, 16, 39, 22, 5, -39 },
  { 11714, 20, 40, 24, 2, -39 },
  { 11814, 17, 48, 19, 1, -47 },
  { 11916, 23, 40, 33, 5, -39 },
  { 12031, 26, 39, 27, 0, -39 },
  { 12158, 42, 39, 44, 1, -39 },
  { 12363, 25, 39, 27, 1, -39 },
  { 12485, 26, 56, 27, 0, -39 },
  { 12667, 18, 39, 22, 2, -39 },
  { 12755, 20, 64, 26, 3, -52 },
  { 12915, 5, 72, 29, 12, -55 },
  { 12960, 20, 64, 26, 3, -52 },
  { 13120, 27, 9, 31, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Regular72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR72PT7B_H_
