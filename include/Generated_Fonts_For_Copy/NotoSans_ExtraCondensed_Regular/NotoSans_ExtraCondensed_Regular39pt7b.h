#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE0, 0x00, 0x04, 0x77, 0xDE, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0x78,
  0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x0E, 0x61, 0xCC, 0x18, 0x07, 0x0C, 0x07,
  0x1C, 0x06, 0x1C, 0x06, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x0E,
  0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x38, 0x0C, 0x38, 0x0C, 0x38, 0x0C,
  0x30, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x38, 0x60, 0x38, 0x60, 0x38,
  0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01,
  0xFF, 0x3F, 0xFD, 0xFB, 0xDC, 0xC2, 0xE6, 0x06, 0x30, 0x31, 0x81, 0xCC,
  0x0E, 0x60, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0x9E,
  0x0C, 0x70, 0x63, 0x83, 0x1C, 0x18, 0xE0, 0xC7, 0x86, 0x77, 0xFF, 0xBF,
  0xF8, 0x7F, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3C, 0x03, 0x81,
  0xF8, 0x0E, 0x0E, 0x70, 0x30, 0x39, 0xC1, 0xC0, 0xC3, 0x07, 0x03, 0x0C,
  0x18, 0x0C, 0x38, 0xE0, 0x30, 0xE3, 0x80, 0xC3, 0x8C, 0x03, 0x0E, 0x70,
  0x0C, 0x39, 0x80, 0x30, 0xC6, 0x3C, 0xC3, 0x39, 0xFB, 0x9C, 0xCE, 0xE6,
  0x77, 0x31, 0xDF, 0x9C, 0xC7, 0x3C, 0x67, 0x0C, 0x03, 0x9C, 0x30, 0x0E,
  0x70, 0xC0, 0x31, 0xC3, 0x01, 0xC7, 0x0C, 0x07, 0x1C, 0x30, 0x18, 0x70,
  0xC0, 0xE0, 0xC7, 0x03, 0x83, 0x1C, 0x0C, 0x0E, 0x60, 0x70, 0x1F, 0x81,
  0xC0, 0x3C, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xCE, 0x00, 0xF1, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xDE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0xEF, 0x1E, 0x79, 0xC7, 0x1C, 0x79, 0xCF, 0x0E, 0x73, 0x81, 0xFC, 0xE0,
  0x7E, 0x38, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF8, 0x70, 0x7E, 0x1F, 0xFF,
  0xC3, 0xFE, 0x78, 0x7F, 0x0F, 0xFF, 0xFF, 0x77, 0x76, 0x66, 0x07, 0x0E,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x70,
  0x78, 0x38, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x06, 0x31, 0xBF, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x80, 0xEE, 0x07, 0x38,
  0x71, 0xE1, 0x84, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x3C, 0xE3, 0x8E, 0x79, 0xC7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x23, 0xBF, 0xE7, 0x00, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x00, 0x0F, 0x81, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78,
  0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3B, 0xC1, 0xCE, 0x0E, 0x78, 0xF3, 0xFF, 0x0F, 0xF0, 0x3F,
  0x00, 0x03, 0x83, 0xC3, 0xE3, 0xF3, 0xFB, 0xDF, 0xCE, 0x47, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1F, 0xC0, 0xFF,
  0x8F, 0xFF, 0x1C, 0x1E, 0x20, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC1,
  0xFF, 0xCF, 0xFF, 0x18, 0x1E, 0x40, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x1F, 0xE0, 0x7E, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x80, 0x7B, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xDC,
  0x03, 0xB8, 0x06, 0x70, 0x1C, 0xE0, 0x31, 0xC0, 0xE3, 0x81, 0xC7, 0x07,
  0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x80, 0xF7, 0xBF, 0x3F, 0xF1,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x87, 0xFC, 0x78, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x61, 0xDF, 0xCE, 0xFE, 0x7C,
  0xFB, 0xC1, 0xDE, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0xEE, 0x0F, 0x78, 0x71, 0xFF, 0x8F, 0xF8, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0x78, 0x3D, 0xC0, 0xF7,
  0x01, 0xDC, 0x07, 0x70, 0x3C, 0xE0, 0xE3, 0xC7, 0x87, 0xBC, 0x0F, 0xE0,
  0x1F, 0x01, 0xFE, 0x0F, 0x3C, 0x38, 0x79, 0xC0, 0xF7, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x78, 0x3D, 0xFB, 0xE3, 0xFF,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1C, 0x70, 0x39, 0xC0,
  0xE7, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xDC, 0x0F, 0x70,
  0x3D, 0xE0, 0xF7, 0xC7, 0xCF, 0xF7, 0x1F, 0x9C, 0x1C, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0xFF, 0x83,
  0xFC, 0x0F, 0xC0, 0x77, 0xBF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x23, 0xBF, 0xF7, 0x00, 0x39, 0xE7, 0xDE, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0x8E, 0x39, 0xE7, 0x1C, 0x73,
  0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x3F, 0x8F, 0xFC, 0x7F, 0xE6, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x78, 0x7C, 0x03, 0x80, 0x78, 0x1C,
  0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x1C, 0x00, 0x0E, 0x70, 0xFE,
  0x39, 0x87, 0xF8, 0x6E, 0x1C, 0x61, 0xB8, 0xE1, 0x87, 0xE3, 0x8E, 0x1F,
  0x8E, 0x38, 0x7E, 0x38, 0xE1, 0xF0, 0xC3, 0x87, 0xC3, 0x0E, 0x1F, 0x0C,
  0x38, 0x6E, 0x38, 0xE1, 0xB8, 0xE3, 0x8E, 0xE3, 0x9E, 0x3B, 0x87, 0xEF,
  0xCE, 0x1F, 0x3E, 0x1C, 0x08, 0x20, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x03, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xE0, 0x07, 0x38, 0x03, 0xCE,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xC0,
  0x70, 0x70, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xE0, 0x38, 0x38,
  0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x9C, 0x00,
  0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x3E,
  0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x80, 0xEE, 0x07,
  0xB8, 0x3C, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7B, 0xFF, 0xCF, 0xFF, 0x3F, 0xF0, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF,
  0x82, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x04, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xC7, 0x07, 0xCE, 0x07, 0x9C, 0x07, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x03,
  0xB8, 0x0F, 0x70, 0x3C, 0xE0, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFD, 0xFF, 0xBF, 0xF7, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xBF, 0xF7,
  0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xC3, 0xC0, 0x63, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x77, 0x00, 0x3B, 0xC0, 0x1D, 0xE0, 0x0E, 0x78, 0x07, 0x3E, 0x03, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70, 0xFF,
  0xFF, 0xCF, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x3F, 0xFF, 0xF0, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x0F, 0xFE, 0xFE, 0xFC, 0x20, 0xE0, 0x3D, 0xC0, 0x7B, 0x81,
  0xE7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE3, 0xC1,
  0xC7, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xF3, 0x81, 0xC7, 0x83, 0x87, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1E,
  0x38, 0x3C, 0x70, 0x38, 0xE0, 0x79, 0xC0, 0x73, 0x80, 0xF7, 0x00, 0xF0,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFB, 0x80,
  0x77, 0xEE, 0x01, 0xDF, 0xB8, 0x07, 0x7E, 0x60, 0x19, 0xF9, 0xC0, 0xE7,
  0xE7, 0x03, 0x9F, 0x9C, 0x0E, 0x7E, 0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE3,
  0x87, 0x1F, 0x86, 0x18, 0x7E, 0x1C, 0xE1, 0xF8, 0x73, 0x87, 0xE1, 0xCE,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x1F,
  0x81, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEE, 0x07,
  0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x87, 0xE3, 0x87, 0xE3, 0xC7,
  0xE1, 0xC7, 0xE1, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0xF7, 0xE0, 0x77,
  0xE0, 0x77, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0,
  0x78, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x79, 0xC0, 0x1E, 0xF0, 0x03,
  0xBC, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0,
  0x0E, 0x70, 0x07, 0x9C, 0x01, 0xE7, 0x80, 0x70, 0xE0, 0x3C, 0x3C, 0x1E,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0x07, 0xFE, 0x3F, 0xF9,
  0xC3, 0xEE, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0x70, 0x7B, 0xFF, 0x9F, 0xF8, 0xFF, 0x87, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xF0, 0x78, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x79, 0xC0, 0x1E, 0xF0,
  0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B,
  0xC0, 0x0E, 0x70, 0x07, 0x9C, 0x01, 0xE7, 0x80, 0x70, 0xE0, 0x3C, 0x3C,
  0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x38, 0x7C, 0xE0, 0x7B, 0x81, 0xEE, 0x03,
  0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0xB8, 0x1E, 0xE0, 0xF3, 0x8F,
  0xCF, 0xFE, 0x3F, 0xE0, 0xE3, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0,
  0xE3, 0x83, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xF8,
  0x07, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0x06, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0xC0, 0x7B, 0xFF, 0xCF, 0xFE,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x78, 0x0E,
  0xF8, 0x3C, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0xF0, 0x03, 0xF8, 0x03,
  0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0xC0, 0x38, 0xE0, 0x3C, 0x70,
  0x1C, 0x38, 0x0E, 0x1E, 0x07, 0x0F, 0x07, 0x83, 0x83, 0x81, 0xC1, 0xC0,
  0xE0, 0xE0, 0x78, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0xCE,
  0x00, 0xEF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x7F,
  0x00, 0xF0, 0x0F, 0x70, 0x0F, 0x00, 0xE7, 0x00, 0xF0, 0x0E, 0x70, 0x0F,
  0x00, 0xE7, 0x81, 0xF8, 0x0E, 0x78, 0x1F, 0x81, 0xE3, 0x81, 0xF8, 0x1C,
  0x38, 0x1F, 0x81, 0xC3, 0x81, 0x98, 0x1C, 0x38, 0x39, 0xC1, 0xC3, 0xC3,
  0x9C, 0x3C, 0x1C, 0x39, 0xC3, 0x81, 0xC3, 0x9C, 0x38, 0x1C, 0x30, 0xC3,
  0x81, 0xC7, 0x0E, 0x78, 0x0E, 0x70, 0xE7, 0x80, 0xE7, 0x0E, 0x70, 0x0E,
  0x70, 0xE7, 0x00, 0xE6, 0x06, 0x70, 0x0E, 0xE0, 0x77, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x78, 0x0E,
  0xF0, 0x3C, 0xE0, 0x71, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x9E, 0x07,
  0x38, 0x0E, 0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x39, 0xC0, 0x73, 0x81,
  0xE7, 0x03, 0x87, 0x0F, 0x0E, 0x1C, 0x1E, 0x38, 0x1C, 0xF0, 0x39, 0xC0,
  0x7F, 0x80, 0x70, 0xF0, 0x0F, 0xE0, 0x3D, 0xC0, 0x73, 0xC0, 0xE3, 0x83,
  0xC7, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x39, 0xC0,
  0x77, 0x00, 0xEE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x1C, 0x70,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x0E,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xE1, 0xE1,
  0xC1, 0xC1, 0xC0, 0x1F, 0xC1, 0xFF, 0x0F, 0x3C, 0x40, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x01, 0xF8, 0xFF, 0xCF, 0xFE, 0xF0, 0x77, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7B, 0x87, 0xDE, 0x7E, 0xFF, 0x73,
  0xF3, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x3E, 0x3B, 0xF9, 0xFB, 0xEF, 0x07, 0x78,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x1D, 0xFB, 0xEC,
  0xFE, 0x63, 0xE0, 0x1F, 0xE7, 0xF9, 0xFF, 0x3C, 0x07, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x0F, 0x01, 0xF3, 0x1F, 0xE1, 0xFC, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x7C, 0xF3, 0xFB, 0xDF, 0x7F, 0x70, 0x7F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xF7, 0x07, 0xDF, 0x77, 0x3F, 0xDC, 0x7E,
  0x70, 0x1F, 0x81, 0xFF, 0x1F, 0x78, 0xE0, 0xEF, 0x07, 0x70, 0x3B, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x8F, 0x9C, 0x7F, 0xE1, 0xFE, 0x00,
  0x03, 0xC1, 0xFC, 0x3F, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0xF3, 0xFE, 0x7F, 0xC1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0x1C, 0xFE, 0x77, 0xDD, 0xDC,
  0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3D,
  0xC1, 0xF7, 0xDF, 0xCF, 0xEF, 0x1F, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE4, 0x07, 0x9E, 0xFC, 0x7F, 0xE1, 0xFF, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0xFC, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x6F, 0xFF, 0x60, 0x00,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x0C,
  0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x7F, 0xEF, 0xDF, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F,
  0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x38, 0xE7, 0x8E, 0x70, 0xEE, 0x0E, 0xE0,
  0xFF, 0x0F, 0xF0, 0xF7, 0x0E, 0x38, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCF, 0xC7, 0xE6, 0xFF, 0x7F, 0xB7,
  0xFB, 0xFD, 0xE1, 0xF0, 0xFE, 0x0F, 0x83, 0xF0, 0x38, 0x1F, 0x81, 0xC0,
  0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0,
  0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07,
  0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07,
  0x03, 0x80, 0xCF, 0xCD, 0xFE, 0xDD, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x1F, 0xC0,
  0xFF, 0x87, 0xDF, 0x1C, 0x1C, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xB8, 0x0E, 0xF0, 0x39, 0xC1, 0xC7, 0xDF, 0x0F, 0xF8, 0x1F, 0xC0, 0xC7,
  0xC6, 0x7F, 0x37, 0x7D, 0xE0, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x7F, 0x83, 0xBF, 0x7D, 0xDF, 0xCE, 0x7C, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x1F, 0x1C, 0xFE, 0x77, 0xDD, 0xDC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3D, 0xC1, 0xF7, 0xDF, 0xCF, 0xEF, 0x1F,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xC7, 0xE7, 0xB7, 0xDB, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x00, 0x1F, 0xC7, 0xFD, 0xE7, 0x78, 0x2E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x3F, 0xFF, 0x7F, 0xE7, 0xF8, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0xFB, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x7B, 0x3F, 0x8F, 0xC0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0x83, 0xDF, 0xFE, 0x7F,
  0x31, 0xF1, 0x80, 0xE0, 0x1D, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x70, 0x38,
  0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38,
  0x1C, 0xE0, 0x33, 0x80, 0xEE, 0x03, 0xB0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x3C, 0x0E, 0xE0, 0x78, 0x1D, 0xC0, 0xF0,
  0x3B, 0x83, 0xE0, 0xF7, 0x07, 0xC1, 0xC7, 0x0F, 0xC3, 0x8E, 0x1B, 0x87,
  0x1C, 0x37, 0x0E, 0x38, 0xE6, 0x38, 0x71, 0xCC, 0x70, 0x73, 0x9C, 0xE0,
  0xE6, 0x39, 0xC1, 0xCC, 0x73, 0x83, 0xB8, 0x6E, 0x07, 0x70, 0xDC, 0x06,
  0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x7B, 0x83, 0x9C, 0x3C, 0xF1, 0xC3,
  0x8E, 0x1C, 0xE0, 0x77, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1F,
  0x01, 0xF8, 0x0F, 0xE0, 0x77, 0x07, 0x3C, 0x38, 0xE3, 0x87, 0x1C, 0x1D,
  0xC0, 0xEE, 0x07, 0x80, 0xF0, 0x1D, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x78,
  0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0x71, 0xC1, 0xC7, 0x07,
  0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70,
  0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xC1, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0xF8, 0x3C, 0x0F, 0xC0,
  0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3E, 0x07, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x3E,
  0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x7C, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC1, 0xF0, 0xF8, 0x3C, 0x00, 0x7E, 0x03, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F,
  0xE8, 0x03, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 28, 9, 2, -28 },
  { 19, 11, 10, 15, 2, -28 },
  { 33, 16, 28, 18, 1, -28 },
  { 89, 13, 32, 17, 2, -30 },
  { 141, 22, 28, 26, 2, -28 },
  { 218, 18, 28, 19, 1, -28 },
  { 281, 4, 10, 8, 2, -28 },
  { 286, 8, 34, 11, 2, -28 },
  { 320, 8, 34, 11, 1, -28 },
  { 354, 13, 13, 15, 1, -30 },
  { 376, 15, 18, 17, 1, -23 },
  { 410, 6, 9, 9, 1, -4 },
  { 417, 9, 3, 11, 1, -12 },
  { 421, 5, 5, 9, 2, -5 },
  { 425, 13, 28, 14, 1, -28 },
  { 471, 13, 28, 17, 2, -28 },
  { 517, 9, 28, 17, 2, -28 },
  { 549, 14, 28, 17, 1, -28 },
  { 598, 14, 28, 17, 1, -28 },
  { 647, 15, 28, 17, 1, -28 },
  { 700, 13, 28, 17, 2, -28 },
  { 746, 13, 28, 17, 2, -28 },
  { 792, 14, 28, 17, 1, -28 },
  { 841, 14, 28, 17, 1, -28 },
  { 890, 14, 28, 17, 1, -28 },
  { 939, 5, 21, 9, 2, -21 },
  { 953, 6, 26, 9, 1, -21 },
  { 973, 15, 18, 17, 1, -23 },
  { 1007, 15, 11, 17, 1, -19 },
  { 1028, 15, 18, 17, 1, -23 },
  { 1062, 12, 28, 12, 0, -28 },
  { 1104, 22, 31, 25, 2, -28 },
  { 1190, 18, 28, 18, 0, -28 },
  { 1253, 14, 28, 19, 3, -28 },
  { 1302, 14, 28, 17, 2, -28 },
  { 1351, 15, 28, 20, 3, -28 },
  { 1404, 11, 28, 16, 3, -28 },
  { 1443, 11, 28, 15, 3, -28 },
  { 1482, 17, 28, 21, 2, -28 },
  { 1542, 15, 28, 21, 3, -28 },
  { 1595, 9, 28, 11, 1, -28 },
  { 1627, 8, 36, 9, -2, -28 },
  { 1663, 15, 28, 17, 3, -28 },
  { 1716, 11, 28, 14, 3, -28 },
  { 1755, 22, 28, 28, 3, -28 },
  { 1832, 16, 28, 22, 3, -28 },
  { 1888, 18, 28, 21, 2, -28 },
  { 1951, 13, 28, 17, 3, -28 },
  { 1997, 18, 35, 21, 2, -28 },
  { 2076, 14, 28, 18, 3, -28 },
  { 2125, 14, 28, 16, 1, -28 },
  { 2174, 14, 28, 15, 0, -28 },
  { 2223, 15, 28, 20, 3, -28 },
  { 2276, 17, 28, 17, 0, -28 },
  { 2336, 28, 28, 28, 0, -28 },
  { 2434, 15, 28, 16, 0, -28 },
  { 2487, 15, 28, 15, 0, -28 },
  { 2540, 12, 28, 14, 1, -28 },
  { 2582, 8, 34, 12, 3, -28 },
  { 2616, 13, 28, 14, 1, -28 },
  { 2662, 8, 34, 12, 1, -28 },
  { 2696, 16, 15, 17, 1, -28 },
  { 2726, 17, 3, 17, 0, 3 },
  { 2733, 7, 6, 10, 2, -30 },
  { 2739, 13, 21, 16, 1, -21 },
  { 2774, 13, 30, 18, 3, -30 },
  { 2823, 11, 21, 14, 2, -21 },
  { 2852, 14, 30, 18, 2, -30 },
  { 2905, 13, 21, 16, 2, -21 },
  { 2940, 11, 30, 10, 0, -30 },
  { 2982, 14, 30, 18, 2, -21 },
  { 3035, 12, 30, 18, 3, -30 },
  { 3080, 4, 29, 8, 2, -29 },
  { 3095, 7, 38, 8, -1, -29 },
  { 3129, 12, 30, 16, 3, -30 },
  { 3174, 3, 30, 8, 3, -30 },
  { 3186, 21, 21, 27, 3, -21 },
  { 3242, 12, 21, 18, 3, -21 },
  { 3274, 14, 21, 17, 2, -21 },
  { 3311, 13, 30, 18, 3, -21 },
  { 3360, 14, 30, 18, 2, -21 },
  { 3413, 9, 21, 12, 3, -21 },
  { 3437, 11, 21, 13, 1, -21 },
  { 3466, 9, 26, 10, 1, -26 },
  { 3496, 13, 21, 18, 2, -21 },
  { 3531, 14, 21, 14, 0, -21 },
  { 3568, 23, 21, 24, 0, -21 },
  { 3629, 13, 21, 15, 1, -21 },
  { 3664, 14, 30, 14, 0, -21 },
  { 3717, 10, 21, 12, 1, -21 },
  { 3744, 10, 34, 14, 2, -28 },
  { 3787, 3, 39, 16, 6, -30 },
  { 3802, 10, 34, 14, 2, -28 },
  { 3845, 15, 5, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Regular39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR39PT7B_H_
