#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xB6, 0xDB, 0x01, 0x7F, 0xC0, 0xE7, 0xE7,
  0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC3, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18,
  0x81, 0x8C, 0x0C, 0x63, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x30,
  0x31, 0x83, 0x18, 0x7F, 0xFB, 0xFF, 0xC6, 0x30, 0x31, 0x81, 0x8C, 0x0C,
  0x60, 0x63, 0x02, 0x30, 0x31, 0x80, 0x04, 0x00, 0x80, 0x10, 0x0F, 0xC3,
  0xFE, 0xE9, 0xB9, 0x07, 0x20, 0xC4, 0x1C, 0x81, 0xD0, 0x3E, 0x01, 0xF0,
  0x0F, 0x01, 0x70, 0x27, 0x04, 0x60, 0x8C, 0x11, 0xC2, 0x7F, 0xFC, 0xFF,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x3C, 0x0C, 0x1F, 0x83, 0x06, 0x61,
  0x83, 0x18, 0x60, 0xC6, 0x38, 0x31, 0x8C, 0x0C, 0x63, 0x03, 0x19, 0xC0,
  0xC6, 0x63, 0x31, 0x9B, 0xE6, 0x6C, 0xDD, 0xFB, 0x33, 0x3C, 0xD8, 0xC0,
  0x66, 0x30, 0x19, 0x8C, 0x06, 0x63, 0x03, 0x18, 0xC0, 0xC6, 0x30, 0x31,
  0x8C, 0x18, 0x33, 0x06, 0x0F, 0x83, 0x81, 0xE0, 0x1F, 0x00, 0xFE, 0x03,
  0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x38, 0x0E, 0xE0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x8E, 0x77, 0x3B, 0x8C, 0xEE, 0x3B, 0x38, 0x6C,
  0xC1, 0xF3, 0x83, 0x8E, 0x0F, 0x3C, 0x7C, 0x7F, 0xB8, 0xFC, 0x70, 0xFF,
  0xED, 0xB6, 0x1C, 0x63, 0x8C, 0x71, 0x8E, 0x38, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0E, 0x38, 0x61, 0x87, 0x0C, 0x38, 0x60, 0xC0, 0xE0,
  0xC1, 0xC1, 0x83, 0x83, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC3,
  0x06, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x0E, 0x18, 0x70, 0xC3, 0x00, 0x0C,
  0x03, 0x00, 0xC2, 0x31, 0xFF, 0xFF, 0xF1, 0xE0, 0x7C, 0x33, 0x1C, 0xE1,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0xFF, 0xFF,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x77, 0x77, 0x66,
  0xEC, 0xFF, 0xFF, 0xF8, 0x5F, 0xF0, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x1F, 0x07,
  0xF0, 0xC7, 0x38, 0xE6, 0x0C, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xEC, 0x19, 0xC7,
  0x3C, 0xE3, 0xF8, 0x3E, 0x00, 0x0E, 0x3C, 0xFB, 0xBE, 0x68, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0x3F, 0x1F, 0xF1, 0x87, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0x1F, 0xF1, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x87, 0xE0, 0xF8, 0x1F,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x60, 0xEF,
  0xF9, 0xFE, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xDC,
  0x0D, 0xC1, 0x9C, 0x19, 0xC3, 0x1C, 0x31, 0xC6, 0x1C, 0x61, 0xCE, 0x1C,
  0xC1, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0xFF, 0xBF, 0xEE, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xD8, 0x3F,
  0xCF, 0xF8, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3A,
  0x1E, 0xFF, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0xF0, 0x1C, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x67, 0x1D, 0xFB, 0xE7, 0x78, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3B, 0x07, 0x60, 0xEC, 0x1D, 0xC3, 0x9C, 0xE3, 0xFC, 0x3F, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x1F, 0x87, 0xF9, 0xC7, 0x30, 0x76,
  0x0E, 0xC1, 0xD8, 0x3B, 0x8E, 0x39, 0xC3, 0xF0, 0x38, 0x1F, 0xC7, 0x1C,
  0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB8, 0x77, 0xFC, 0x7F,
  0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1D, 0xC7, 0xBD, 0xF3, 0xFE, 0x39, 0xC0, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0xC7, 0xF0, 0xFC, 0x00, 0x5F, 0xF0, 0x00, 0x00,
  0x00, 0xBF, 0xE0, 0x27, 0x77, 0x00, 0x00, 0x00, 0x00, 0x03, 0x77, 0x76,
  0x6E, 0xC0, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x06, 0x00, 0x40, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x07, 0x03, 0xC1, 0xE0, 0xF0,
  0x78, 0x0E, 0x01, 0x00, 0x00, 0x7F, 0x7F, 0x90, 0xE0, 0x30, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x03, 0x83, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x00,
  0x00, 0x06, 0x07, 0x83, 0xC0, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xC0,
  0x60, 0x60, 0x0C, 0x38, 0x03, 0x8C, 0x00, 0x67, 0x1F, 0x99, 0x8E, 0xE6,
  0x63, 0x18, 0xD8, 0xCE, 0x36, 0x63, 0x8D, 0x98, 0xE3, 0xE6, 0x38, 0xF9,
  0x8E, 0x36, 0x63, 0x99, 0x9C, 0xE6, 0x63, 0xFB, 0x98, 0xF3, 0xC6, 0x08,
  0x41, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE1, 0x80, 0x1F, 0xE0,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0,
  0x37, 0x00, 0xCC, 0x07, 0x30, 0x1C, 0xE0, 0x73, 0x81, 0x86, 0x06, 0x18,
  0x38, 0x70, 0xFF, 0xC3, 0xFF, 0x0C, 0x0C, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0x98, 0x06, 0xE0, 0x1F, 0x80, 0x70, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCF, 0xFC, 0xFF, 0x0F, 0xFC,
  0xE0, 0xEE, 0x06, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x1E,
  0xFF, 0xCF, 0xF0, 0x0F, 0xE7, 0xFC, 0xE1, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x13, 0xFE, 0x1F, 0x80, 0xFF, 0x0F,
  0xFC, 0xE3, 0xCE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0xE0, 0xEE, 0x3C, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x0F, 0xF0, 0xFF,
  0xCE, 0x04, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1B, 0x80, 0xDC, 0x06, 0x78, 0x31, 0xFF, 0x87, 0xF8, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFE, 0xF8, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xCF,
  0xFF, 0xC0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F,
  0x3B, 0xF7, 0xC0, 0xE0, 0x7E, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38,
  0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xC0, 0xFE, 0x0F, 0xE0, 0xF7, 0x0E, 0x70,
  0xE3, 0x0E, 0x38, 0xE1, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF,
  0xFC, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x06,
  0xFF, 0x01, 0xBE, 0xC0, 0xEF, 0xB0, 0x33, 0xEC, 0x0C, 0xFB, 0x83, 0x3E,
  0x61, 0xCF, 0x98, 0x63, 0xE7, 0x18, 0xF8, 0xCE, 0x3E, 0x33, 0x0F, 0x8C,
  0xC3, 0xE3, 0xB0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x87, 0x83, 0xE0, 0xE0,
  0xF8, 0x30, 0x30, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE,
  0x0F, 0xB0, 0x7D, 0xC3, 0xE6, 0x1F, 0x38, 0xF9, 0xC7, 0xC6, 0x3E, 0x39,
  0xF0, 0xCF, 0x87, 0x7C, 0x1B, 0xE0, 0xDF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x03, 0xF0, 0x1C, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0xE0, 0x3B,
  0x80, 0xEE, 0x03, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x07,
  0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xE7, 0x07,
  0x1E, 0x3C, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0x87, 0x7F, 0xCF, 0xF1,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x00, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0xE0, 0x3B, 0x80, 0xEE,
  0x03, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x07, 0xC0, 0x1B,
  0x00, 0x6C, 0x01, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xE7, 0x07, 0x1E, 0x3C,
  0x3F, 0xE0, 0x7F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0xFF, 0x0F, 0xF8, 0xE3, 0xCE, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x1C, 0xE7, 0xCF, 0xF0, 0xFF, 0x0E, 0x70, 0xE3, 0x8E,
  0x38, 0xE1, 0x8E, 0x1C, 0xE0, 0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0x1F, 0xC7,
  0xF9, 0xC3, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x61, 0xEF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0xE0, 0x1F, 0x80,
  0x66, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xC3, 0x07, 0x0C, 0x1C, 0x38,
  0x70, 0xE1, 0x81, 0x86, 0x06, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0xCC, 0x03,
  0x70, 0x0D, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x76, 0x07, 0x81, 0xD8, 0x1E, 0x06, 0x70,
  0x78, 0x19, 0xC1, 0xF0, 0xE7, 0x06, 0xC3, 0x8C, 0x3B, 0x0E, 0x30, 0xCC,
  0x30, 0xE3, 0x30, 0xC3, 0x8C, 0xE7, 0x06, 0x33, 0x9C, 0x19, 0xC6, 0x70,
  0x66, 0x19, 0x81, 0xD8, 0x66, 0x07, 0x61, 0xB8, 0x0D, 0x87, 0xE0, 0x36,
  0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1C, 0x0F,
  0x00, 0x70, 0x77, 0x06, 0x30, 0xE3, 0x8E, 0x18, 0xC1, 0x9C, 0x1D, 0x80,
  0xD8, 0x0F, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0xD8, 0x1D, 0x81,
  0x9C, 0x38, 0xC3, 0x8C, 0x30, 0xE7, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x76,
  0x07, 0x70, 0x67, 0x0E, 0x30, 0xE3, 0x8C, 0x39, 0xC1, 0x98, 0x1D, 0x81,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xBF, 0xE0, 0x38, 0x0E,
  0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0,
  0x03, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x00, 0xDC, 0x0E, 0x60, 0x63, 0x87,
  0x0C, 0x30, 0x71, 0x81, 0x98, 0x0F, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0xC3, 0x06, 0x0C, 0x1F, 0x1F, 0xE2, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x7F, 0x7F, 0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3D, 0xFB,
  0x3C, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x78, 0xFF, 0x9B, 0x7B, 0x83, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0D, 0xE3, 0xB7, 0xF6, 0x7C, 0x0F,
  0x1F, 0xCE, 0x4E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x06, 0x03, 0x81, 0xC2, 0x7F, 0x1F, 0x80, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0xF3, 0x3F, 0x6F, 0x3D, 0xC3, 0xB0, 0x7E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xB0, 0x77, 0x0E,
  0xE3, 0xCF, 0xD8, 0xFB, 0x0F, 0x07, 0xF0, 0xC7, 0x38, 0x66, 0x0C, 0xC1,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C,
  0x11, 0xFE, 0x1F, 0xC0, 0x07, 0x8F, 0x87, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x7C, 0xFE, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1E, 0x67, 0xED, 0xE7, 0xB8,
  0x76, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x36,
  0x0E, 0xE1, 0xDC, 0x79, 0xFB, 0x1E, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x83, 0xDF, 0xF3, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xBC, 0xDF, 0xB6, 0xFE, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xDF, 0xA0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x31, 0xCE, 0x20, 0x00, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCC,
  0x6F, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x87,
  0xE1, 0xB8, 0xEE, 0x73, 0x98, 0xEE, 0x3B, 0x0D, 0xC3, 0xF8, 0xF6, 0x39,
  0xCE, 0x73, 0x8C, 0xE3, 0xB8, 0x6E, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x1E, 0x6F, 0xDF, 0xBC, 0xED, 0xFC,
  0x3C, 0x7E, 0x1C, 0x1F, 0x0E, 0x0F, 0x87, 0x07, 0xC3, 0x83, 0xE1, 0xC1,
  0xF0, 0xE0, 0xF8, 0x70, 0x7C, 0x38, 0x3E, 0x1C, 0x1F, 0x0E, 0x0F, 0x87,
  0x07, 0xC3, 0x83, 0xE1, 0xC1, 0x80, 0xCF, 0x37, 0xED, 0xBF, 0x87, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xC0, 0x0F, 0x03, 0xF8, 0x39, 0xC7, 0x0E, 0x60, 0xE6,
  0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x06, 0x60, 0x67,
  0x0E, 0x70, 0xC3, 0xFC, 0x1F, 0x80, 0xCF, 0x1B, 0xF3, 0x47, 0x70, 0x6E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xBC, 0x76, 0xFE, 0xEF, 0x9C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x1E, 0x67, 0xED, 0xEF, 0xB8, 0x76, 0x0E, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x36, 0x0E, 0xE1, 0xDC, 0x79,
  0xFB, 0x1E, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0xCF, 0xBF, 0x7F, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0x3E, 0x3F, 0xBC, 0xDC, 0x0C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x81, 0xC0, 0x60, 0x38, 0x1A, 0x1D, 0xFE, 0xFE, 0x00, 0x30,
  0x61, 0xC3, 0xEF, 0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xF9, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xE1, 0xF8, 0x7E, 0x3D,
  0xFB, 0x3C, 0xC0, 0xE0, 0x7C, 0x1D, 0x83, 0xB0, 0x77, 0x0C, 0xE1, 0x8C,
  0x71, 0x8E, 0x39, 0x87, 0x30, 0x6E, 0x0D, 0xC1, 0xB0, 0x3E, 0x03, 0xC0,
  0x70, 0x0E, 0x00, 0xE0, 0xE0, 0xD8, 0x38, 0x36, 0x0E, 0x0D, 0x87, 0x87,
  0x71, 0xB1, 0xDC, 0x6C, 0x63, 0x1B, 0x18, 0xC6, 0xC6, 0x33, 0x33, 0x8E,
  0xCE, 0xC3, 0xB1, 0xB0, 0x6C, 0x6C, 0x1B, 0x1B, 0x07, 0x87, 0xC1, 0xE1,
  0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x00, 0x60, 0xEE, 0x18, 0xC7, 0x1C, 0xE1,
  0x98, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x01, 0xE0, 0x7C, 0x0D, 0xC3, 0x98,
  0x73, 0x8C, 0x73, 0x86, 0xE0, 0xE0, 0xE0, 0x7C, 0x1D, 0x83, 0xB0, 0x77,
  0x0C, 0xE1, 0x8C, 0x71, 0x8E, 0x39, 0x83, 0x30, 0x6E, 0x0D, 0xC1, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38,
  0x3E, 0x07, 0x80, 0xFF, 0xFF, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38,
  0x38, 0x30, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0x07, 0x87, 0xC3, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0x87, 0x01,
  0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E,
  0x03, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x7C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01,
  0x80, 0xF8, 0x1C, 0x3C, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x38, 0x7C, 0x38, 0x00, 0x78, 0x3F, 0xC7, 0x3F, 0xC1, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 22, 7, 2, -22 },
  { 10, 8, 8, 12, 2, -22 },
  { 18, 13, 22, 14, 1, -22 },
  { 54, 11, 26, 13, 1, -24 },
  { 90, 18, 22, 21, 1, -22 },
  { 140, 14, 22, 15, 1, -22 },
  { 179, 3, 8, 6, 2, -22 },
  { 182, 6, 27, 9, 2, -22 },
  { 203, 7, 27, 9, 1, -22 },
  { 227, 10, 11, 12, 1, -24 },
  { 241, 11, 14, 13, 1, -18 },
  { 261, 4, 8, 7, 1, -4 },
  { 265, 7, 3, 9, 1, -10 },
  { 268, 3, 4, 7, 2, -4 },
  { 270, 10, 22, 12, 1, -22 },
  { 298, 11, 22, 13, 1, -22 },
  { 329, 7, 22, 13, 2, -22 },
  { 349, 11, 22, 13, 1, -22 },
  { 380, 11, 22, 13, 1, -22 },
  { 411, 12, 22, 13, 1, -22 },
  { 444, 10, 22, 13, 2, -22 },
  { 472, 11, 22, 13, 1, -22 },
  { 503, 11, 22, 13, 1, -22 },
  { 534, 11, 22, 13, 1, -22 },
  { 565, 11, 22, 13, 1, -22 },
  { 596, 3, 17, 7, 2, -17 },
  { 603, 4, 21, 7, 1, -17 },
  { 614, 11, 14, 13, 1, -18 },
  { 634, 11, 8, 13, 1, -15 },
  { 645, 11, 14, 13, 1, -18 },
  { 665, 9, 22, 10, 0, -22 },
  { 690, 18, 25, 20, 1, -22 },
  { 747, 14, 22, 14, 0, -22 },
  { 786, 12, 22, 15, 2, -22 },
  { 819, 11, 22, 14, 2, -22 },
  { 850, 12, 22, 16, 2, -22 },
  { 883, 9, 22, 12, 2, -22 },
  { 908, 9, 22, 12, 2, -22 },
  { 933, 13, 22, 17, 2, -22 },
  { 969, 12, 22, 17, 2, -22 },
  { 1002, 7, 22, 9, 1, -22 },
  { 1022, 7, 28, 7, -2, -22 },
  { 1047, 12, 22, 14, 2, -22 },
  { 1080, 9, 22, 12, 2, -22 },
  { 1105, 18, 22, 22, 2, -22 },
  { 1155, 13, 22, 18, 2, -22 },
  { 1191, 14, 22, 17, 2, -22 },
  { 1230, 11, 22, 14, 2, -22 },
  { 1261, 14, 27, 17, 2, -22 },
  { 1309, 12, 22, 14, 2, -22 },
  { 1342, 11, 22, 13, 1, -22 },
  { 1373, 11, 22, 12, 0, -22 },
  { 1404, 12, 22, 16, 2, -22 },
  { 1437, 14, 22, 14, 0, -22 },
  { 1476, 22, 22, 22, 0, -22 },
  { 1537, 12, 22, 12, 0, -22 },
  { 1570, 12, 22, 12, 0, -22 },
  { 1603, 10, 22, 11, 1, -22 },
  { 1631, 7, 27, 10, 2, -22 },
  { 1655, 10, 22, 12, 1, -22 },
  { 1683, 6, 27, 10, 1, -22 },
  { 1704, 13, 12, 14, 0, -22 },
  { 1724, 14, 2, 14, 0, 3 },
  { 1728, 6, 5, 8, 1, -24 },
  { 1732, 10, 17, 13, 1, -17 },
  { 1754, 11, 24, 14, 2, -24 },
  { 1787, 9, 17, 11, 1, -17 },
  { 1807, 11, 24, 14, 1, -24 },
  { 1840, 11, 17, 13, 1, -17 },
  { 1864, 9, 24, 8, 0, -24 },
  { 1891, 11, 24, 14, 1, -17 },
  { 1924, 10, 24, 14, 2, -24 },
  { 1954, 3, 23, 7, 2, -23 },
  { 1963, 5, 30, 7, 0, -23 },
  { 1982, 10, 24, 12, 2, -24 },
  { 2012, 3, 24, 7, 2, -24 },
  { 2021, 17, 17, 21, 2, -17 },
  { 2058, 10, 17, 14, 2, -17 },
  { 2080, 12, 17, 14, 1, -17 },
  { 2106, 11, 24, 14, 2, -17 },
  { 2139, 11, 24, 14, 1, -17 },
  { 2172, 7, 17, 9, 2, -17 },
  { 2187, 9, 17, 11, 1, -17 },
  { 2207, 7, 20, 8, 1, -20 },
  { 2225, 10, 17, 14, 2, -17 },
  { 2247, 11, 17, 11, 0, -17 },
  { 2271, 18, 17, 19, 0, -17 },
  { 2310, 11, 17, 12, 0, -17 },
  { 2334, 11, 24, 11, 0, -17 },
  { 2367, 8, 17, 9, 1, -17 },
  { 2384, 9, 27, 11, 1, -22 },
  { 2415, 2, 31, 13, 5, -24 },
  { 2423, 9, 27, 11, 1, -22 },
  { 2454, 11, 4, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Regular31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR31PT7B_H_
