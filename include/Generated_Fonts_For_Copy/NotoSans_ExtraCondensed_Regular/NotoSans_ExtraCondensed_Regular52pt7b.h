#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x80, 0x00, 0x00,
  0x1E, 0x7F, 0xFF, 0xFF, 0x78, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7B, 0xE1, 0xEF, 0x87, 0x9C, 0x1E, 0x70, 0x79, 0xC1, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0E,
  0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07,
  0x07, 0x80, 0x1C, 0x1C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x0E, 0x0F, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x81,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xDF, 0x9F, 0x30, 0x6F, 0x8C, 0x03, 0xC3,
  0x00, 0xF0, 0xC0, 0x3C, 0x30, 0x0F, 0x0C, 0x03, 0xC3, 0x00, 0x78, 0xC0,
  0x1F, 0x30, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xCF, 0x80, 0x31, 0xF0, 0x0C, 0x3C, 0x03,
  0x0F, 0x00, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x3C, 0x03, 0x0F, 0xC0, 0xC7,
  0xBF, 0x37, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x78, 0x01, 0xFF,
  0x00, 0xF0, 0x07, 0x8E, 0x01, 0xC0, 0x0E, 0x1C, 0x07, 0x80, 0x1C, 0x3C,
  0x0E, 0x00, 0x78, 0x78, 0x1C, 0x00, 0xF0, 0x70, 0x78, 0x01, 0xE0, 0xE0,
  0xE0, 0x03, 0xC1, 0xC1, 0xC0, 0x07, 0x83, 0x87, 0x80, 0x0F, 0x07, 0x0E,
  0x00, 0x1E, 0x0E, 0x1C, 0x00, 0x3C, 0x1C, 0x78, 0x00, 0x78, 0x38, 0xE0,
  0xE0, 0xF0, 0xF1, 0xC7, 0xF0, 0xE1, 0xE7, 0x9F, 0xE1, 0xC3, 0x8E, 0x3D,
  0xE3, 0xC7, 0x3C, 0xF1, 0xC3, 0xFE, 0x79, 0xC3, 0xC7, 0xF8, 0xE3, 0x83,
  0x87, 0xE3, 0xC7, 0x07, 0x03, 0x07, 0x8E, 0x0E, 0x00, 0x0E, 0x3C, 0x1C,
  0x00, 0x3C, 0x78, 0x38, 0x00, 0x70, 0xF0, 0x78, 0x00, 0xE1, 0xE0, 0xE0,
  0x03, 0xC3, 0xC1, 0xC0, 0x07, 0x07, 0x83, 0x80, 0x0E, 0x07, 0x07, 0x00,
  0x3C, 0x0E, 0x0E, 0x00, 0x70, 0x1C, 0x3C, 0x00, 0xE0, 0x3C, 0x78, 0x03,
  0xC0, 0x38, 0xE0, 0x07, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x07, 0x87, 0x9E, 0x0F, 0x1F, 0x3E, 0x1E, 0x7C, 0x3C, 0x3C,
  0xF0, 0x3C, 0x79, 0xE0, 0x7D, 0xF3, 0xC0, 0x7B, 0xC7, 0x80, 0xFF, 0x8F,
  0x00, 0xFF, 0x1E, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x78, 0x03, 0xF0, 0xF8,
  0x0F, 0xE1, 0xF0, 0x3F, 0xE1, 0xF9, 0xFB, 0xE3, 0xFF, 0xE7, 0xC3, 0xFF,
  0x87, 0xC3, 0xFE, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEE, 0x73, 0x9C, 0xE7, 0x00, 0x03, 0xE0, 0x70, 0x1E, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3E, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x04, 0x0E, 0x0B, 0xE7, 0x3D,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xF7,
  0x80, 0xF3, 0xC0, 0xF8, 0xF0, 0x78, 0x7C, 0x1C, 0x1C, 0x02, 0x08, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xFF, 0xFD, 0xE0, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0x3F, 0x0F, 0x87,
  0xC3, 0xC0, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7D,
  0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x3E, 0x3C,
  0x0F, 0x0F, 0x87, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x04, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF,
  0x3E, 0xF7, 0xCF, 0xF8, 0xF3, 0x0F, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x7F, 0x1C, 0x07,
  0xC2, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0xFC, 0x3F,
  0x1C, 0x07, 0xE4, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0xB0, 0x07, 0xEF, 0x8F, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00,
  0x1E, 0xF0, 0x00, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x73, 0xE0, 0x07, 0x9F,
  0x00, 0x38, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xE1, 0xF0, 0x0F,
  0x0F, 0x80, 0x70, 0x7C, 0x07, 0x83, 0xE0, 0x38, 0x1F, 0x03, 0xC0, 0xF8,
  0x1C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xDF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x10, 0x1F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x80, 0x3E, 0x78, 0x7F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFE, 0x00, 0x10, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xE1, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x82, 0x01, 0xE7, 0xF0, 0xFB, 0xFE, 0x3D, 0xFF, 0xCF, 0x73, 0xFB, 0xF8,
  0x3E, 0xFC, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7,
  0xC0, 0x7D, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xFB, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x03,
  0xE7, 0x80, 0x78, 0x78, 0x1F, 0x0F, 0x83, 0xC0, 0xF9, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7E, 0x7E,
  0x0F, 0x07, 0xC3, 0xE0, 0x7C, 0x78, 0x07, 0xDF, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x1E,
  0xF8, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x7E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3E, 0xF8,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0xFD,
  0xF0, 0x7F, 0x3F, 0x7B, 0xCF, 0xFE, 0xF1, 0xFF, 0x7C, 0x3F, 0x9E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x02, 0x1F, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x7B, 0xEF, 0xFF,
  0xFD, 0xE3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0x3C, 0xF9, 0xFB, 0xF7, 0xE7, 0x86,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x9F, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFD,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFC, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC3,
  0xC0, 0x7F, 0x87, 0x0F, 0x07, 0xFE, 0x1E, 0x38, 0x1F, 0xF8, 0x79, 0xE0,
  0xF1, 0xE0, 0xE7, 0x87, 0x87, 0x83, 0x9C, 0x1E, 0x1E, 0x0E, 0x70, 0x70,
  0x78, 0x39, 0xC1, 0xC1, 0xE0, 0xF7, 0x07, 0x07, 0x83, 0xDC, 0x3C, 0x1E,
  0x0E, 0x70, 0xF0, 0x78, 0x3B, 0xC3, 0xC1, 0xE0, 0xEF, 0x0F, 0x07, 0x83,
  0x9C, 0x3C, 0x1E, 0x0E, 0x70, 0x70, 0x78, 0x39, 0xC1, 0xC3, 0xE1, 0xE7,
  0x07, 0x8D, 0x87, 0x1C, 0x1E, 0x77, 0x3C, 0x78, 0x3F, 0xDF, 0xE1, 0xE0,
  0xFE, 0x3F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x04, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xCF,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF8,
  0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0xC0,
  0x3E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3C, 0x01, 0xF0, 0x78,
  0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x8F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x7D, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x0F, 0xBC, 0x01, 0xF7,
  0x80, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xEF,
  0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x81, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x78, 0x3F, 0xCF, 0x00, 0xF9, 0xE0, 0x0F, 0xBC,
  0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF0,
  0x0F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0xFE, 0x3C, 0x3F,
  0x00, 0x8F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x08, 0x3F, 0xDF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0xFC, 0xF0,
  0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0,
  0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0x0F, 0x83, 0xF0, 0x03, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x7C, 0x3F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x7F, 0xEF, 0xF9, 0xFE, 0x3F, 0x80, 0xF0,
  0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0,
  0x3E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC3,
  0xE0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E,
  0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xDF,
  0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F,
  0x83, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x3C, 0x03,
  0xC7, 0x80, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x01,
  0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3B, 0xFF, 0xC0,
  0x01, 0xEF, 0xF7, 0x00, 0x07, 0xBF, 0xDE, 0x00, 0x1D, 0xFF, 0x78, 0x00,
  0xF7, 0xFD, 0xE0, 0x03, 0xDF, 0xF3, 0xC0, 0x0F, 0x7F, 0xCF, 0x00, 0x39,
  0xFF, 0x3C, 0x01, 0xE7, 0xFC, 0x70, 0x07, 0x9F, 0xF1, 0xE0, 0x1C, 0x7F,
  0xC7, 0x80, 0xF1, 0xFF, 0x1E, 0x03, 0xC7, 0xFC, 0x3C, 0x0F, 0x1F, 0xF0,
  0xF0, 0x38, 0x7F, 0xC3, 0xC1, 0xE1, 0xFF, 0x07, 0x07, 0x87, 0xFC, 0x1E,
  0x1C, 0x1F, 0xF0, 0x78, 0xF0, 0x7F, 0xC1, 0xE3, 0xC1, 0xFF, 0x03, 0xCF,
  0x07, 0xFC, 0x0F, 0x38, 0x1F, 0xF0, 0x3D, 0xE0, 0x7F, 0xC0, 0x77, 0x81,
  0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x1F, 0xF0,
  0x07, 0x80, 0x7C, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xF7, 0x80, 0x3F, 0xDE, 0x00, 0xFF, 0x7C, 0x03, 0xFC, 0xF0, 0x0F,
  0xF3, 0xC0, 0x3F, 0xC7, 0x80, 0xFF, 0x1E, 0x03, 0xFC, 0x3C, 0x0F, 0xF0,
  0xF0, 0x3F, 0xC3, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x3C,
  0x3F, 0xC0, 0xF0, 0xFF, 0x03, 0xE3, 0xFC, 0x07, 0x8F, 0xF0, 0x1F, 0x3F,
  0xC0, 0x3C, 0xFF, 0x00, 0xF3, 0xFC, 0x01, 0xEF, 0xF0, 0x07, 0xBF, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x7E, 0x07,
  0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x9F,
  0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x03,
  0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x3F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF,
  0x83, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x7F, 0x07,
  0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x9F,
  0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x03,
  0xF1, 0xE0, 0x3F, 0x3C, 0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03,
  0xE7, 0x80, 0x7C, 0xF0, 0x1F, 0x1E, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E,
  0x3C, 0x03, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x1F,
  0x78, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xBF, 0x1F, 0x80, 0xC7, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x80, 0x0F, 0xB8, 0x07, 0xCF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x03, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x30,
  0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x8F, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xC0, 0x07, 0xDE, 0x00, 0x3E,
  0x00, 0x3E, 0xF0, 0x01, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0x0F, 0x3E,
  0x00, 0x7E, 0x00, 0x78, 0xF0, 0x07, 0xF0, 0x07, 0xC7, 0x80, 0x3F, 0x80,
  0x3E, 0x3C, 0x01, 0xDE, 0x01, 0xE1, 0xF0, 0x0E, 0xF0, 0x0F, 0x0F, 0x80,
  0x77, 0x80, 0x78, 0x3C, 0x07, 0xBC, 0x07, 0xC1, 0xE0, 0x3C, 0xE0, 0x3E,
  0x0F, 0x01, 0xE7, 0x81, 0xE0, 0x78, 0x0E, 0x3C, 0x0F, 0x03, 0xE0, 0x71,
  0xE0, 0x78, 0x0F, 0x07, 0x8F, 0x07, 0xC0, 0x78, 0x3C, 0x38, 0x3E, 0x03,
  0xC1, 0xE1, 0xC1, 0xE0, 0x1E, 0x0E, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x78,
  0x78, 0x03, 0xC7, 0x83, 0xC7, 0xC0, 0x1E, 0x3C, 0x0E, 0x3E, 0x00, 0xF1,
  0xE0, 0x71, 0xE0, 0x07, 0x8E, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x1E, 0x78,
  0x00, 0xF7, 0x80, 0xF3, 0xC0, 0x07, 0xBC, 0x03, 0xBE, 0x00, 0x3D, 0xE0,
  0x1D, 0xE0, 0x01, 0xEE, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF3, 0xC0, 0x1F, 0x3E, 0x01, 0xE1,
  0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x78,
  0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3D, 0xF0, 0x03, 0xDE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03,
  0xDE, 0x00, 0x3D, 0xE0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x7C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C,
  0x3E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x00,
  0xF0, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x3C,
  0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0x81,
  0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x79, 0xF0,
  0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0x73,
  0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x1C, 0x3E, 0x10, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F,
  0x8F, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x77, 0x7F, 0xF7, 0x3F,
  0xE7, 0x1F, 0xC7, 0x06, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x9F, 0xC1,
  0xF7, 0xFC, 0x3D, 0xFF, 0xC7, 0xBC, 0xFC, 0xFE, 0x0F, 0x9F, 0x80, 0xFB,
  0xF0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x03, 0xDF,
  0x80, 0x7B, 0xF0, 0x1F, 0x7F, 0x03, 0xCF, 0x71, 0xF9, 0xEF, 0xFE, 0x3C,
  0xFF, 0xC7, 0x8F, 0xE0, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF0, 0xFC, 0xE3, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x0E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0,
  0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x7F, 0x3E, 0x1F, 0xF3, 0xC7,
  0xFF, 0x79, 0xF8, 0xEF, 0x3E, 0x0F, 0xEF, 0x80, 0xFD, 0xF0, 0x0F, 0xBC,
  0x01, 0xF7, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xF0,
  0x1F, 0x9E, 0x03, 0xF3, 0xF1, 0xDE, 0x3F, 0xFB, 0xC7, 0xFE, 0x78, 0x3F,
  0x8F, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8,
  0x7C, 0x3C, 0x0F, 0x1F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x02, 0x1F, 0x07,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0xF8,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x3F, 0xF3, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xF1, 0xE1, 0xFF,
  0x3C, 0x7F, 0xF7, 0x9F, 0x9E, 0xF3, 0xE0, 0xFE, 0xF8, 0x0F, 0xDE, 0x01,
  0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07,
  0xDF, 0x01, 0xF9, 0xE0, 0x7F, 0x3F, 0x1D, 0xE3, 0xFF, 0xBC, 0x7F, 0xE7,
  0x83, 0xF9, 0xF0, 0x18, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x10, 0x07, 0xC3, 0xC3, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x9F, 0xC7, 0xDF,
  0xF3, 0xDF, 0xFD, 0xEF, 0x7F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x77, 0xFF, 0xF7, 0x90,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x07, 0xC3, 0xE1,
  0xF0, 0x78, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7A,
  0x7D, 0xFE, 0xFE, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xBE, 0x03,
  0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83,
  0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xCF, 0x80, 0xF7,
  0xE0, 0x3D, 0xF8, 0x0F, 0xEF, 0x03, 0xF3, 0xC0, 0xFC, 0xF8, 0x3E, 0x1E,
  0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x8F, 0x81, 0xE3,
  0xE0, 0x7C, 0xF8, 0x0F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFC, 0x1F, 0xC7, 0x9F, 0xF1, 0xFF, 0x3D, 0xFF, 0xDF, 0xFD, 0xEE,
  0x7E, 0xE7, 0xEF, 0xC0, 0xFE, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x3F,
  0x01, 0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x3C, 0x03,
  0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xFC,
  0x03, 0xC0, 0x3F, 0xE0, 0x1E, 0x01, 0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x07,
  0x80, 0x7F, 0xC0, 0x3C, 0x03, 0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x00,
  0xFF, 0x80, 0x78, 0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xE0, 0x1E, 0x01, 0xFF,
  0x00, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x3C, 0x03, 0xFE, 0x01,
  0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0xF1, 0xFC, 0x79, 0xFF, 0x3D, 0xFF,
  0xDE, 0xE7, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x07, 0x9F, 0x01,
  0xF1, 0xF0, 0x3C, 0x3F, 0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x04, 0x00, 0xF1, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFC, 0x7B, 0x8F,
  0xCF, 0xE0, 0x79, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03,
  0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xEF, 0x80, 0x3D, 0xF8, 0x07, 0xBF, 0x01, 0xF7, 0xF0, 0x3C,
  0xF7, 0x1F, 0x9E, 0xFF, 0xE3, 0xEF, 0xFC, 0x7C, 0xFE, 0x0F, 0x83, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xF1, 0xE1, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0x8E, 0xF3,
  0xE0, 0xFE, 0xF8, 0x0F, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC,
  0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x01, 0xF9, 0xE0, 0x7F, 0x3F,
  0x1D, 0xE3, 0xFF, 0xBC, 0x7F, 0xE7, 0x83, 0xF9, 0xF0, 0x18, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFF, 0x7F, 0xF7, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0xFF, 0xF7, 0xFF,
  0xBF, 0x0E, 0xF0, 0x0B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xE0,
  0x1F, 0xF1, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x02, 0x00, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x11, 0xFF, 0x0F, 0xF0,
  0x7F, 0x01, 0x80, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x3F, 0x7E, 0x7B, 0x9F, 0xFD, 0xCF, 0xFC,
  0xE3, 0xFC, 0x70, 0x30, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xE3, 0xC0,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0xF0, 0x0F, 0x80, 0x3D, 0xE0, 0x1F, 0x80, 0xF3,
  0xC0, 0x3F, 0x01, 0xE7, 0xC0, 0x7E, 0x03, 0xC7, 0x81, 0xFC, 0x07, 0x8F,
  0x03, 0xB8, 0x0F, 0x1E, 0x07, 0x78, 0x3C, 0x3C, 0x0E, 0xF0, 0x78, 0x7C,
  0x3D, 0xE0, 0xF0, 0x78, 0x79, 0xC1, 0xE0, 0xF0, 0xF3, 0x83, 0x81, 0xE1,
  0xC7, 0x8F, 0x03, 0xC3, 0x8F, 0x1E, 0x03, 0xCF, 0x1E, 0x3C, 0x07, 0x9E,
  0x1C, 0x78, 0x0F, 0x3C, 0x39, 0xE0, 0x1E, 0x70, 0x7B, 0xC0, 0x3C, 0xE0,
  0xF7, 0x80, 0x39, 0xC1, 0xEF, 0x00, 0x7F, 0x81, 0xDE, 0x00, 0xFF, 0x03,
  0xB8, 0x01, 0xFC, 0x07, 0x70, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x07, 0x9E, 0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E,
  0x07, 0x87, 0x81, 0xE3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x7C, 0x0F, 0x1E, 0x03, 0xEF,
  0x80, 0x7B, 0xC0, 0x1F, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x1E,
  0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x05, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xF8, 0x07, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x7F, 0x01, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0x80, 0x00, 0x18, 0x00, 0x2F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0xFF, 0xA0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 37, 12, 3, -37 },
  { 29, 14, 13, 20, 3, -37 },
  { 52, 22, 37, 24, 1, -37 },
  { 154, 18, 43, 22, 2, -40 },
  { 251, 31, 38, 35, 2, -38 },
  { 399, 23, 39, 25, 2, -38 },
  { 512, 5, 13, 11, 3, -37 },
  { 521, 11, 45, 15, 3, -37 },
  { 583, 11, 45, 15, 2, -37 },
  { 645, 17, 18, 21, 2, -40 },
  { 684, 19, 25, 22, 2, -31 },
  { 744, 7, 13, 12, 2, -6 },
  { 756, 12, 4, 14, 1, -16 },
  { 762, 6, 6, 12, 3, -6 },
  { 767, 18, 37, 19, 1, -37 },
  { 851, 18, 39, 22, 2, -38 },
  { 939, 12, 37, 22, 3, -37 },
  { 995, 18, 38, 22, 2, -38 },
  { 1081, 18, 39, 22, 2, -38 },
  { 1169, 21, 37, 22, 1, -37 },
  { 1267, 17, 38, 22, 3, -37 },
  { 1348, 18, 39, 22, 2, -38 },
  { 1436, 18, 37, 22, 2, -37 },
  { 1520, 19, 39, 22, 2, -38 },
  { 1613, 18, 39, 22, 2, -38 },
  { 1701, 6, 28, 12, 3, -28 },
  { 1722, 7, 35, 12, 2, -28 },
  { 1753, 19, 23, 22, 2, -30 },
  { 1808, 19, 15, 22, 2, -26 },
  { 1844, 19, 23, 22, 2, -30 },
  { 1899, 14, 38, 17, 1, -38 },
  { 1966, 30, 41, 34, 2, -37 },
  { 2120, 23, 37, 23, 0, -37 },
  { 2227, 19, 37, 25, 4, -37 },
  { 2315, 19, 39, 23, 3, -38 },
  { 2408, 20, 37, 27, 4, -37 },
  { 2501, 15, 37, 21, 4, -37 },
  { 2571, 15, 37, 20, 4, -37 },
  { 2641, 23, 39, 28, 3, -38 },
  { 2754, 20, 37, 28, 4, -37 },
  { 2847, 11, 37, 15, 2, -37 },
  { 2898, 11, 47, 12, -3, -37 },
  { 2963, 19, 37, 23, 4, -37 },
  { 3051, 14, 37, 19, 4, -37 },
  { 3116, 30, 37, 37, 4, -37 },
  { 3255, 22, 37, 30, 4, -37 },
  { 3357, 23, 39, 29, 3, -38 },
  { 3470, 17, 37, 23, 4, -37 },
  { 3549, 23, 47, 29, 3, -38 },
  { 3685, 19, 37, 24, 4, -37 },
  { 3773, 18, 39, 21, 2, -38 },
  { 3861, 18, 37, 20, 1, -37 },
  { 3945, 21, 38, 27, 3, -37 },
  { 4045, 23, 37, 23, 0, -37 },
  { 4152, 37, 37, 37, 0, -37 },
  { 4324, 20, 37, 21, 0, -37 },
  { 4417, 20, 37, 20, 0, -37 },
  { 4510, 17, 37, 19, 1, -37 },
  { 4589, 11, 45, 16, 4, -37 },
  { 4651, 18, 37, 19, 1, -37 },
  { 4735, 10, 45, 16, 2, -37 },
  { 4792, 21, 20, 23, 1, -37 },
  { 4845, 23, 4, 23, 0, 4 },
  { 4857, 10, 8, 14, 2, -40 },
  { 4867, 16, 29, 22, 2, -28 },
  { 4925, 19, 41, 24, 3, -40 },
  { 5023, 15, 29, 18, 2, -28 },
  { 5078, 19, 41, 24, 2, -40 },
  { 5176, 18, 29, 22, 2, -28 },
  { 5242, 14, 40, 13, 0, -40 },
  { 5312, 19, 40, 24, 2, -28 },
  { 5407, 17, 40, 24, 3, -40 },
  { 5492, 5, 38, 11, 3, -38 },
  { 5516, 9, 50, 11, -1, -38 },
  { 5573, 18, 40, 21, 3, -40 },
  { 5663, 5, 40, 11, 3, -40 },
  { 5688, 29, 28, 35, 3, -28 },
  { 5790, 17, 28, 24, 3, -28 },
  { 5850, 19, 29, 23, 2, -28 },
  { 5919, 19, 40, 24, 3, -28 },
  { 6014, 19, 40, 24, 2, -28 },
  { 6109, 12, 28, 16, 3, -28 },
  { 6151, 14, 29, 18, 2, -28 },
  { 6202, 12, 35, 13, 1, -34 },
  { 6255, 17, 29, 24, 3, -28 },
  { 6317, 19, 28, 19, 0, -28 },
  { 6384, 31, 28, 31, 0, -28 },
  { 6493, 18, 28, 19, 1, -28 },
  { 6556, 19, 40, 19, 0, -28 },
  { 6651, 14, 28, 16, 1, -28 },
  { 6700, 15, 45, 19, 2, -37 },
  { 6785, 3, 52, 21, 9, -40 },
  { 6805, 15, 45, 19, 2, -37 },
  { 6890, 19, 7, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Regular52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR52PT7B_H_
