#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0xDF, 0x00, 0xCF, 0x9F, 0x3E,
  0x6C, 0xD8, 0xB1, 0x00, 0x18, 0x83, 0x10, 0x66, 0x0C, 0xC1, 0x99, 0xFF,
  0xFF, 0xF9, 0x88, 0x31, 0x06, 0x20, 0xCC, 0x7F, 0xEF, 0xFC, 0x46, 0x08,
  0xC3, 0x10, 0x62, 0x0C, 0x41, 0x98, 0x00, 0x08, 0x02, 0x00, 0x80, 0xFE,
  0x7F, 0xBA, 0x0C, 0x83, 0x20, 0xC8, 0x1A, 0x07, 0xC0, 0x7C, 0x0F, 0x82,
  0x60, 0x8C, 0x23, 0x09, 0xBA, 0xEF, 0xF0, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x00, 0x78, 0x30, 0x4C, 0x30, 0xCC, 0x60, 0xCC, 0x60, 0xCC, 0x60,
  0xC4, 0xC0, 0xCC, 0xC0, 0xCC, 0x9C, 0xCD, 0xBE, 0x6D, 0xB2, 0x79, 0x33,
  0x13, 0x23, 0x03, 0x23, 0x02, 0x23, 0x06, 0x23, 0x06, 0x23, 0x04, 0x33,
  0x0C, 0x3E, 0x0C, 0x1C, 0x08, 0x03, 0xE0, 0x37, 0x06, 0x30, 0x63, 0x06,
  0x30, 0x77, 0x03, 0x60, 0x3E, 0x01, 0xC0, 0x3C, 0x06, 0xC6, 0xE6, 0x6C,
  0x76, 0xC3, 0xCC, 0x3C, 0xC1, 0xCE, 0x3C, 0x7F, 0xE7, 0xE7, 0xFF, 0xFC,
  0x18, 0x63, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18,
  0x61, 0x87, 0x0C, 0x30, 0x60, 0xC0, 0xC1, 0x87, 0x0C, 0x30, 0xE1, 0x86,
  0x18, 0x61, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x61, 0x8C, 0x00,
  0x1C, 0x0C, 0x06, 0x19, 0x2F, 0xF8, 0xE0, 0xD0, 0x6C, 0x63, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFC, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x76, 0x66, 0xCC, 0xC0, 0xFF, 0xF0, 0xDF, 0x00,
  0x03, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x00, 0x08, 0x1F,
  0x1F, 0xCC, 0x76, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x87, 0xC3, 0x63, 0xB9, 0x9F, 0xC7, 0xC0, 0x1C, 0xF7, 0xFB,
  0xCC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0x18, 0x3F, 0x3F, 0xC8, 0x70, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x3F, 0xFF, 0xF0, 0x08,
  0x3F, 0xBD, 0xC8, 0x70, 0x18, 0x0C, 0x06, 0x06, 0x07, 0x1F, 0x0F, 0x80,
  0xE0, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC1, 0xFF, 0xDF, 0xC0, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x02, 0x60, 0xCC, 0x11, 0x86, 0x30,
  0xC6, 0x30, 0xC6, 0x19, 0xFF, 0xFF, 0xF8, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFC, 0xFF, 0x21,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x83, 0xFF, 0xBF, 0x80, 0x02,
  0x0F, 0x8F, 0x46, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xCF, 0x6F, 0xB8, 0xFC,
  0x3E, 0x1E, 0x0F, 0x86, 0xC3, 0x61, 0xB9, 0xCF, 0xC3, 0xC0, 0xFF, 0xFF,
  0xF0, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0x0C, 0x0F,
  0xC7, 0x39, 0x86, 0xE1, 0xB8, 0x66, 0x19, 0x8E, 0x37, 0x07, 0x83, 0xE1,
  0xDC, 0x63, 0xB0, 0x6C, 0x1F, 0x07, 0xC1, 0xF8, 0x67, 0xF8, 0xFC, 0x08,
  0x1F, 0x1F, 0xCC, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xD8, 0xEF,
  0xF3, 0xD8, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x9F, 0x8F, 0x80, 0x5B, 0xE0,
  0x00, 0x00, 0x0D, 0xF0, 0x26, 0x76, 0x00, 0x00, 0x00, 0x00, 0x76, 0x66,
  0xCC, 0xC0, 0x00, 0x40, 0x30, 0x3C, 0x3C, 0x3C, 0x3C, 0x0C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x80, 0x30, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x1E,
  0x1E, 0x1E, 0x0E, 0x03, 0x00, 0x10, 0xFE, 0x7F, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x0C, 0x1C, 0x18, 0x18, 0x10, 0x10, 0x00, 0x00, 0x38, 0x38,
  0x38, 0x07, 0xF0, 0x38, 0x70, 0x60, 0x71, 0x80, 0x66, 0x00, 0x6C, 0x7C,
  0xD9, 0xD9, 0xA3, 0x33, 0xC4, 0x63, 0x98, 0xC7, 0x31, 0x9E, 0x63, 0x3C,
  0xC6, 0x78, 0xDC, 0xD1, 0xEF, 0x31, 0x8C, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xE3, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x81, 0x98, 0x19, 0x81, 0x98, 0x19, 0xC3, 0x8C, 0x30, 0xC3, 0xFC, 0x3F,
  0xE7, 0x0E, 0x60, 0x66, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x30, 0xFF, 0x3F,
  0xEC, 0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0xFF, 0x3F, 0xCC, 0x3B,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xBF, 0xEF, 0xE0, 0x02, 0x03,
  0xF1, 0xFC, 0xE0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x11, 0xFC, 0x3F, 0xFE,
  0x1F, 0xE3, 0x0E, 0x60, 0xEC, 0x0D, 0x81, 0xB0, 0x36, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0x81, 0xB0, 0x76, 0x0C, 0xC3, 0x9F, 0xE3,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x01, 0x80, 0xFF, 0x1F, 0xF3, 0x81, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xFE, 0x1F, 0xE0, 0x36,
  0x03, 0x60, 0x37, 0x03, 0x70, 0x33, 0x83, 0x1F, 0xF0, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xEF,
  0xC0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x9F, 0xFE, 0xC1, 0xF0, 0xEC, 0x33, 0x1C, 0xC6, 0x33, 0x8C,
  0xC3, 0x70, 0xD8, 0x3F, 0x0E, 0xC3, 0x38, 0xC6, 0x31, 0xCC, 0x33, 0x0E,
  0xC1, 0xB0, 0x6C, 0x1C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFD, 0x81, 0xFB, 0x03, 0xF6, 0x0D,
  0xEC, 0x1B, 0xCC, 0x37, 0x98, 0xCF, 0x31, 0x9E, 0x33, 0x3C, 0x66, 0x78,
  0xD8, 0xF1, 0xB1, 0xE1, 0xE3, 0xC3, 0x87, 0x87, 0x0F, 0x06, 0x18, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3D, 0x87, 0xB0, 0xF7, 0x1E, 0x63, 0xCC, 0x78,
  0xCF, 0x19, 0xE1, 0xBC, 0x37, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0x80, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0x60, 0xC7, 0x07, 0x30, 0x19,
  0x80, 0xDC, 0x06, 0xE0, 0x37, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x0E, 0x70, 0x71, 0xC7, 0x0F, 0xF0, 0x1F, 0x00, 0xFE,
  0x7F, 0xB0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xFF, 0xBF, 0x9E,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x02, 0x00, 0xFE,
  0x0F, 0xF8, 0x60, 0xC7, 0x07, 0x30, 0x19, 0x80, 0xDC, 0x06, 0xE0, 0x37,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0x70,
  0x71, 0xC7, 0x0F, 0xF0, 0x1F, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E,
  0xC3, 0x3F, 0xCF, 0xC3, 0x38, 0xC6, 0x31, 0xCC, 0x33, 0x0E, 0xC1, 0xB0,
  0x6C, 0x1C, 0x08, 0x1F, 0xDF, 0xFC, 0x0E, 0x06, 0x03, 0x81, 0xC0, 0x70,
  0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0C, 0x06, 0x03, 0x03, 0xC1, 0xFF, 0xDF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xDF, 0xE3,
  0xF0, 0xE0, 0x7E, 0x06, 0x60, 0x66, 0x06, 0x60, 0xE7, 0x0E, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x9C, 0x19, 0x81, 0x98, 0x19, 0x81, 0xB8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0xE0, 0x7C, 0x1C, 0x0D, 0x83,
  0x83, 0xB0, 0x78, 0x76, 0x0F, 0x0C, 0xE3, 0x61, 0x8C, 0x6C, 0x31, 0x8D,
  0x8E, 0x31, 0x99, 0xC6, 0x33, 0x30, 0xEC, 0x66, 0x0D, 0x8C, 0xC1, 0xB1,
  0xB8, 0x36, 0x17, 0x06, 0xC3, 0xC0, 0xD0, 0x78, 0x0E, 0x0F, 0x01, 0xC1,
  0xE0, 0x38, 0x1C, 0x00, 0x60, 0xCE, 0x38, 0xC6, 0x18, 0xC1, 0xB8, 0x36,
  0x06, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0D, 0x81, 0xB0, 0x77, 0x0C,
  0x61, 0x8C, 0x61, 0xCC, 0x1B, 0x83, 0x80, 0xE0, 0xEC, 0x19, 0x87, 0x38,
  0xC3, 0x18, 0x67, 0x0E, 0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0xFF, 0xFF,
  0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x70, 0x60,
  0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0xE0,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0xF8,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8F, 0xE0, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x19, 0x81, 0x98, 0x30,
  0xC3, 0x0C, 0x60, 0x6E, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0x0C, 0x70, 0x80,
  0x1C, 0x3F, 0x90, 0xC0, 0x60, 0x38, 0x1C, 0x3E, 0xFF, 0xE3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3F, 0xED, 0xE6, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x31, 0xBE, 0xE3, 0x71, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF8, 0xFF, 0xED, 0xE0, 0x1E, 0x3F, 0x72, 0x60, 0xE0, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x7F, 0x3F, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x31, 0xCC, 0xFB, 0x73, 0xD8, 0x7E, 0x1F, 0x87, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xD8, 0x76, 0x1D, 0xFB, 0x3C, 0xC0, 0x1C,
  0x1F, 0x9C, 0xCC, 0x3E, 0x1E, 0x0F, 0xFF, 0xFF, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x09, 0xFC, 0x7C, 0x0E, 0x3C, 0xE9, 0x83, 0x06, 0x0F, 0x7E, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x1C,
  0xCF, 0xB7, 0x3D, 0x87, 0xE1, 0xF8, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x1F, 0x87, 0x61, 0xDF, 0xB3, 0xCC, 0x03, 0x00, 0xC0, 0x60, 0x19, 0xFE,
  0x7F, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x39, 0xFE, 0xF3,
  0x71, 0xB0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x38, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x33, 0x30, 0x03, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x0D, 0x8E, 0xC6, 0x67, 0x33, 0x1B, 0x0F, 0x87, 0xE3,
  0xB1, 0x98, 0xCE, 0x63, 0x31, 0xD8, 0x6C, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xCC, 0x39, 0xFC, 0xFB, 0x9F, 0x36, 0x1C, 0x7C, 0x38, 0xF8,
  0x60, 0xF0, 0xC1, 0xE1, 0x83, 0xC3, 0x07, 0x86, 0x0F, 0x0C, 0x1E, 0x18,
  0x3C, 0x30, 0x78, 0x60, 0xF0, 0xC1, 0x80, 0xCE, 0x7F, 0xB8, 0xDC, 0x6C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0E,
  0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x1D, 0x86, 0x61, 0x8F, 0xC3, 0xF0, 0xCE, 0x6F, 0xB8, 0xDC, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x3F, 0xFB, 0x79,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x1C, 0xCF, 0xB7, 0x3D, 0x87,
  0xE1, 0xF8, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x1F, 0x87, 0x61, 0xDF,
  0xB3, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x8F, 0x7F,
  0xF8, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x3C, 0xFF,
  0x8E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x7F, 0xFF, 0x00,
  0x30, 0x60, 0xC1, 0xEF, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x3E, 0x3C, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0xED, 0xE6, 0xC0, 0xF8, 0x76,
  0x19, 0x86, 0x61, 0x98, 0xE3, 0x30, 0xCC, 0x33, 0x0C, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xC0, 0xC1, 0x83, 0xE1, 0xC3, 0x61, 0xC3, 0x63, 0xC6,
  0x63, 0xC6, 0x63, 0x46, 0x33, 0x66, 0x32, 0x66, 0x36, 0x6C, 0x36, 0x6C,
  0x36, 0x2C, 0x1E, 0x2C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x61, 0xD8,
  0x63, 0x38, 0xCC, 0x3B, 0x07, 0x81, 0xE0, 0x30, 0x1E, 0x07, 0x83, 0xF0,
  0xCC, 0x33, 0x98, 0x6E, 0x1C, 0xC0, 0xF8, 0x76, 0x19, 0x86, 0x61, 0x9C,
  0xE3, 0x30, 0xCC, 0x33, 0x06, 0xC1, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0x83, 0xE0, 0xF0, 0x00, 0xFD, 0xF8, 0x30, 0x61,
  0xC3, 0x0E, 0x18, 0x30, 0xE1, 0x87, 0x0C, 0x1F, 0xFF, 0x80, 0x0F, 0x1E,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x70, 0xC0, 0x70, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1E, 0x07, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x38, 0xF0, 0xE0, 0xF8, 0x7F, 0xF8, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 19, 6, 2, -19 },
  { 9, 7, 7, 10, 2, -19 },
  { 16, 11, 19, 12, 1, -19 },
  { 43, 10, 23, 12, 1, -21 },
  { 72, 16, 20, 18, 1, -20 },
  { 112, 12, 20, 13, 1, -20 },
  { 142, 2, 7, 6, 2, -19 },
  { 144, 6, 23, 8, 1, -19 },
  { 162, 6, 23, 8, 1, -19 },
  { 180, 9, 9, 11, 1, -21 },
  { 191, 10, 13, 12, 1, -16 },
  { 208, 4, 7, 6, 1, -3 },
  { 212, 6, 2, 7, 1, -8 },
  { 214, 3, 3, 6, 2, -3 },
  { 216, 9, 19, 10, 1, -19 },
  { 238, 9, 20, 12, 1, -20 },
  { 261, 6, 19, 12, 2, -19 },
  { 276, 9, 20, 12, 1, -20 },
  { 299, 9, 20, 12, 1, -20 },
  { 322, 11, 19, 12, 0, -19 },
  { 349, 9, 19, 12, 1, -19 },
  { 371, 9, 20, 12, 1, -20 },
  { 394, 10, 19, 12, 1, -19 },
  { 418, 10, 20, 12, 1, -20 },
  { 443, 9, 20, 12, 1, -20 },
  { 466, 3, 15, 6, 2, -15 },
  { 472, 4, 19, 6, 1, -15 },
  { 482, 10, 12, 12, 1, -16 },
  { 497, 10, 7, 12, 1, -13 },
  { 506, 10, 12, 12, 1, -16 },
  { 521, 8, 20, 9, 0, -20 },
  { 541, 15, 21, 18, 1, -19 },
  { 581, 12, 19, 12, 0, -19 },
  { 610, 10, 19, 13, 2, -19 },
  { 634, 10, 20, 12, 1, -20 },
  { 659, 11, 19, 14, 2, -19 },
  { 686, 8, 19, 11, 2, -19 },
  { 705, 8, 19, 10, 2, -19 },
  { 724, 12, 20, 15, 1, -20 },
  { 754, 10, 19, 14, 2, -19 },
  { 778, 6, 19, 8, 1, -19 },
  { 793, 5, 24, 6, -1, -19 },
  { 808, 10, 19, 12, 2, -19 },
  { 832, 8, 19, 10, 2, -19 },
  { 851, 15, 19, 19, 2, -19 },
  { 887, 11, 19, 15, 2, -19 },
  { 914, 13, 20, 15, 1, -20 },
  { 947, 9, 19, 12, 2, -19 },
  { 969, 13, 25, 15, 1, -20 },
  { 1010, 10, 19, 12, 2, -19 },
  { 1034, 9, 20, 11, 1, -20 },
  { 1057, 10, 19, 10, 0, -19 },
  { 1081, 10, 19, 14, 2, -19 },
  { 1105, 12, 19, 12, 0, -19 },
  { 1134, 19, 19, 19, 0, -19 },
  { 1180, 11, 19, 11, 0, -19 },
  { 1207, 11, 19, 11, 0, -19 },
  { 1234, 8, 19, 10, 1, -19 },
  { 1253, 6, 23, 8, 2, -19 },
  { 1271, 10, 19, 10, 0, -19 },
  { 1295, 5, 23, 8, 1, -19 },
  { 1310, 12, 10, 12, 0, -19 },
  { 1325, 12, 2, 12, 0, 2 },
  { 1328, 5, 5, 7, 1, -21 },
  { 1332, 9, 15, 11, 1, -15 },
  { 1349, 9, 21, 12, 2, -21 },
  { 1373, 8, 15, 9, 1, -15 },
  { 1388, 10, 21, 12, 1, -21 },
  { 1415, 9, 15, 11, 1, -15 },
  { 1432, 7, 21, 7, 0, -21 },
  { 1451, 10, 21, 12, 1, -15 },
  { 1478, 9, 21, 12, 2, -21 },
  { 1502, 2, 20, 6, 2, -20 },
  { 1507, 4, 26, 6, 0, -20 },
  { 1520, 9, 21, 11, 2, -21 },
  { 1544, 2, 21, 6, 2, -21 },
  { 1550, 15, 15, 18, 2, -15 },
  { 1579, 9, 15, 12, 2, -15 },
  { 1596, 10, 15, 12, 1, -15 },
  { 1615, 9, 21, 12, 2, -15 },
  { 1639, 10, 21, 12, 1, -15 },
  { 1666, 6, 15, 8, 2, -15 },
  { 1678, 7, 15, 9, 1, -15 },
  { 1692, 7, 18, 7, 0, -18 },
  { 1708, 9, 15, 12, 2, -15 },
  { 1725, 10, 15, 10, 0, -15 },
  { 1744, 16, 15, 16, 0, -15 },
  { 1774, 10, 15, 10, 0, -15 },
  { 1793, 10, 21, 10, 0, -15 },
  { 1820, 7, 15, 8, 1, -15 },
  { 1834, 8, 23, 10, 1, -19 },
  { 1857, 2, 27, 11, 4, -21 },
  { 1864, 8, 23, 10, 1, -19 },
  { 1887, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Regular27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR27PT7B_H_
