#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x6D, 0xB0, 0x03, 0xFE, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0xC1,
  0x8C, 0xFF, 0xFF, 0xFF, 0x19, 0x81, 0x18, 0x31, 0x83, 0x18, 0x31, 0x8F,
  0xFE, 0xFF, 0xE3, 0x30, 0x33, 0x02, 0x30, 0x63, 0x06, 0x30, 0x63, 0x00,
  0x04, 0x01, 0x00, 0xE0, 0xFF, 0x75, 0xF9, 0x0C, 0x43, 0x10, 0xE4, 0x1D,
  0x07, 0xC0, 0x7C, 0x07, 0x81, 0x70, 0x4C, 0x13, 0x04, 0xE1, 0x3F, 0x7B,
  0xFC, 0x04, 0x01, 0x00, 0x40, 0x10, 0x38, 0x18, 0x3E, 0x0C, 0x1B, 0x0C,
  0x18, 0xC6, 0x0C, 0x63, 0x06, 0x33, 0x03, 0x19, 0x81, 0x8C, 0xC0, 0xC6,
  0xC6, 0x63, 0x6F, 0x9B, 0x36, 0xCF, 0xB3, 0x33, 0x9B, 0x18, 0x0D, 0x8C,
  0x0C, 0xC6, 0x06, 0x63, 0x03, 0x31, 0x83, 0x08, 0xC1, 0x86, 0x60, 0x83,
  0xE0, 0xC0, 0xF0, 0x1E, 0x01, 0xF8, 0x0C, 0xC0, 0xE6, 0x07, 0x30, 0x39,
  0x80, 0xCC, 0x06, 0x60, 0x3E, 0x00, 0xE0, 0x0F, 0x00, 0xFC, 0x66, 0x63,
  0x73, 0xBB, 0x0F, 0x98, 0x3C, 0xC1, 0xE7, 0x0F, 0x38, 0xF8, 0xFE, 0xE3,
  0xE3, 0x80, 0xFF, 0xFF, 0x0E, 0x18, 0x61, 0xC3, 0x06, 0x1C, 0x30, 0x60,
  0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x83, 0x06, 0x06,
  0x0C, 0x0C, 0x1C, 0xC1, 0x86, 0x0C, 0x30, 0xE1, 0x86, 0x1C, 0x70, 0xC3,
  0x0C, 0x30, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xC3, 0x18, 0x63, 0x00, 0x0C,
  0x06, 0x03, 0x1D, 0xFF, 0xF8, 0xE0, 0xF8, 0x6E, 0x73, 0x11, 0x00, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xFF, 0xFF, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x77, 0x66, 0x6C, 0xC0, 0xFF,
  0xF0, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x1C,
  0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x00, 0x1E, 0x0F, 0xC7, 0x39, 0xC6, 0x61, 0xD8, 0x7E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0x61,
  0xD8, 0x67, 0x38, 0xFC, 0x1F, 0x00, 0x0E, 0x3C, 0xFB, 0xFE, 0xF9, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE0, 0x3E, 0x1F, 0xCE, 0x39, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x0E,
  0x03, 0xFF, 0xFF, 0xC0, 0x3E, 0x1F, 0xEE, 0x39, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x03, 0x8F, 0xC3, 0xE0, 0x3E, 0x01, 0x80, 0x70, 0x1C, 0x03,
  0x01, 0xC0, 0x78, 0x3B, 0xFE, 0xFE, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x2C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0xC3,
  0x0C, 0x70, 0xC6, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x7E, 0x1F, 0xC6, 0x78, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x78, 0x3B, 0xFE, 0x7E, 0x00, 0x07, 0x87, 0xE3, 0xC0, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0xEF, 0x3F, 0xEF, 0x1F, 0x87, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0x60, 0xD8, 0x77, 0x18, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x00,
  0x1F, 0x0F, 0xE7, 0x1D, 0x87, 0xE0, 0xD8, 0x36, 0x1D, 0xC6, 0x3B, 0x87,
  0xC1, 0xE0, 0xFE, 0x71, 0xB8, 0x7E, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x1D,
  0xFE, 0x3F, 0x00, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xF8, 0x7E, 0x0F,
  0x83, 0xE1, 0xF8, 0x76, 0x1D, 0xFB, 0x3E, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x71, 0xF8, 0x7C, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x27, 0x77, 0x00, 0x00, 0x00, 0x00, 0x07, 0x76, 0x66, 0xCC, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x38, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x06, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x18, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x70, 0x08, 0x00, 0x3C, 0x7F, 0x99,
  0xC0, 0x60, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x07, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x03,
  0xFC, 0x03, 0x07, 0x03, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x19, 0x87, 0xCC,
  0xC6, 0x66, 0x66, 0x33, 0x33, 0x18, 0xF1, 0x8C, 0x78, 0xC6, 0x3C, 0x63,
  0x16, 0x33, 0x9B, 0x19, 0xCC, 0xCC, 0xA6, 0x63, 0xDE, 0x30, 0xC6, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xF1, 0x80, 0x3F, 0xC0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x03, 0xB8, 0x18,
  0xC0, 0xC6, 0x06, 0x30, 0x71, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8E, 0x0E,
  0x70, 0x73, 0x01, 0x98, 0x0D, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x1F, 0xF3,
  0x9F, 0x70, 0xEE, 0x0D, 0xC1, 0xB8, 0x37, 0x0E, 0xE1, 0xDF, 0xF3, 0xFC,
  0x71, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1B, 0x87, 0x7F,
  0xCF, 0xF0, 0x07, 0xC3, 0xFC, 0x71, 0x9C, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x8F, 0xF0, 0xFE, 0xFC, 0x0F, 0xF0, 0xE7, 0x8E,
  0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0xCF,
  0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xE0, 0x7F,
  0xC7, 0x8E, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x3F, 0xC1, 0xF6, 0x01, 0xB0, 0x0D, 0x80, 0x6E, 0x03, 0x70,
  0x19, 0xC0, 0xCF, 0x06, 0x3F, 0xF0, 0xFF, 0x80, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x06, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x3F, 0xFC, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xB8, 0xE0, 0xFC,
  0x1B, 0x87, 0x71, 0xCE, 0x31, 0xCE, 0x39, 0x87, 0x70, 0xEC, 0x1F, 0x83,
  0xF0, 0x7F, 0x0E, 0x61, 0xCE, 0x39, 0xC7, 0x1C, 0xE3, 0x9C, 0x33, 0x87,
  0x70, 0x6E, 0x0E, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFD, 0x80, 0xFE, 0xC0,
  0x7F, 0x60, 0x3F, 0xB8, 0x37, 0xCC, 0x1B, 0xE6, 0x0D, 0xF3, 0x0C, 0xF8,
  0xC6, 0x7C, 0x63, 0x3E, 0x31, 0x9F, 0x1D, 0x8F, 0x86, 0xC7, 0xC3, 0x63,
  0xE1, 0xE1, 0xF0, 0x70, 0xF8, 0x38, 0x7C, 0x1C, 0x38, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xD8, 0x3D, 0x83, 0xDC, 0x3C, 0xC3, 0xCE, 0x3C, 0x63,
  0xC6, 0x3C, 0x73, 0xC3, 0x3C, 0x3B, 0xC1, 0xBC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x7F, 0x83, 0xCF, 0x0E, 0x1C,
  0x70, 0x39, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0xE0, 0x1B, 0x80, 0x6E, 0x01,
  0xF8, 0x07, 0x60, 0x19, 0x80, 0x66, 0x01, 0x9C, 0x0E, 0x70, 0x38, 0xC0,
  0xC3, 0x87, 0x07, 0xF8, 0x0F, 0xC0, 0xF8, 0x3F, 0xCE, 0xFB, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6E, 0x7B, 0xFC, 0xFE, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x80, 0x7F,
  0x83, 0xCF, 0x0E, 0x1C, 0x70, 0x39, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0xE0,
  0x1B, 0x80, 0x6E, 0x01, 0xF8, 0x07, 0x60, 0x19, 0x80, 0x66, 0x01, 0x9C,
  0x0E, 0x70, 0x38, 0xC0, 0xC3, 0x87, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0xFC, 0x1F, 0xE3, 0xFE, 0x70,
  0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x73, 0xFE, 0x7F, 0x0E,
  0x61, 0xCE, 0x38, 0xC7, 0x1C, 0xE3, 0x9C, 0x33, 0x87, 0x70, 0x6E, 0x0E,
  0x1F, 0x0F, 0xF7, 0x9B, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x3E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x3B,
  0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x1D, 0xC7, 0x3F, 0xE3,
  0xF8, 0xE0, 0x3F, 0x01, 0xD8, 0x0C, 0xC0, 0xE6, 0x07, 0x38, 0x39, 0xC1,
  0x86, 0x0C, 0x30, 0xE1, 0xC7, 0x0E, 0x30, 0x31, 0x81, 0x9C, 0x0E, 0xE0,
  0x76, 0x01, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x70, 0x3F, 0x03, 0x81, 0xD8, 0x1C, 0x0C, 0xC0, 0xE0, 0x66, 0x0D,
  0x07, 0x38, 0x6C, 0x39, 0xC3, 0x61, 0xC6, 0x1B, 0x0C, 0x30, 0xD8, 0x61,
  0x8E, 0xC7, 0x0E, 0x63, 0x38, 0x73, 0x19, 0x81, 0x98, 0xCC, 0x0C, 0xC6,
  0x60, 0x6E, 0x37, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x6E, 0x1C, 0xC3,
  0x18, 0x63, 0x9C, 0x33, 0x06, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x80, 0xF0, 0x3F, 0x06, 0x61, 0xCC, 0x31, 0xC6, 0x19, 0xC3, 0x30, 0x7E,
  0x06, 0xE0, 0x7C, 0x1D, 0x83, 0xB8, 0x67, 0x1C, 0x63, 0x8E, 0x60, 0xCC,
  0x1B, 0x03, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x70,
  0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x1F, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xFF, 0xF0, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x02, 0x00,
  0x70, 0x07, 0x00, 0xF8, 0x0D, 0x81, 0x9C, 0x18, 0xC3, 0x0E, 0x30, 0x67,
  0x07, 0xE0, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x07, 0x1E, 0x3F,
  0x88, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x7F, 0x79, 0xF0, 0xF8, 0x78, 0x3C,
  0x1F, 0x1D, 0xFE, 0xFB, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0xE3, 0x7E, 0xF3, 0xB8, 0x7E, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF8, 0x3E, 0x1F, 0x86, 0xDF, 0xB7, 0xC0, 0x0F, 0x3F, 0x79, 0x70,
  0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x71, 0x3F, 0x1F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0x39, 0xFF, 0x73,
  0xEC, 0x3D, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1D, 0x83, 0xB8, 0xF3, 0xFE, 0x7C, 0xC0, 0x0E, 0x0F, 0xC7, 0x39, 0x86,
  0x60, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xF8, 0x0E, 0x01, 0x80, 0x60, 0x1C,
  0x13, 0xF8, 0x7E, 0x1F, 0x1F, 0x38, 0x38, 0x38, 0x38, 0x3E, 0xFE, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x1C, 0x67, 0xFD, 0xCF, 0xB0, 0xF6, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x76, 0x0E, 0xE3, 0xCF, 0xF9, 0xF7, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x66, 0x3C, 0xFF, 0x0F, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x39, 0xBE, 0xF3, 0xF0, 0xF8, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x33, 0x30, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x37, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x07, 0x87, 0xC7, 0x63, 0x33, 0x99, 0x8D, 0x87, 0xE3, 0xF1, 0xDC,
  0xC6, 0x63, 0xB0, 0xD8, 0x6C, 0x3E, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xCE, 0x1C, 0xDF, 0x7E, 0xF3, 0xE7, 0xE3, 0xC7, 0xE1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xCE, 0x6F, 0xBC,
  0xFC, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x1E, 0x07, 0xF1, 0xC7, 0x30, 0xE6, 0x0D, 0xC1, 0xB8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB0, 0x66, 0x0C, 0xE3, 0x8F, 0xE0,
  0xF8, 0xCE, 0x37, 0xEF, 0x3B, 0x87, 0xE1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x83, 0xE1, 0xF8, 0x6D, 0xFB, 0x7C, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1C, 0x67, 0xFD, 0xCF, 0xB0, 0xF6,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x76, 0x0E,
  0xE3, 0xCF, 0xF9, 0xF7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0xCF, 0xBB, 0xF7, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x3E, 0x7F, 0xE2, 0xC0, 0xC0, 0xE0, 0xF0, 0x78,
  0x3E, 0x0E, 0x07, 0x03, 0x07, 0x87, 0xFE, 0xFC, 0x10, 0x60, 0xC1, 0xFF,
  0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x7C,
  0x78, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3F, 0x1D, 0xFE, 0xFB, 0xE0, 0xFC, 0x19, 0x83, 0x30,
  0xE6, 0x1C, 0xE3, 0x0C, 0x61, 0x8C, 0x33, 0x87, 0x60, 0x6C, 0x0D, 0x81,
  0xF0, 0x3C, 0x03, 0x80, 0x70, 0xE1, 0xC1, 0xF0, 0xE0, 0xD8, 0x78, 0x6C,
  0x3C, 0x76, 0x1E, 0x33, 0x9B, 0x18, 0xCD, 0x8C, 0x66, 0x66, 0x33, 0x37,
  0x19, 0x9B, 0x0F, 0x8D, 0x83, 0xC6, 0xC1, 0xE3, 0x60, 0xF0, 0xE0, 0x78,
  0x70, 0x38, 0x38, 0x60, 0xDC, 0x73, 0x18, 0xC6, 0x3B, 0x06, 0xC1, 0xF0,
  0x38, 0x0E, 0x07, 0x81, 0xB0, 0xEC, 0x33, 0x8C, 0x67, 0x1F, 0x83, 0xE0,
  0xFC, 0x19, 0x83, 0x30, 0xE7, 0x1C, 0xE3, 0x0C, 0x61, 0x8C, 0x33, 0x83,
  0x60, 0x6C, 0x0D, 0x81, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x81, 0xF0, 0x3C, 0x00, 0xFF, 0xFC, 0x38, 0x60, 0xC3,
  0x86, 0x1C, 0x30, 0x61, 0xC3, 0x0E, 0x1C, 0x3F, 0xFF, 0x03, 0x0F, 0x0E,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF0, 0xF0, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0E, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xF0, 0x38, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x07, 0x0F, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x78, 0xF0, 0xC0, 0x78, 0x3F, 0xDE,
  0x1F, 0x40, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 7, 8, 11, 2, -21 },
  { 16, 12, 21, 13, 1, -21 },
  { 48, 10, 24, 12, 1, -22 },
  { 78, 17, 21, 19, 1, -21 },
  { 123, 13, 21, 14, 1, -21 },
  { 158, 2, 8, 6, 2, -21 },
  { 160, 7, 26, 8, 1, -21 },
  { 183, 6, 26, 8, 1, -21 },
  { 203, 9, 10, 12, 1, -22 },
  { 215, 11, 14, 12, 1, -17 },
  { 235, 4, 7, 7, 1, -3 },
  { 239, 6, 2, 8, 1, -9 },
  { 241, 3, 3, 7, 2, -3 },
  { 243, 9, 21, 11, 1, -21 },
  { 267, 10, 21, 12, 1, -21 },
  { 294, 7, 21, 12, 2, -21 },
  { 313, 10, 21, 12, 1, -21 },
  { 340, 10, 21, 12, 1, -21 },
  { 367, 12, 21, 12, 0, -21 },
  { 399, 10, 21, 12, 1, -21 },
  { 426, 10, 21, 12, 1, -21 },
  { 453, 10, 21, 12, 1, -21 },
  { 480, 10, 21, 12, 1, -21 },
  { 507, 10, 21, 12, 1, -21 },
  { 534, 3, 16, 7, 2, -16 },
  { 540, 4, 20, 7, 1, -16 },
  { 550, 11, 13, 12, 1, -17 },
  { 568, 11, 8, 12, 1, -14 },
  { 579, 11, 13, 12, 1, -17 },
  { 597, 9, 21, 9, 0, -21 },
  { 621, 17, 23, 19, 1, -21 },
  { 670, 13, 21, 13, 0, -21 },
  { 705, 11, 21, 14, 2, -21 },
  { 734, 11, 21, 13, 1, -21 },
  { 763, 12, 21, 15, 2, -21 },
  { 795, 8, 21, 12, 2, -21 },
  { 816, 8, 21, 11, 2, -21 },
  { 837, 13, 21, 16, 1, -21 },
  { 872, 11, 21, 15, 2, -21 },
  { 901, 6, 21, 8, 1, -21 },
  { 917, 5, 27, 7, -1, -21 },
  { 934, 11, 21, 13, 2, -21 },
  { 963, 8, 21, 11, 2, -21 },
  { 984, 17, 21, 21, 2, -21 },
  { 1029, 12, 21, 17, 2, -21 },
  { 1061, 14, 21, 16, 1, -21 },
  { 1098, 10, 21, 13, 2, -21 },
  { 1125, 14, 26, 16, 1, -21 },
  { 1171, 11, 21, 13, 2, -21 },
  { 1200, 10, 21, 12, 1, -21 },
  { 1227, 11, 21, 11, 0, -21 },
  { 1256, 11, 21, 15, 2, -21 },
  { 1285, 13, 21, 13, 0, -21 },
  { 1320, 21, 21, 21, 0, -21 },
  { 1376, 11, 21, 12, 0, -21 },
  { 1405, 11, 21, 11, 0, -21 },
  { 1434, 9, 21, 10, 1, -21 },
  { 1458, 6, 26, 9, 2, -21 },
  { 1478, 9, 21, 11, 1, -21 },
  { 1502, 6, 26, 9, 1, -21 },
  { 1522, 12, 11, 13, 0, -21 },
  { 1539, 13, 2, 13, 0, 2 },
  { 1543, 6, 4, 8, 1, -22 },
  { 1546, 9, 16, 12, 1, -16 },
  { 1564, 10, 22, 13, 2, -22 },
  { 1592, 8, 16, 10, 1, -16 },
  { 1608, 11, 22, 13, 1, -22 },
  { 1639, 10, 16, 12, 1, -16 },
  { 1659, 8, 22, 7, 0, -22 },
  { 1681, 11, 23, 13, 1, -16 },
  { 1713, 9, 22, 13, 2, -22 },
  { 1738, 2, 21, 6, 2, -21 },
  { 1744, 4, 28, 6, 0, -21 },
  { 1758, 9, 22, 12, 2, -22 },
  { 1783, 2, 22, 6, 2, -22 },
  { 1789, 16, 16, 20, 2, -16 },
  { 1821, 9, 16, 13, 2, -16 },
  { 1839, 11, 16, 13, 1, -16 },
  { 1861, 10, 23, 13, 2, -16 },
  { 1890, 11, 23, 13, 1, -16 },
  { 1922, 7, 16, 9, 2, -16 },
  { 1936, 8, 16, 10, 1, -16 },
  { 1952, 7, 19, 8, 0, -19 },
  { 1969, 9, 16, 13, 2, -16 },
  { 1987, 11, 16, 11, 0, -16 },
  { 2009, 17, 16, 18, 0, -16 },
  { 2043, 10, 16, 11, 0, -16 },
  { 2063, 11, 23, 11, 0, -16 },
  { 2095, 7, 16, 9, 1, -16 },
  { 2109, 8, 26, 11, 1, -21 },
  { 2135, 2, 29, 12, 5, -22 },
  { 2143, 8, 26, 11, 1, -21 },
  { 2169, 11, 4, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Regular29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR29PT7B_H_
