#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x2C, 0xBB, 0x99, 0x24, 0x48, 0x93, 0xF2, 0x85, 0x0A,
  0x7E, 0x48, 0x91, 0x20, 0x27, 0xE9, 0x4A, 0x30, 0xE5, 0x2F, 0x88, 0x40,
  0xC4, 0xA4, 0xA4, 0xA8, 0xAA, 0xAD, 0xD5, 0x15, 0x25, 0x25, 0x27, 0x30,
  0xD1, 0x23, 0x43, 0x06, 0x15, 0xA6, 0xCC, 0x99, 0xD8, 0xF0, 0x29, 0x49,
  0x24, 0x93, 0x26, 0xC4, 0x22, 0x23, 0x33, 0x32, 0x26, 0xC0, 0x6B, 0x6F,
  0x60, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0xEA, 0xFF, 0xB0, 0x08, 0x46,
  0x21, 0x10, 0x84, 0x42, 0x30, 0x66, 0xA7, 0x38, 0xC6, 0x33, 0x9C, 0x9C,
  0x2F, 0x92, 0x49, 0x24, 0x80, 0x71, 0x20, 0xC2, 0x08, 0x21, 0x0C, 0x21,
  0x0F, 0xC0, 0xE4, 0x86, 0x21, 0x30, 0x43, 0x1C, 0xBC, 0x08, 0x61, 0x8A,
  0x29, 0x24, 0xA2, 0xFC, 0x20, 0x80, 0xF4, 0x21, 0x0E, 0x78, 0x63, 0x1C,
  0xBC, 0x32, 0x21, 0x0B, 0x6A, 0x71, 0x8C, 0xDC, 0xFC, 0x10, 0x82, 0x08,
  0x41, 0x04, 0x30, 0x86, 0x00, 0x74, 0xA7, 0x3D, 0x32, 0x51, 0x8C, 0xFC,
  0x64, 0xA5, 0x39, 0xCF, 0xE2, 0x11, 0xB8, 0xE0, 0x0B, 0xE0, 0x0E, 0xA0,
  0x04, 0x33, 0x30, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x83, 0x83, 0x83,
  0x19, 0x88, 0x00, 0x79, 0x11, 0x12, 0x24, 0x06, 0x60, 0x1C, 0x62, 0x42,
  0x9D, 0xA5, 0xA5, 0xAD, 0xAD, 0xBF, 0x80, 0x40, 0x7C, 0x10, 0x60, 0xA1,
  0x42, 0x8D, 0x1F, 0x3E, 0x45, 0x8A, 0x18, 0xF2, 0x68, 0xA2, 0x8B, 0xC8,
  0xA3, 0x8E, 0x2F, 0x00, 0x3A, 0x71, 0x08, 0x42, 0x10, 0xC2, 0x1E, 0xF2,
  0x68, 0xE3, 0x86, 0x18, 0x61, 0x8E, 0x6F, 0x00, 0xF8, 0x88, 0x8F, 0x88,
  0x88, 0xF0, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0x80, 0x3D, 0x9C, 0x20, 0x82,
  0x38, 0x61, 0xC5, 0x17, 0xC0, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86,
  0x18, 0x40, 0xFB, 0x6D, 0xB6, 0xDB, 0x80, 0x24, 0x92, 0x49, 0x24, 0x93,
  0xC0, 0x8E, 0x29, 0x24, 0xA3, 0x8F, 0x24, 0x9A, 0x28, 0xC0, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0xC1, 0xE0, 0xF8, 0xB4, 0x7A, 0x3D, 0x2E, 0x57,
  0x2B, 0x95, 0xCC, 0xE2, 0x60, 0xC7, 0x1E, 0x69, 0xA6, 0x59, 0x67, 0x8E,
  0x38, 0x40, 0x38, 0x9B, 0x14, 0x28, 0x50, 0xE1, 0x42, 0x84, 0x99, 0xE0,
  0xE4, 0xE3, 0x18, 0xCF, 0xD0, 0x84, 0x20, 0x38, 0x9B, 0x14, 0x28, 0x50,
  0xE1, 0x42, 0x84, 0x99, 0xE0, 0x40, 0xC0, 0x80, 0xE2, 0x68, 0xA2, 0x8B,
  0xEF, 0x24, 0x9A, 0x28, 0xC0, 0x7E, 0xA1, 0x0C, 0x30, 0x43, 0x1C, 0xBC,
  0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x8F, 0x37, 0x80, 0x87, 0x89, 0x12, 0x24, 0xC9, 0x1A,
  0x14, 0x38, 0x60, 0xC0, 0x84, 0x78, 0x89, 0x31, 0x25, 0x24, 0xA4, 0x95,
  0x9A, 0xA1, 0x94, 0x31, 0x86, 0x30, 0xC6, 0x00, 0xCD, 0x24, 0x8E, 0x30,
  0xC3, 0x0E, 0x49, 0x2C, 0xC0, 0x8F, 0x24, 0x92, 0x70, 0xC3, 0x0C, 0x30,
  0xC3, 0x00, 0xF8, 0x46, 0x23, 0x10, 0x8C, 0x42, 0x3E, 0xF2, 0x49, 0x24,
  0x92, 0x4E, 0x82, 0x10, 0xC2, 0x10, 0x42, 0x10, 0x42, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xF0, 0x10, 0xC2, 0x9A, 0x47, 0x10, 0xFE, 0xD0, 0xF1,
  0x17, 0x99, 0x9F, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0x8E, 0x6C, 0x78, 0x88,
  0x88, 0x87, 0x08, 0x43, 0xD9, 0xC6, 0x31, 0x8C, 0xDA, 0x74, 0xA7, 0xF8,
  0x42, 0x0E, 0x74, 0x4F, 0x44, 0x44, 0x44, 0x40, 0x6C, 0xE3, 0x18, 0xC6,
  0x6D, 0x08, 0x7C, 0xC0, 0x84, 0x21, 0xEC, 0xC6, 0x31, 0x8C, 0x62, 0xDF,
  0xE0, 0x51, 0x55, 0x55, 0x78, 0x84, 0x21, 0x39, 0x53, 0x9C, 0x94, 0xA6,
  0xFF, 0xE0, 0xF7, 0xD9, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xF6, 0x63,
  0x18, 0xC6, 0x31, 0x74, 0xE3, 0x18, 0xC6, 0x6E, 0xB6, 0x63, 0x18, 0xC7,
  0x36, 0x84, 0x21, 0x00, 0x6C, 0xE3, 0x18, 0xC6, 0x6D, 0x08, 0x42, 0x10,
  0xBA, 0x49, 0x24, 0x7E, 0x10, 0xC3, 0x0E, 0x7E, 0x44, 0xF4, 0x44, 0x44,
  0x47, 0x8C, 0x63, 0x18, 0xC6, 0x7D, 0x8E, 0x52, 0xB5, 0x38, 0xC6, 0x88,
  0xE6, 0xD5, 0x4A, 0xA5, 0x52, 0xA8, 0xD4, 0x44, 0xCA, 0xDC, 0x63, 0x39,
  0x79, 0x8E, 0x52, 0xB5, 0x18, 0xC6, 0x21, 0x39, 0x80, 0x71, 0x22, 0x64,
  0x4F, 0x36, 0x44, 0x44, 0xC4, 0x44, 0x44, 0x30, 0xFF, 0xFF, 0xFF, 0xFC,
  0x84, 0x44, 0x44, 0x36, 0x44, 0x44, 0xC0, 0xF6, 0x20,
};

const GFXglyph NotoSans_ExtraCondensed_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 7, 11, 7, 0, -11 },
  { 16, 5, 12, 6, 1, -11 },
  { 24, 8, 11, 10, 1, -11 },
  { 35, 7, 11, 7, 0, -11 },
  { 45, 1, 4, 3, 1, -11 },
  { 46, 3, 13, 4, 1, -11 },
  { 51, 4, 13, 4, 0, -11 },
  { 58, 4, 5, 6, 1, -11 },
  { 61, 6, 7, 6, 0, -9 },
  { 67, 2, 4, 3, 1, -2 },
  { 68, 4, 2, 4, 0, -5 },
  { 69, 2, 2, 3, 1, -2 },
  { 70, 5, 11, 6, 0, -11 },
  { 77, 5, 11, 6, 1, -11 },
  { 84, 3, 11, 6, 1, -11 },
  { 89, 6, 11, 6, 0, -11 },
  { 98, 5, 11, 6, 1, -11 },
  { 105, 6, 11, 6, 0, -11 },
  { 114, 5, 11, 6, 1, -11 },
  { 121, 5, 11, 6, 1, -11 },
  { 128, 6, 11, 6, 0, -11 },
  { 137, 5, 11, 6, 1, -11 },
  { 144, 5, 11, 6, 1, -11 },
  { 151, 2, 8, 3, 1, -8 },
  { 153, 2, 10, 3, 1, -8 },
  { 156, 6, 7, 6, 0, -9 },
  { 162, 6, 4, 6, 0, -7 },
  { 165, 6, 7, 6, 0, -9 },
  { 171, 4, 11, 5, 0, -11 },
  { 177, 8, 12, 10, 1, -11 },
  { 189, 7, 11, 7, 0, -11 },
  { 199, 6, 11, 7, 1, -11 },
  { 208, 5, 11, 7, 1, -11 },
  { 215, 6, 11, 8, 1, -11 },
  { 224, 4, 11, 6, 1, -11 },
  { 230, 4, 11, 6, 1, -11 },
  { 236, 6, 11, 8, 1, -11 },
  { 245, 6, 11, 8, 1, -11 },
  { 254, 3, 11, 4, 1, -11 },
  { 259, 3, 14, 3, -1, -11 },
  { 265, 6, 11, 7, 1, -11 },
  { 274, 4, 11, 6, 1, -11 },
  { 280, 9, 11, 11, 1, -11 },
  { 293, 6, 11, 9, 1, -11 },
  { 302, 7, 11, 8, 1, -11 },
  { 312, 5, 11, 7, 1, -11 },
  { 319, 7, 14, 8, 1, -11 },
  { 332, 6, 11, 7, 1, -11 },
  { 341, 5, 11, 6, 1, -11 },
  { 348, 6, 11, 6, 0, -11 },
  { 357, 6, 11, 8, 1, -11 },
  { 366, 7, 11, 7, 0, -11 },
  { 376, 11, 11, 11, 0, -11 },
  { 392, 6, 11, 6, 0, -11 },
  { 401, 6, 11, 6, 0, -11 },
  { 410, 5, 11, 5, 0, -11 },
  { 417, 3, 13, 5, 1, -11 },
  { 422, 5, 11, 6, 0, -11 },
  { 429, 4, 13, 5, 0, -11 },
  { 436, 6, 6, 7, 0, -11 },
  { 441, 7, 1, 7, 0, 1 },
  { 442, 2, 2, 4, 1, -11 },
  { 443, 4, 8, 6, 1, -8 },
  { 447, 5, 11, 7, 1, -11 },
  { 454, 4, 8, 5, 1, -8 },
  { 458, 5, 11, 7, 1, -11 },
  { 465, 5, 8, 6, 1, -8 },
  { 470, 4, 11, 4, 0, -11 },
  { 476, 5, 12, 7, 1, -8 },
  { 484, 5, 11, 7, 1, -11 },
  { 491, 1, 11, 3, 1, -11 },
  { 493, 2, 15, 3, 0, -11 },
  { 497, 5, 11, 6, 1, -11 },
  { 504, 1, 11, 3, 1, -11 },
  { 506, 8, 8, 10, 1, -8 },
  { 514, 5, 8, 7, 1, -8 },
  { 519, 5, 8, 7, 1, -8 },
  { 524, 5, 12, 7, 1, -8 },
  { 532, 5, 12, 7, 1, -8 },
  { 540, 3, 8, 5, 1, -8 },
  { 543, 5, 8, 5, 0, -8 },
  { 548, 4, 10, 4, 0, -10 },
  { 553, 5, 8, 7, 1, -8 },
  { 558, 5, 8, 6, 0, -8 },
  { 563, 9, 8, 9, 0, -8 },
  { 572, 5, 8, 6, 0, -8 },
  { 577, 5, 12, 6, 0, -8 },
  { 585, 4, 8, 5, 0, -8 },
  { 589, 4, 13, 5, 1, -11 },
  { 596, 2, 15, 6, 2, -11 },
  { 600, 4, 13, 5, 1, -11 },
  { 607, 6, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Regular15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR15PT7B_H_
