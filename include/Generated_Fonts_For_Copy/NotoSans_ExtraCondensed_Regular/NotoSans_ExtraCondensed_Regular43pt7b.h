#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x76, 0x66,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xF8, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70,
  0xF7, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0xE1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x86, 0x00, 0xC1, 0x83, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0x3D, 0x84, 0xF3,
  0x01, 0xC6, 0x03, 0x8C, 0x07, 0x18, 0x0E, 0x30, 0x1E, 0x60, 0x3E, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x33, 0xC0,
  0x63, 0xC0, 0xC3, 0x81, 0x87, 0x03, 0x0E, 0x06, 0x3E, 0x0C, 0x77, 0x9B,
  0xEF, 0xFF, 0x9F, 0xFC, 0x03, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x1E, 0x00, 0xE0, 0x3F, 0x80, 0x70, 0x1F, 0xC0,
  0x70, 0x1C, 0x70, 0x38, 0x0E, 0x38, 0x1C, 0x07, 0x0C, 0x1C, 0x03, 0x87,
  0x0E, 0x01, 0xC3, 0x87, 0x00, 0xE1, 0xC7, 0x00, 0x70, 0xE3, 0x80, 0x38,
  0x71, 0x80, 0x1C, 0x39, 0xC0, 0x0E, 0x1C, 0xE3, 0x87, 0x0C, 0x63, 0xF3,
  0x8E, 0x73, 0xF8, 0xC7, 0x39, 0xCE, 0x7F, 0x39, 0xC7, 0x1F, 0x9C, 0xE1,
  0xC7, 0x8E, 0x70, 0xE0, 0x0E, 0x38, 0x70, 0x07, 0x1C, 0x38, 0x03, 0x8E,
  0x1C, 0x03, 0x87, 0x0E, 0x01, 0xC3, 0x87, 0x00, 0xE1, 0xC3, 0x80, 0xE0,
  0xE1, 0xC0, 0x70, 0x70, 0xC0, 0x38, 0x18, 0xE0, 0x38, 0x0E, 0xF0, 0x1C,
  0x03, 0xF0, 0x1C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xC7, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC1, 0xC3,
  0xDE, 0x1C, 0x78, 0xE1, 0xC7, 0x8F, 0x3C, 0x70, 0x7B, 0xCF, 0x03, 0xB8,
  0xF0, 0x3F, 0x8F, 0x01, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0x78, 0x1F,
  0x87, 0x83, 0xF8, 0x7F, 0xFB, 0xC3, 0xFF, 0x3E, 0x1F, 0xE1, 0xF0, 0xFB,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xE0,
  0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x03,
  0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38,
  0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x87, 0x0B, 0xDD, 0xEF, 0xFF, 0xBF, 0xFF, 0x0F, 0x80,
  0x37, 0x01, 0xDC, 0x0E, 0x38, 0x78, 0xF0, 0xC1, 0x81, 0x04, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0xE7, 0x30, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0xC1, 0xE7, 0xC7, 0x87, 0x8F, 0x07, 0x1C,
  0x0F, 0x78, 0x1E, 0xF0, 0x1D, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xF0, 0x3C, 0xE0,
  0x79, 0xE0, 0xE3, 0xE3, 0xC3, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDE, 0xFF, 0xBF, 0x8F, 0x43, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC3, 0xE2, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x7F, 0xF3, 0xFF, 0xE3, 0xC3, 0xE2, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xFA, 0x01, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x06, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x03, 0x9E, 0x01, 0xCF, 0x01,
  0xC7, 0x80, 0xE3, 0xC0, 0xE1, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x1C, 0x0F, 0x0E, 0x07, 0x8E, 0x03, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x30, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF6, 0x07, 0xCF, 0xFF,
  0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xF8,
  0x23, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x7E, 0x1D, 0xFF, 0x3B, 0xFE, 0x7C, 0x3E, 0xF0,
  0x3D, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0x70, 0x1C, 0xE0, 0x39, 0xE0, 0xF1, 0xE3, 0xC3, 0xFF, 0x83,
  0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3C, 0x3E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E,
  0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x3C, 0x1E, 0x7C, 0x0F, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3E, 0x7C, 0x3C, 0x3E, 0x78, 0x1E, 0x70, 0x0F,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0F,
  0x7C, 0x1E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x83,
  0xFF, 0x1E, 0x3E, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F,
  0x7F, 0xFC, 0xFF, 0x73, 0xF9, 0xC1, 0x87, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x7F, 0xE1, 0xFF,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x7B, 0xDE, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0xF7, 0xBD, 0xCE, 0xF7, 0x39, 0xCC, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x3F, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0x80, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x38, 0x0C, 0x0E, 0x70, 0x3F, 0x8E, 0x70, 0x7F, 0x87, 0x70, 0xE3,
  0x87, 0x71, 0xE3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3,
  0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3,
  0x87, 0xE1, 0xC7, 0x87, 0xE1, 0xC7, 0x86, 0xE1, 0xC7, 0x8E, 0xE1, 0xFD,
  0xFE, 0x70, 0xFC, 0xFC, 0x70, 0x78, 0x78, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x0F, 0x81,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x1D, 0xE0, 0x07, 0xBC, 0x00, 0xF3, 0x80, 0x1C, 0x70,
  0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x78,
  0x0E, 0x0F, 0x03, 0xC1, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x78, 0x0F, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x00, 0xE7, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x78,
  0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x86, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x02, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C,
  0x0F, 0x9E, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x87, 0xC1, 0xE1, 0xF0, 0x04, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x01,
  0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x3C, 0x00, 0xE7, 0x80, 0x1C, 0x78, 0x03,
  0x8F, 0x80, 0x70, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1E, 0xFF, 0xFF, 0xF7, 0xF8, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3F, 0x3F, 0xFF, 0xFC, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xEF,
  0xF7, 0xF3, 0xF0, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xE0, 0xF1, 0xE0, 0xF3,
  0xC0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFB, 0xC0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0xF0,
  0x70, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x70, 0x01, 0xFF, 0xB8,
  0x00, 0xFF, 0xDC, 0x00, 0x7F, 0xEF, 0x00, 0x77, 0xFB, 0x80, 0x3B, 0xFD,
  0xC0, 0x1D, 0xFE, 0xE0, 0x1E, 0xFF, 0x38, 0x0E, 0x7F, 0x9C, 0x07, 0x3F,
  0xCE, 0x03, 0x9F, 0xE7, 0x83, 0x8F, 0xF1, 0xC1, 0xC7, 0xF8, 0xE0, 0xE3,
  0xFC, 0x70, 0xF1, 0xFE, 0x1C, 0x70, 0xFF, 0x0E, 0x38, 0x7F, 0x87, 0x1C,
  0x3F, 0xC3, 0xDC, 0x1F, 0xE0, 0xEE, 0x0F, 0xF0, 0x77, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x7F, 0x81,
  0xE0, 0x3F, 0xC0, 0x70, 0x1E, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0xE0, 0x1F, 0xBC, 0x07, 0xE7,
  0x01, 0xFD, 0xC0, 0x7F, 0x78, 0x1F, 0xCE, 0x07, 0xF3, 0xC1, 0xFC, 0x70,
  0x7F, 0x1E, 0x1F, 0xC7, 0x87, 0xF0, 0xE1, 0xFC, 0x3C, 0x7F, 0x07, 0x1F,
  0xC1, 0xE7, 0xF0, 0x39, 0xFC, 0x0F, 0x7F, 0x03, 0xDF, 0xC0, 0x77, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3C, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0,
  0xF8, 0x3E, 0x07, 0x83, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E,
  0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xE7, 0x00, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x81, 0xF0,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0xE7, 0x9F, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x7C, 0xFF, 0xF9, 0xFF, 0xC3, 0xFE, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3E, 0x07, 0x83, 0xC0, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01,
  0xE7, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x7F,
  0xF3, 0xFF, 0x9F, 0x1E, 0xF8, 0x0B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xB0, 0x3E, 0xFF, 0xF3,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E, 0xF0, 0x07, 0x78,
  0x07, 0x9E, 0x03, 0xCF, 0x83, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0,
  0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xE1, 0xC0, 0x1C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0x70, 0x70, 0x0E, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0x77, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x07, 0x00, 0x3D, 0xC0, 0x1F,
  0x00, 0x73, 0x80, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x03, 0xCF, 0x00, 0xF8,
  0x07, 0x9E, 0x01, 0xB0, 0x0F, 0x1C, 0x07, 0x70, 0x1C, 0x38, 0x0E, 0xE0,
  0x78, 0x78, 0x1D, 0xC0, 0xF0, 0xF0, 0x3B, 0x81, 0xE1, 0xE0, 0x77, 0x03,
  0xC1, 0xC1, 0xC7, 0x07, 0x03, 0x83, 0x8E, 0x1E, 0x07, 0x87, 0x1C, 0x3C,
  0x0F, 0x0E, 0x38, 0x78, 0x0E, 0x3C, 0x70, 0xE0, 0x1C, 0x70, 0x71, 0xC0,
  0x38, 0xE0, 0xE7, 0x80, 0x79, 0xC1, 0xCF, 0x00, 0xF3, 0x83, 0x9E, 0x00,
  0xE7, 0x07, 0x38, 0x01, 0xDC, 0x07, 0x70, 0x03, 0xB8, 0x0E, 0xE0, 0x07,
  0x70, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x78, 0x07, 0x9C, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC1,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x70, 0x1C, 0x78, 0x0F, 0x38, 0x03, 0x9C,
  0x01, 0xDE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xEF, 0x00, 0x77, 0x80,
  0x79, 0xC0, 0x38, 0xF0, 0x3C, 0x78, 0x1C, 0x1C, 0x0E, 0x0F, 0x0F, 0x03,
  0x87, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x3B, 0xC0, 0x1E, 0xF0, 0x07, 0xF8,
  0x03, 0x9C, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x78,
  0x38, 0x38, 0x1C, 0x3C, 0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xF7,
  0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1F, 0xFF, 0xFF, 0xFC, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0x70,
  0x0E, 0x38, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xE3, 0xC0,
  0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x00, 0x80, 0x7F, 0xC3,
  0xFF, 0x87, 0xBE, 0x10, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x3F, 0xC7, 0xFF, 0x3F, 0xFD, 0xF0, 0x77, 0x81, 0xDC, 0x07,
  0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0x78, 0x7D, 0xF7, 0xF3, 0xFD,
  0xC7, 0xE7, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x9F, 0xC7, 0x7F,
  0xCE, 0xFF, 0x9F, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDF, 0x07, 0xBB, 0xFE,
  0x77, 0xFC, 0xE7, 0xF0, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xFE, 0x7C, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x13,
  0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x04, 0x1C, 0x7F,
  0x39, 0xFF, 0x73, 0xFE, 0xEF, 0x07, 0xDC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x01, 0xEF, 0x07,
  0xCF, 0xFB, 0x9F, 0xF7, 0x1F, 0xCE, 0x0F, 0xE0, 0x7F, 0xC3, 0xEF, 0x9E,
  0x1E, 0x70, 0x39, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1F, 0x02, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x03,
  0xE0, 0x7F, 0x0F, 0xE0, 0xF2, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3F, 0xCF, 0xFC, 0xFF, 0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x02, 0x00, 0x3F, 0x9C, 0xFF, 0xB9, 0xFF, 0x77, 0x83, 0xEF, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7B, 0x81, 0xF7, 0x83, 0xE7, 0xFD, 0xCF, 0xFB, 0x8F, 0xC7, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x98, 0x1F, 0x3F,
  0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x82, 0x0E, 0x7F,
  0x3B, 0xFE, 0xFF, 0xFB, 0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3C, 0xEE, 0xFF, 0xE0, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x0E, 0x0E, 0x0F, 0x0F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0xFE, 0xFC,
  0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x07, 0xB8, 0x1E, 0xE0, 0xF3,
  0x83, 0x8E, 0x1E, 0x38, 0xF0, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x3B, 0xC0,
  0xEF, 0x83, 0xFE, 0x0F, 0xBC, 0x3C, 0xF0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E,
  0x38, 0x3C, 0xE0, 0xF3, 0x81, 0xEE, 0x07, 0xB8, 0x0E, 0xE0, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x80, 0x20, 0xE7, 0xE1, 0xF8, 0xEF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFE,
  0xF8, 0x7E, 0x1E, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xE0, 0x3C, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0x00, 0x83, 0x9F, 0xCE, 0xFF, 0xBF, 0xFE, 0xF8, 0x7B, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x01, 0x00, 0x1F, 0xC0, 0x7F, 0xC1,
  0xFF, 0xC7, 0x83, 0xCE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B, 0xC0, 0xE7, 0x83, 0xC7, 0xFF, 0x07,
  0xFC, 0x07, 0xF0, 0x00, 0x81, 0xCF, 0xE3, 0xBF, 0xE7, 0x77, 0xCF, 0x83,
  0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x77, 0x81, 0xEF, 0x83, 0xDD, 0xFF, 0x3B, 0xFE, 0x73, 0xF0,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0x9C, 0xFF,
  0xB9, 0xFF, 0x77, 0x83, 0xEF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x81, 0xF7, 0x83, 0xE7, 0xFD,
  0xCF, 0xFB, 0x8F, 0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x01,
  0x39, 0xFE, 0xFB, 0xBE, 0xFC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x03, 0x01, 0xFE, 0x3F, 0xF7, 0xFE, 0x70,
  0x2F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0xC0,
  0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x1F,
  0xEF, 0xFB, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x0F, 0xF1, 0xFC, 0x3F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x07, 0xFC, 0x3F, 0x7F, 0xDD, 0xFE, 0x73, 0xF1, 0xC0, 0xF0, 0x0F, 0x70,
  0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xDC, 0x07,
  0x80, 0xE7, 0x01, 0xE0, 0x39, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07, 0x8E,
  0x0F, 0xC1, 0xC3, 0x83, 0xF0, 0x70, 0xE0, 0xCE, 0x1C, 0x3C, 0x73, 0x8F,
  0x0F, 0x1C, 0xE3, 0xC1, 0xC7, 0x38, 0xE0, 0x71, 0xCE, 0x38, 0x1C, 0xE1,
  0xCE, 0x07, 0xB8, 0x77, 0x80, 0xEE, 0x1D, 0xC0, 0x3B, 0x87, 0x70, 0x0E,
  0xE1, 0xDC, 0x03, 0xB0, 0x77, 0x00, 0xEC, 0x0D, 0xC0, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0xF0, 0x3D,
  0xC0, 0xF7, 0x87, 0x8E, 0x1E, 0x3C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE,
  0x07, 0x38, 0x1C, 0xF0, 0xF3, 0xC3, 0x87, 0x1E, 0x1E, 0x70, 0x3B, 0xC0,
  0xFE, 0x01, 0xC0, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C,
  0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x3F, 0x07, 0xF0, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xFC,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x0F, 0x80, 0xFC, 0x03,
  0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x7E, 0x03, 0xF0,
  0x1F, 0x07, 0xE0, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3E, 0x0F,
  0xC0, 0xF8, 0x0E, 0x00, 0x1E, 0x01, 0x7F, 0x81, 0xFF, 0xF7, 0xE3, 0xFF,
  0x80, 0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 31, 10, 3, -31 },
  { 17, 12, 11, 16, 2, -31 },
  { 34, 18, 31, 20, 1, -31 },
  { 104, 15, 36, 18, 2, -33 },
  { 172, 25, 31, 29, 2, -31 },
  { 269, 20, 31, 21, 1, -31 },
  { 347, 5, 11, 9, 2, -31 },
  { 354, 9, 38, 13, 2, -31 },
  { 397, 9, 38, 13, 1, -31 },
  { 440, 14, 15, 17, 2, -33 },
  { 467, 16, 20, 18, 1, -25 },
  { 507, 5, 11, 10, 2, -5 },
  { 514, 10, 3, 12, 1, -13 },
  { 518, 4, 5, 10, 3, -5 },
  { 521, 14, 31, 16, 1, -31 },
  { 576, 15, 31, 18, 2, -31 },
  { 635, 10, 31, 18, 3, -31 },
  { 674, 15, 31, 18, 1, -31 },
  { 733, 15, 31, 18, 1, -31 },
  { 792, 17, 31, 18, 1, -31 },
  { 858, 15, 31, 18, 2, -31 },
  { 917, 15, 31, 18, 2, -31 },
  { 976, 16, 31, 18, 1, -31 },
  { 1038, 16, 31, 18, 1, -31 },
  { 1100, 14, 31, 18, 2, -31 },
  { 1155, 4, 23, 10, 3, -23 },
  { 1167, 5, 29, 10, 2, -23 },
  { 1186, 16, 19, 18, 1, -25 },
  { 1224, 16, 12, 18, 1, -21 },
  { 1248, 16, 19, 18, 1, -25 },
  { 1286, 12, 31, 14, 1, -31 },
  { 1333, 24, 35, 28, 2, -31 },
  { 1438, 19, 31, 19, 0, -31 },
  { 1512, 16, 31, 21, 3, -31 },
  { 1574, 16, 31, 19, 2, -31 },
  { 1636, 17, 31, 22, 3, -31 },
  { 1702, 12, 31, 17, 3, -31 },
  { 1749, 12, 31, 16, 3, -31 },
  { 1796, 19, 31, 23, 2, -31 },
  { 1870, 17, 31, 23, 3, -31 },
  { 1936, 10, 31, 12, 1, -31 },
  { 1975, 9, 39, 10, -2, -31 },
  { 2019, 16, 31, 19, 3, -31 },
  { 2081, 12, 31, 16, 3, -31 },
  { 2128, 25, 31, 31, 3, -31 },
  { 2225, 18, 31, 24, 3, -31 },
  { 2295, 20, 31, 24, 2, -31 },
  { 2373, 15, 31, 19, 3, -31 },
  { 2432, 20, 38, 24, 2, -31 },
  { 2527, 16, 31, 20, 3, -31 },
  { 2589, 14, 31, 18, 2, -31 },
  { 2644, 16, 31, 16, 0, -31 },
  { 2706, 17, 31, 22, 3, -31 },
  { 2772, 19, 31, 19, 0, -31 },
  { 2846, 31, 31, 31, 0, -31 },
  { 2967, 17, 31, 17, 0, -31 },
  { 3033, 17, 31, 17, 0, -31 },
  { 3099, 14, 31, 16, 1, -31 },
  { 3154, 9, 38, 13, 3, -31 },
  { 3197, 14, 31, 16, 1, -31 },
  { 3252, 9, 38, 13, 1, -31 },
  { 3295, 17, 17, 19, 1, -31 },
  { 3332, 19, 2, 19, 0, 4 },
  { 3337, 8, 7, 11, 2, -33 },
  { 3344, 14, 24, 18, 1, -24 },
  { 3386, 15, 33, 20, 3, -33 },
  { 3448, 12, 24, 15, 2, -24 },
  { 3484, 15, 33, 20, 2, -33 },
  { 3546, 14, 23, 18, 2, -23 },
  { 3587, 12, 33, 11, 0, -33 },
  { 3637, 15, 34, 20, 2, -24 },
  { 3701, 14, 33, 20, 3, -33 },
  { 3759, 4, 32, 9, 3, -32 },
  { 3775, 8, 42, 9, -1, -32 },
  { 3817, 14, 33, 17, 3, -33 },
  { 3875, 3, 33, 9, 3, -33 },
  { 3888, 24, 24, 29, 3, -24 },
  { 3960, 14, 24, 20, 3, -24 },
  { 4002, 15, 24, 19, 2, -24 },
  { 4047, 15, 34, 20, 3, -24 },
  { 4111, 15, 34, 20, 2, -24 },
  { 4175, 10, 24, 13, 3, -24 },
  { 4205, 12, 24, 15, 1, -24 },
  { 4241, 10, 28, 11, 1, -28 },
  { 4276, 14, 23, 20, 3, -23 },
  { 4317, 16, 23, 16, 0, -23 },
  { 4363, 26, 23, 26, 0, -23 },
  { 4438, 14, 23, 16, 1, -23 },
  { 4479, 16, 33, 16, 0, -23 },
  { 4545, 11, 23, 13, 1, -23 },
  { 4577, 12, 38, 16, 2, -31 },
  { 4634, 3, 43, 17, 7, -33 },
  { 4651, 12, 38, 16, 2, -31 },
  { 4708, 16, 6, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Regular43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR43PT7B_H_
