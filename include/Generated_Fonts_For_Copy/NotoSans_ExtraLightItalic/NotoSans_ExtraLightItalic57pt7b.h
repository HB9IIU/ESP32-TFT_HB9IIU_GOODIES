#ifndef _NOTOSANS_EXTRALIGHTITALIC57PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x08, 0x00, 0x18,
  0x1C, 0x60, 0x61, 0x81, 0x8E, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x03, 0x0C,
  0x0C, 0x60, 0x31, 0x80, 0x86, 0x06, 0x18, 0x18, 0x40, 0x61, 0x01, 0x0C,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xC3, 0x07, 0x01,
  0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x20, 0x00, 0x0F,
  0x18, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0C, 0xF0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x20, 0x38, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x10, 0x0E, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x80, 0x30, 0x70, 0x3C, 0x08, 0x78,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x3F, 0xE0, 0x00, 0x18,
  0x0E, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x18, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x1C, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x06, 0x07, 0x00, 0x0C, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x06, 0x0C, 0x0F, 0x0C, 0x00, 0xC1, 0x83, 0xFC,
  0xC0, 0x0C, 0x38, 0x70, 0xEC, 0x01, 0x83, 0x0C, 0x06, 0xC0, 0x18, 0x61,
  0x80, 0x7E, 0x03, 0x0C, 0x38, 0x03, 0x60, 0x61, 0xC3, 0x00, 0x33, 0xFC,
  0x18, 0x70, 0x03, 0x1F, 0x83, 0x06, 0x00, 0x30, 0x00, 0x60, 0x60, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0C,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0xE0, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0E, 0x06, 0x01, 0x80,
  0x00, 0x71, 0xE0, 0x30, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0x18, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x1C, 0x70, 0x03, 0x00, 0x06, 0x38, 0x00, 0xE0, 0x03, 0x0C, 0x00,
  0x18, 0x00, 0xC6, 0x00, 0x03, 0x00, 0x63, 0x80, 0x00, 0xE0, 0x38, 0xC0,
  0x00, 0x1C, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x0C, 0x00, 0x00, 0x63, 0x83,
  0x00, 0x00, 0x1D, 0xC0, 0xC0, 0x00, 0x03, 0xE0, 0x30, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x0E,
  0x60, 0x1C, 0x00, 0x0E, 0x0C, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x7E, 0x7F,
  0x00, 0x70, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x00, 0x00, 0x18,
  0xC6, 0x73, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x23, 0x00, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0xF8, 0x08, 0x00,
  0x3C, 0x18, 0x00, 0x0F, 0x18, 0x00, 0x03, 0xD0, 0x07, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x8C, 0x00,
  0x07, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x78, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x6F, 0xEE, 0x40, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0x80, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x81, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x38, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x01, 0xF0, 0x07, 0x60, 0x3C, 0xC0, 0xE3, 0x87, 0x86, 0x1C,
  0x0C, 0xF0, 0x18, 0x80, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3E,
  0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x3F, 0xC0, 0x06,
  0x1F, 0xFE, 0x01, 0xCF, 0x00, 0xE0, 0x33, 0x80, 0x0E, 0x06, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x18, 0xE0,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x1E, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xE1, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x3C, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0xE0,
  0x01, 0x80, 0x38, 0x00, 0x18, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30,
  0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x6C, 0x1C,
  0x00, 0x3B, 0x01, 0xC0, 0x1E, 0x60, 0x1F, 0xFF, 0x0C, 0x00, 0xFF, 0x83,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x03, 0xC0, 0x07,
  0xEF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x01,
  0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0x07, 0x03, 0x80, 0x80, 0x00, 0x08,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0xE0, 0x0E, 0x10, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x70, 0xC0, 0x01,
  0xFF, 0xF0, 0x06, 0x30, 0x00, 0xF0, 0x0E, 0x00, 0xC6, 0x00, 0x38, 0x01,
  0xC0, 0x19, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x30, 0x03, 0x80, 0x06, 0x00,
  0x6E, 0x00, 0xE0, 0x00, 0xC0, 0x0D, 0x80, 0x18, 0x00, 0x30, 0x01, 0xB0,
  0x07, 0x00, 0x06, 0x00, 0x36, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0xC0, 0x18,
  0x00, 0x18, 0x00, 0xF0, 0x06, 0x00, 0x06, 0x00, 0x36, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xD8, 0x03, 0x00, 0x07, 0x00,
  0x3B, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x60, 0x0C, 0x00, 0x38, 0x01, 0xCC,
  0x01, 0x80, 0x0D, 0x00, 0x31, 0x80, 0x38, 0x01, 0xA0, 0x0C, 0x38, 0x03,
  0x00, 0xE6, 0x03, 0x83, 0x00, 0x70, 0x38, 0xE1, 0xC0, 0x60, 0x07, 0xFC,
  0x0F, 0xF0, 0x0C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0xFE, 0x00, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0xE0,
  0x03, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x78, 0x0E, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x30, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xF0,
  0x06, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x00,
  0x60, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xE3, 0x00, 0x01, 0xFF, 0xF1, 0x80, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x80, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x01, 0xCD, 0xC0, 0x00, 0x00, 0xCC, 0x60, 0x00, 0x00, 0x6C, 0x38, 0x00,
  0x00, 0x3C, 0x0C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x03,
  0x60, 0x00, 0x00, 0x0D, 0x80, 0x6E, 0x00, 0x00, 0x03, 0x30, 0x0C, 0xC0,
  0x00, 0x00, 0xEE, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x73, 0x00, 0x00,
  0x07, 0x30, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x00, 0x30,
  0xC0, 0x31, 0xC0, 0x00, 0x0E, 0x38, 0x06, 0x18, 0x00, 0x01, 0x86, 0x01,
  0xC3, 0x00, 0x00, 0x70, 0xC0, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x06, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xE0, 0x38, 0x38, 0x00,
  0x18, 0x18, 0x06, 0x03, 0x00, 0x07, 0x03, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x00, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0xE0, 0x30, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0x70, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x07, 0x00,
  0x30, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x38, 0x01, 0xC0,
  0x30, 0x01, 0x86, 0x00, 0x30, 0x0E, 0x00, 0x31, 0x80, 0x06, 0x01, 0x80,
  0x06, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xCC, 0x00, 0x38, 0x06, 0x00, 0x1F,
  0x80, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x00, 0x60,
  0x1B, 0x00, 0x00, 0x0E, 0x01, 0x98, 0x00, 0x00, 0xC0, 0x19, 0x80, 0x00,
  0x0C, 0x01, 0x9C, 0x00, 0x00, 0xC0, 0x38, 0xC0, 0x00, 0x1C, 0x03, 0x0E,
  0x00, 0x01, 0x80, 0x30, 0x60, 0x00, 0x18, 0x03, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x30, 0x00, 0x18, 0x07, 0x03, 0x00, 0x03, 0x80, 0x60, 0x38, 0x00,
  0x30, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0E, 0x00,
  0xC0, 0x03, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x03, 0x00,
  0xE0, 0x18, 0x00, 0x30, 0x0E, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x18, 0x00,
  0x18, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0xC0, 0x38, 0x00, 0x0C, 0x1C, 0x03,
  0x00, 0x00, 0xC1, 0x80, 0x30, 0x00, 0x06, 0x18, 0x03, 0x00, 0x00, 0x61,
  0x80, 0x30, 0x00, 0x07, 0x18, 0x07, 0x00, 0x00, 0x33, 0x80, 0x60, 0x00,
  0x03, 0xB0, 0x06, 0x00, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x01, 0xB0, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x30, 0x0F, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x30, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x30, 0x0F, 0xF0, 0x01, 0x80,
  0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x00,
  0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x80,
  0x00, 0xE0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x02, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x08, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x16, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x03, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x01, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0E,
  0x00, 0x0C, 0x30, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x00, 0x0E, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x83, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x80, 0x60, 0x07, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x30,
  0x03, 0x80, 0x60, 0x0E, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00,
  0x60, 0x38, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8E,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x73, 0x00, 0x01, 0x8C, 0x00,
  0x07, 0x70, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x03,
  0xE0, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0,
  0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xE0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07,
  0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x07, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x03, 0x06, 0x00, 0x0F, 0x80,
  0x20, 0x07, 0xFE, 0x08, 0x03, 0xE1, 0xE3, 0x00, 0xE0, 0x0C, 0x60, 0x38,
  0x00, 0xCC, 0x0E, 0x00, 0x0D, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1C,
  0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30,
  0x00, 0x07, 0x06, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x6C, 0x1C, 0x00, 0x1B,
  0x01, 0x80, 0x06, 0x60, 0x38, 0x01, 0xCC, 0x03, 0x80, 0x61, 0x80, 0x3E,
  0xF8, 0x30, 0x03, 0xFE, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x0F, 0x00, 0x06, 0x07, 0xFC, 0x00, 0xC3, 0xC3, 0xC0,
  0x18, 0xC0, 0x1C, 0x07, 0x30, 0x01, 0xC0, 0xCC, 0x00, 0x18, 0x1B, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x1E, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0x87, 0x80,
  0x00, 0x70, 0xD0, 0x00, 0x1C, 0x1B, 0x00, 0x07, 0x06, 0x60, 0x01, 0xC0,
  0xC7, 0x00, 0x70, 0x18, 0x7C, 0xFC, 0x03, 0x07, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xF0, 0x78, 0x0F,
  0x00, 0x10, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x04, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x28, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0xFF, 0xC1, 0x80, 0x0F, 0x87, 0x86, 0x00, 0x70, 0x03, 0x18, 0x03, 0x80,
  0x06, 0x60, 0x1C, 0x00, 0x0B, 0x00, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0xF0, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x05,
  0x80, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xB0, 0x06, 0x00, 0x0C, 0xC0,
  0x1C, 0x00, 0x63, 0x00, 0x38, 0x07, 0x0C, 0x00, 0x7C, 0xF8, 0x20, 0x00,
  0xFF, 0x81, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xF1, 0xF0, 0x0F, 0x00, 0x60, 0x38, 0x00, 0xE0, 0xE0, 0x00,
  0xC3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x1C,
  0xE0, 0x00, 0x31, 0x80, 0x00, 0xE7, 0x00, 0x07, 0x8C, 0x00, 0x3E, 0x18,
  0x0F, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x06, 0x01, 0xF9, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x47, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x04, 0x00, 0x3F, 0xF0, 0x20, 0x03, 0xE0, 0xE1, 0x80,
  0x1C, 0x00, 0xC6, 0x00, 0xE0, 0x01, 0x98, 0x07, 0x00, 0x02, 0x60, 0x38,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x78, 0x0C, 0x00, 0x01, 0x60, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x6C, 0x01, 0x80, 0x03, 0x30, 0x07, 0x00, 0x18, 0xC0, 0x0E, 0x01, 0xC7,
  0x00, 0x1F, 0x3E, 0x18, 0x00, 0x3F, 0xE0, 0x60, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x78, 0x00, 0xC0, 0xFF, 0xC0, 0x30,
  0xF8, 0xF8, 0x0C, 0x70, 0x0E, 0x07, 0x30, 0x01, 0xC1, 0x98, 0x00, 0x30,
  0x6C, 0x00, 0x0C, 0x1E, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC3, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0C, 0x70,
  0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x18, 0x03, 0x80,
  0x06, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x63,
  0xE0, 0x00, 0x19, 0x98, 0x00, 0x07, 0xC7, 0x00, 0x03, 0xE0, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x70, 0x06, 0x00,
  0x0C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x60, 0xFF, 0x80,
  0x3F, 0xE0, 0x0C, 0x78, 0x78, 0x1E, 0x1E, 0x01, 0x9C, 0x03, 0x87, 0x00,
  0xE0, 0x67, 0x00, 0x31, 0xC0, 0x0E, 0x0C, 0x80, 0x06, 0x70, 0x01, 0xC1,
  0xB0, 0x00, 0xCC, 0x00, 0x18, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0x61, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x38, 0x00, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x60, 0xFF, 0xE0, 0x0C, 0x3E, 0x3E,
  0x01, 0x8E, 0x01, 0xE0, 0x63, 0x00, 0x1C, 0x0C, 0xC0, 0x01, 0x81, 0xB0,
  0x00, 0x30, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x18,
  0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x83, 0xC0, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x70, 0x00,
  0x07, 0x18, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x07,
  0x00, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0xF3, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0x81, 0xFF, 0x00, 0x06, 0x1E, 0x1E, 0x00, 0x18, 0xC0, 0x1C, 0x00, 0xC6,
  0x00, 0x38, 0x03, 0x30, 0x00, 0x60, 0x0D, 0x80, 0x01, 0xC0, 0x3C, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x18, 0x0F, 0x00, 0x00, 0xE0, 0x34, 0x00, 0x07, 0x00, 0xD8, 0x00, 0x38,
  0x03, 0x60, 0x01, 0xC0, 0x18, 0xE0, 0x0E, 0x00, 0x61, 0xF3, 0xF0, 0x01,
  0x83, 0xFF, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x10, 0x03, 0xFF, 0x02, 0x00,
  0xF8, 0x38, 0x60, 0x1C, 0x00, 0xC6, 0x03, 0x80, 0x06, 0x60, 0x70, 0x00,
  0x26, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1E,
  0x0C, 0x00, 0x01, 0x60, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x06, 0xC0, 0x60,
  0x00, 0xCC, 0x07, 0x00, 0x18, 0xC0, 0x38, 0x07, 0x1C, 0x01, 0xF3, 0xE1,
  0x80, 0x0F, 0xF8, 0x18, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x18, 0x3F, 0xC0, 0xC3, 0xE4, 0x06, 0x70,
  0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x3E, 0x0F, 0xC1, 0xC0, 0x02, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x20, 0x00, 0x70, 0xC0, 0x07, 0x83, 0xF9, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x79, 0xC0, 0x3F, 0xC0, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x38, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38,
  0x30, 0x00, 0x0F, 0x06, 0x00, 0x03, 0x60, 0xE0, 0x00, 0x6C, 0x1C, 0x00,
  0x1B, 0x01, 0x80, 0x0E, 0x60, 0x38, 0x03, 0x8C, 0x03, 0xF7, 0xC1, 0x80,
  0x3F, 0xF0, 0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00,
  0xC0, 0x70, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x1C,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xB0, 0x00,
  0x3C, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0xCE, 0x00, 0x1B, 0x00, 0x0E,
  0x70, 0x01, 0xD8, 0x00, 0x61, 0x80, 0x0C, 0xC0, 0x07, 0x0C, 0x00, 0xE6,
  0x00, 0x30, 0x60, 0x06, 0x30, 0x03, 0x83, 0x00, 0x71, 0x80, 0x18, 0x18,
  0x03, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x60, 0x0C, 0x06, 0x01, 0x81, 0x80,
  0xE0, 0x30, 0x1C, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x0C, 0x0E,
  0x03, 0x03, 0x00, 0x60, 0x60, 0x18, 0x18, 0x03, 0x07, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x31, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0E,
  0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x6C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x18, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x43, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x05, 0xC0,
  0xF8, 0x03, 0xE0, 0x07, 0xF1, 0xE8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x38,
  0x00,
};

const GFXglyph NotoSans_ExtraLightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 42, 13, 2, -41 },
  { 59, 14, 15, 19, 6, -41 },
  { 86, 34, 41, 35, 2, -41 },
  { 261, 26, 46, 31, 3, -43 },
  { 411, 36, 42, 44, 5, -41 },
  { 600, 34, 42, 39, 3, -41 },
  { 779, 5, 15, 10, 6, -41 },
  { 789, 16, 50, 14, 2, -41 },
  { 889, 17, 50, 14, -4, -41 },
  { 996, 24, 24, 31, 7, -43 },
  { 1068, 27, 26, 32, 4, -33 },
  { 1156, 9, 14, 11, -3, -7 },
  { 1172, 14, 2, 18, 2, -16 },
  { 1176, 4, 5, 12, 2, -4 },
  { 1179, 26, 41, 18, -3, -41 },
  { 1313, 26, 42, 31, 4, -41 },
  { 1450, 15, 41, 31, 9, -41 },
  { 1527, 28, 41, 31, 1, -41 },
  { 1671, 29, 42, 31, 1, -41 },
  { 1824, 29, 41, 31, 1, -41 },
  { 1973, 29, 42, 31, 2, -41 },
  { 2126, 27, 42, 31, 4, -41 },
  { 2268, 26, 41, 31, 6, -41 },
  { 2402, 27, 42, 31, 3, -41 },
  { 2544, 27, 42, 31, 3, -41 },
  { 2686, 9, 32, 12, 2, -31 },
  { 2722, 14, 38, 12, -3, -31 },
  { 2789, 27, 26, 32, 4, -34 },
  { 2877, 27, 14, 32, 4, -27 },
  { 2925, 27, 26, 32, 4, -34 },
  { 3013, 19, 42, 23, 5, -41 },
  { 3113, 43, 45, 48, 3, -40 },
  { 3355, 32, 41, 31, -3, -41 },
  { 3519, 30, 41, 34, 3, -41 },
  { 3673, 31, 42, 34, 5, -41 },
  { 3836, 33, 41, 38, 3, -41 },
  { 4006, 29, 41, 30, 3, -41 },
  { 4155, 29, 41, 28, 3, -41 },
  { 4304, 33, 42, 39, 5, -41 },
  { 4478, 36, 41, 39, 3, -41 },
  { 4663, 19, 41, 16, 0, -41 },
  { 4761, 24, 51, 14, -10, -41 },
  { 4914, 33, 41, 31, 3, -41 },
  { 5084, 21, 41, 28, 3, -41 },
  { 5192, 43, 41, 46, 3, -41 },
  { 5413, 36, 41, 39, 3, -41 },
  { 5598, 34, 42, 41, 5, -41 },
  { 5777, 29, 41, 32, 3, -41 },
  { 5926, 34, 51, 41, 5, -41 },
  { 6143, 29, 41, 32, 3, -41 },
  { 6292, 28, 42, 28, 1, -41 },
  { 6439, 28, 41, 28, 5, -41 },
  { 6583, 34, 42, 39, 5, -41 },
  { 6762, 29, 41, 31, 6, -41 },
  { 6911, 44, 41, 47, 7, -41 },
  { 7137, 36, 41, 28, -3, -41 },
  { 7322, 28, 41, 28, 5, -41 },
  { 7466, 33, 41, 31, 0, -41 },
  { 7636, 22, 50, 17, -1, -41 },
  { 7774, 9, 41, 18, 6, -41 },
  { 7821, 21, 50, 17, -4, -41 },
  { 7953, 26, 25, 32, 3, -41 },
  { 8035, 22, 2, 21, -5, 6 },
  { 8041, 7, 9, 14, 8, -44 },
  { 8049, 27, 32, 31, 3, -31 },
  { 8157, 27, 44, 32, 2, -43 },
  { 8306, 23, 32, 26, 3, -31 },
  { 8398, 30, 44, 32, 3, -43 },
  { 8563, 23, 32, 28, 3, -31 },
  { 8655, 31, 58, 16, -7, -44 },
  { 8880, 30, 45, 32, 1, -31 },
  { 9049, 26, 43, 32, 2, -43 },
  { 9189, 11, 41, 12, 2, -41 },
  { 9246, 21, 55, 12, -8, -41 },
  { 9391, 26, 43, 26, 2, -43 },
  { 9531, 11, 43, 12, 2, -43 },
  { 9591, 43, 31, 48, 2, -31 },
  { 9758, 27, 31, 32, 2, -31 },
  { 9863, 26, 32, 32, 3, -31 },
  { 9967, 30, 44, 32, -1, -31 },
  { 10132, 28, 44, 32, 3, -31 },
  { 10286, 21, 31, 21, 2, -31 },
  { 10368, 22, 32, 24, 1, -31 },
  { 10456, 16, 39, 18, 3, -38 },
  { 10534, 27, 31, 32, 3, -30 },
  { 10639, 24, 30, 24, 3, -30 },
  { 10729, 37, 30, 38, 3, -30 },
  { 10868, 29, 30, 26, -2, -30 },
  { 10977, 33, 44, 24, -6, -30 },
  { 11159, 26, 30, 25, -1, -30 },
  { 11257, 21, 50, 19, 1, -41 },
  { 11389, 2, 57, 31, 16, -43 },
  { 11404, 21, 50, 19, -3, -41 },
  { 11536, 27, 6, 32, 4, -23 },
};

const GFXfont NotoSans_ExtraLightItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRALIGHTITALIC57PT7B_H_
