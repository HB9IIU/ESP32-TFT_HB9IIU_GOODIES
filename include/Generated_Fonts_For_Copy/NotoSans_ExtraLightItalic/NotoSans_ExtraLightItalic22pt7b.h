#ifndef _NOTOSANS_EXTRALIGHTITALIC22PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x00, 0x88, 0x45, 0x24, 0x92,
  0x4A, 0x40, 0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x80, 0x44, 0x3F, 0xFC,
  0x21, 0x01, 0x10, 0x10, 0x80, 0x84, 0x3F, 0xFC, 0x42, 0x02, 0x10, 0x10,
  0x80, 0x88, 0x08, 0x40, 0x01, 0x00, 0x40, 0xF8, 0x49, 0x22, 0x08, 0x82,
  0x40, 0x90, 0x1C, 0x01, 0x80, 0x58, 0x22, 0x08, 0x82, 0x28, 0x91, 0xF8,
  0x10, 0x04, 0x00, 0x38, 0x09, 0x10, 0x44, 0x41, 0x21, 0x08, 0x84, 0x42,
  0x12, 0x08, 0x4B, 0x22, 0x52, 0x8A, 0x85, 0xD2, 0x10, 0x48, 0x42, 0x41,
  0x11, 0x08, 0x84, 0x22, 0x11, 0x10, 0x3C, 0x07, 0x80, 0x42, 0x02, 0x10,
  0x20, 0x81, 0x04, 0x04, 0x40, 0x2C, 0x01, 0x80, 0x32, 0x02, 0x10, 0x60,
  0x45, 0x01, 0x28, 0x0A, 0x40, 0x23, 0x06, 0x8F, 0xC2, 0x55, 0x60, 0x04,
  0x21, 0x04, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x04, 0x00, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08,
  0x21, 0x04, 0x21, 0x08, 0x00, 0x04, 0x04, 0x22, 0x19, 0x02, 0xB8, 0xE0,
  0xA0, 0x88, 0x84, 0x02, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F,
  0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x24, 0xA5, 0x00, 0xF8, 0xC0, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x07, 0x81, 0x08, 0x41, 0x10,
  0x12, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x48,
  0x08, 0x82, 0x10, 0x41, 0xF0, 0x09, 0xD3, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x21, 0x08, 0x07, 0xC3, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x07,
  0xFE, 0x07, 0xC1, 0x82, 0x00, 0x20, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0xF8, 0x01, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x80, 0x87,
  0xF0, 0x00, 0x20, 0x06, 0x00, 0xA0, 0x12, 0x02, 0x40, 0x24, 0x04, 0x40,
  0x84, 0x10, 0x42, 0x08, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x0F, 0xE2, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x0B, 0x01, 0x98,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x40, 0x08, 0x01, 0x20, 0x47, 0xF0, 0x03,
  0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x13, 0xC2, 0x84, 0x60, 0x48,
  0x0A, 0x01, 0x40, 0x28, 0x08, 0x81, 0x10, 0x41, 0xF0, 0x7F, 0xC0, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x03, 0x00, 0x07, 0x83, 0x08, 0x40, 0x90, 0x12, 0x02,
  0x20, 0x86, 0x60, 0x30, 0x1B, 0x0C, 0x12, 0x02, 0x40, 0x28, 0x09, 0x01,
  0x10, 0x61, 0xF0, 0x0F, 0x02, 0x18, 0x81, 0x10, 0x24, 0x02, 0x80, 0x50,
  0x12, 0x02, 0x21, 0xC3, 0xC8, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x87,
  0xE0, 0x24, 0x00, 0x00, 0x02, 0x40, 0x08, 0x40, 0x00, 0x00, 0x00, 0x01,
  0x08, 0x84, 0x22, 0x00, 0x00, 0x40, 0xE0, 0xC0, 0xC0, 0xC0, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x70, 0x60, 0x60, 0x20,
  0x00, 0x7D, 0x04, 0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x41, 0x02, 0x00,
  0x00, 0x20, 0x40, 0x00, 0xF0, 0x03, 0x86, 0x02, 0x00, 0x82, 0x00, 0x22,
  0x00, 0x0A, 0x0F, 0xC5, 0x08, 0x42, 0x88, 0x21, 0x84, 0x10, 0xC4, 0x08,
  0x62, 0x08, 0x51, 0x04, 0x28, 0x4E, 0x22, 0x18, 0xE1, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x10, 0x07, 0xF0, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x14,
  0x02, 0x40, 0x22, 0x04, 0x20, 0x42, 0x08, 0x20, 0xFE, 0x10, 0x22, 0x02,
  0x20, 0x14, 0x01, 0x40, 0x18, 0x01, 0x1F, 0x81, 0x06, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x02, 0x20, 0x63, 0xF8, 0x20, 0xC4, 0x04, 0x40, 0x24, 0x02,
  0x40, 0x24, 0x04, 0x80, 0x8F, 0xF0, 0x03, 0xE0, 0xC1, 0x10, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x03, 0xF8, 0x1F, 0x80, 0x83, 0x04, 0x04, 0x20,
  0x22, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04,
  0x80, 0x24, 0x02, 0x20, 0x22, 0x06, 0x1F, 0xC0, 0x1F, 0xE2, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFC, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x07, 0xF8, 0x1F, 0xE2, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x07, 0xE0, 0x40, 0xC4, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x81, 0xF4, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x02, 0x20, 0x11, 0x01, 0x07, 0xF8, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44,
  0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x8F, 0xFC, 0x20, 0x11, 0x00, 0x44,
  0x01, 0x10, 0x04, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0x08, 0x1E, 0x08,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x78,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x1E, 0x00, 0x10,
  0x08, 0x81, 0x84, 0x10, 0x21, 0x02, 0x10, 0x11, 0x00, 0x90, 0x05, 0x80,
  0x34, 0x02, 0x10, 0x10, 0x80, 0x82, 0x04, 0x10, 0x20, 0x42, 0x02, 0x10,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0xFF, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC3,
  0x00, 0x62, 0x80, 0x51, 0x20, 0x48, 0x90, 0x24, 0x48, 0x24, 0x24, 0x12,
  0x22, 0x11, 0x11, 0x10, 0x88, 0x48, 0x44, 0x28, 0x42, 0x14, 0x22, 0x0C,
  0x11, 0x04, 0x08, 0x10, 0x04, 0x60, 0x11, 0x80, 0x45, 0x02, 0x24, 0x08,
  0x90, 0x22, 0x20, 0x88, 0x84, 0x21, 0x11, 0x04, 0x44, 0x11, 0x10, 0x24,
  0x40, 0xA1, 0x01, 0x88, 0x06, 0x20, 0x08, 0x07, 0xC0, 0xC1, 0x08, 0x04,
  0xC0, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x05, 0x00, 0x28, 0x02, 0x20, 0x11, 0x03, 0x07, 0xE0, 0x1F, 0x82, 0x08,
  0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x23, 0x8B, 0x81, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x07, 0xC0, 0xC1, 0x08, 0x04,
  0xC0, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x05, 0x00, 0x28, 0x02, 0x20, 0x11, 0x03, 0x07, 0xE0, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x1F, 0x82, 0x08, 0x40, 0x88, 0x12, 0x02, 0x40,
  0x48, 0x09, 0x02, 0x3F, 0x88, 0x41, 0x04, 0x20, 0x84, 0x10, 0x81, 0x20,
  0x24, 0x06, 0x07, 0xC1, 0x04, 0x40, 0x08, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x01, 0x00, 0x67, 0xF0,
  0xFF, 0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x09,
  0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80,
  0x14, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x40, 0x21, 0x02, 0x07, 0xE0,
  0x80, 0x38, 0x02, 0x80, 0x44, 0x04, 0x40, 0x84, 0x08, 0x41, 0x04, 0x10,
  0x42, 0x04, 0x20, 0x44, 0x02, 0x40, 0x28, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x80, 0x80, 0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x50, 0x48, 0x28, 0x24, 0x24,
  0x12, 0x12, 0x11, 0x11, 0x08, 0x88, 0x88, 0x48, 0x44, 0x24, 0x24, 0x14,
  0x0A, 0x0A, 0x06, 0x06, 0x03, 0x03, 0x01, 0x01, 0x00, 0x80, 0x08, 0x0C,
  0x20, 0x20, 0x81, 0x01, 0x08, 0x04, 0x40, 0x12, 0x00, 0x28, 0x00, 0xC0,
  0x03, 0x00, 0x14, 0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x81, 0x04, 0x04,
  0x20, 0x18, 0x80, 0x30, 0x09, 0x02, 0x20, 0x44, 0x10, 0x44, 0x09, 0x01,
  0x20, 0x28, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x1F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x1F, 0xF8, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xF0, 0x88, 0x84, 0x44,
  0x44, 0x22, 0x22, 0x22, 0x11, 0x0F, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x3E, 0x00, 0x02, 0x00, 0xC0, 0x50, 0x24, 0x08, 0x84, 0x22, 0x08,
  0x81, 0x40, 0x60, 0x10, 0xFF, 0x80, 0x89, 0x10, 0x0F, 0x44, 0x32, 0x0D,
  0x01, 0x40, 0x60, 0x28, 0x0A, 0x02, 0x81, 0xA0, 0x44, 0x31, 0xF4, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x09, 0xE2, 0x84, 0xC1, 0x60, 0x50, 0x14,
  0x05, 0x01, 0x40, 0x60, 0x1C, 0x0B, 0x04, 0xBE, 0x00, 0x0F, 0x88, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x07, 0xC0, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0xF2, 0x10, 0xA2, 0x04, 0x40,
  0x44, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x84, 0x28, 0x7C,
  0x80, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x1C, 0x73, 0xC1, 0x00, 0x80, 0x40,
  0x10, 0x07, 0xE0, 0x00, 0x70, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0xFC,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x0E, 0x00,
  0x0F, 0x22, 0x14, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80,
  0x90, 0x31, 0x0A, 0x3E, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0xFC, 0x00,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x09, 0xE2, 0x84, 0xC1, 0x60, 0x50,
  0x14, 0x05, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x00, 0x11, 0x00,
  0x22, 0x24, 0x44, 0x44, 0x88, 0x88, 0x01, 0x01, 0x00, 0x00, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0xE0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x32, 0x18,
  0x88, 0x44, 0x12, 0x05, 0x01, 0xA0, 0x48, 0x21, 0x08, 0x42, 0x08, 0x83,
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x80, 0x27, 0x0E,
  0x28, 0x91, 0x30, 0xA1, 0x60, 0xC1, 0x40, 0x81, 0x40, 0x81, 0x40, 0x81,
  0x40, 0x81, 0x81, 0x02, 0x81, 0x02, 0x81, 0x02, 0x81, 0x02, 0x27, 0x8A,
  0x13, 0x05, 0x81, 0x40, 0x50, 0x14, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A,
  0x04, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x24, 0x10, 0xF8, 0x13, 0xC2, 0x84, 0x60, 0x88, 0x12, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x40, 0x2C, 0x09, 0x82, 0x2F, 0x84, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x00, 0x0F, 0x22, 0x14, 0x83, 0x20, 0x24, 0x05, 0x00,
  0xA0, 0x14, 0x04, 0x80, 0x90, 0x31, 0x0A, 0x3E, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x27, 0x28, 0x30, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x1F, 0x10, 0x48, 0x04, 0x02, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x9F, 0x80, 0x10, 0x82, 0x3F, 0x20, 0x84, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x07, 0x00, 0x20, 0x24, 0x09, 0x01, 0x20, 0x24,
  0x04, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x32, 0x0C, 0x3E, 0x80, 0x80,
  0xC0, 0x60, 0x50, 0x24, 0x22, 0x21, 0x10, 0x90, 0x48, 0x28, 0x14, 0x04,
  0x00, 0x81, 0x06, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x12, 0x24, 0x48,
  0x92, 0x14, 0x48, 0x50, 0xA1, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x10, 0x31,
  0x04, 0x08, 0x40, 0x88, 0x05, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x11, 0x02,
  0x10, 0x20, 0x8C, 0x08, 0x10, 0x11, 0x01, 0x10, 0x20, 0x82, 0x08, 0x40,
  0x84, 0x08, 0x80, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x03, 0xFC, 0x02, 0x18, 0x20,
  0x81, 0x02, 0x04, 0x10, 0x21, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x0C, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x60,
  0x80, 0x70, 0x63, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 6, 6, 7, 2, -16 },
  { 14, 13, 16, 14, 1, -16 },
  { 40, 10, 18, 12, 1, -17 },
  { 63, 14, 16, 17, 2, -16 },
  { 91, 13, 16, 15, 1, -16 },
  { 117, 2, 6, 4, 2, -16 },
  { 119, 6, 19, 6, 1, -16 },
  { 134, 6, 19, 6, -1, -16 },
  { 149, 9, 10, 12, 3, -17 },
  { 161, 10, 10, 13, 2, -13 },
  { 174, 3, 6, 4, -1, -3 },
  { 177, 5, 1, 7, 1, -6 },
  { 178, 1, 2, 5, 1, -2 },
  { 179, 10, 16, 7, -1, -16 },
  { 199, 11, 16, 12, 1, -16 },
  { 221, 5, 16, 12, 4, -16 },
  { 231, 11, 16, 12, 0, -16 },
  { 253, 12, 16, 12, 0, -16 },
  { 277, 12, 16, 12, 0, -16 },
  { 301, 11, 16, 12, 1, -16 },
  { 323, 11, 16, 12, 1, -16 },
  { 345, 10, 16, 12, 2, -16 },
  { 365, 11, 16, 12, 1, -16 },
  { 387, 11, 16, 12, 1, -16 },
  { 409, 3, 12, 5, 1, -12 },
  { 414, 5, 15, 5, -1, -12 },
  { 424, 10, 10, 13, 2, -13 },
  { 437, 10, 5, 13, 2, -10 },
  { 444, 10, 10, 13, 2, -13 },
  { 457, 7, 16, 9, 2, -16 },
  { 471, 17, 18, 18, 1, -16 },
  { 510, 12, 16, 12, -1, -16 },
  { 534, 12, 16, 13, 1, -16 },
  { 558, 12, 16, 13, 2, -16 },
  { 582, 13, 16, 15, 1, -16 },
  { 608, 11, 16, 12, 1, -16 },
  { 630, 11, 16, 11, 1, -16 },
  { 652, 13, 16, 15, 2, -16 },
  { 678, 14, 16, 15, 1, -16 },
  { 706, 7, 16, 6, 0, -16 },
  { 720, 9, 20, 5, -4, -16 },
  { 743, 13, 16, 12, 1, -16 },
  { 769, 8, 16, 11, 1, -16 },
  { 785, 17, 16, 18, 1, -16 },
  { 819, 14, 16, 15, 1, -16 },
  { 847, 13, 16, 16, 2, -16 },
  { 873, 11, 16, 12, 1, -16 },
  { 895, 13, 20, 16, 2, -16 },
  { 928, 11, 16, 12, 1, -16 },
  { 950, 11, 16, 11, 0, -16 },
  { 972, 11, 16, 11, 2, -16 },
  { 994, 13, 16, 15, 2, -16 },
  { 1020, 12, 16, 12, 2, -16 },
  { 1044, 17, 16, 18, 3, -16 },
  { 1078, 14, 16, 11, -1, -16 },
  { 1106, 11, 16, 11, 2, -16 },
  { 1128, 13, 16, 12, 0, -16 },
  { 1154, 8, 19, 7, 0, -16 },
  { 1173, 4, 16, 7, 2, -16 },
  { 1181, 9, 19, 7, -2, -16 },
  { 1203, 10, 10, 12, 1, -16 },
  { 1216, 9, 1, 8, -2, 2 },
  { 1218, 3, 4, 5, 3, -17 },
  { 1220, 10, 12, 12, 1, -12 },
  { 1235, 10, 17, 13, 1, -17 },
  { 1257, 9, 12, 10, 1, -12 },
  { 1271, 12, 17, 13, 1, -17 },
  { 1297, 9, 12, 11, 1, -12 },
  { 1311, 12, 22, 6, -3, -17 },
  { 1344, 11, 17, 13, 1, -12 },
  { 1368, 10, 17, 12, 1, -17 },
  { 1390, 4, 16, 5, 1, -16 },
  { 1398, 8, 21, 5, -3, -16 },
  { 1419, 10, 17, 10, 1, -17 },
  { 1441, 4, 17, 5, 1, -17 },
  { 1450, 16, 12, 19, 1, -12 },
  { 1474, 10, 12, 12, 1, -12 },
  { 1489, 10, 12, 12, 1, -12 },
  { 1504, 11, 17, 13, 0, -12 },
  { 1528, 11, 17, 13, 1, -12 },
  { 1552, 8, 12, 8, 1, -12 },
  { 1564, 9, 12, 9, 0, -12 },
  { 1578, 6, 15, 7, 1, -15 },
  { 1590, 11, 12, 12, 1, -12 },
  { 1607, 9, 12, 9, 1, -12 },
  { 1621, 14, 12, 15, 1, -12 },
  { 1642, 12, 12, 10, -1, -12 },
  { 1660, 12, 17, 9, -2, -12 },
  { 1686, 10, 12, 10, 0, -12 },
  { 1701, 7, 19, 7, 1, -16 },
  { 1718, 1, 22, 12, 6, -17 },
  { 1721, 8, 20, 7, -1, -16 },
  { 1741, 10, 2, 13, 2, -9 },
};

const GFXfont NotoSans_ExtraLightItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRALIGHTITALIC22PT7B_H_
