#ifndef _NOTOSANS_EXTRALIGHTITALIC40PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x40, 0xE0, 0xE0, 0x30, 0xCC, 0x32, 0x08, 0x82, 0x21,
  0x98, 0x66, 0x11, 0x04, 0x41, 0x10, 0xCC, 0x20, 0x00, 0x18, 0x08, 0x00,
  0x18, 0x08, 0x00, 0x10, 0x18, 0x00, 0x10, 0x10, 0x00, 0x30, 0x10, 0x00,
  0x20, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x20, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0x40, 0x00, 0x80, 0xC0, 0x00,
  0x80, 0xC0, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x01, 0x01, 0x80, 0x03,
  0x01, 0x00, 0x03, 0x01, 0x00, 0xFF, 0xFF, 0xFC, 0x02, 0x03, 0x00, 0x06,
  0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C,
  0x04, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x0C,
  0x30, 0x83, 0x04, 0x00, 0x40, 0x80, 0x18, 0x10, 0x03, 0x06, 0x00, 0x60,
  0x80, 0x0C, 0x10, 0x00, 0xC2, 0x00, 0x0C, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x09, 0xC0, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x08,
  0x10, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x06, 0x10, 0x21,
  0x83, 0xF5, 0xE0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x01, 0x03, 0xB8, 0x00, 0xC1, 0x83, 0x00,
  0x60, 0x40, 0xC0, 0x10, 0x30, 0x30, 0x08, 0x08, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x80, 0x40, 0x30, 0x40, 0x10, 0x08, 0x30, 0x04,
  0x02, 0x18, 0x03, 0x01, 0x84, 0x00, 0xC0, 0x63, 0x1F, 0x30, 0x11, 0x98,
  0x64, 0x0C, 0xC4, 0x09, 0x86, 0x23, 0x03, 0x77, 0x18, 0x80, 0xC7, 0x8C,
  0x60, 0x30, 0x02, 0x10, 0x0C, 0x01, 0x04, 0x03, 0x00, 0xC1, 0x00, 0x80,
  0x60, 0xC0, 0x20, 0x10, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x03, 0x00, 0xC0, 0xC0, 0x80, 0x30, 0x60, 0x40, 0x06, 0x30, 0x30, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF3, 0x80, 0x01, 0x80, 0xC0, 0x01,
  0x00, 0x40, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x02, 0x00, 0x60, 0x02,
  0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x03, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0E,
  0x30, 0x01, 0x18, 0x18, 0x02, 0x30, 0x08, 0x06, 0x60, 0x0C, 0x04, 0xC0,
  0x06, 0x0C, 0xC0, 0x02, 0x18, 0x80, 0x03, 0x10, 0x80, 0x01, 0xA0, 0x80,
  0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x60, 0x60, 0x06, 0x30, 0x38,
  0x1C, 0x10, 0x1F, 0xF0, 0x1C, 0x33, 0x22, 0x26, 0x64, 0x44, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x0C, 0x08, 0x03, 0x84, 0x00, 0x72, 0x00,
  0x0D, 0x1F, 0x01, 0xFF, 0x81, 0x40, 0x01, 0x20, 0x01, 0x08, 0x03, 0x04,
  0x03, 0x03, 0x01, 0x00, 0x80, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x30, 0x86, 0x18, 0xC3, 0x18, 0x43, 0x00, 0x7F,
  0xFF, 0xF0, 0x5F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x73, 0xC0, 0x70, 0x18, 0x30, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x31,
  0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x58, 0x00, 0x16, 0x00, 0x0D, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0x80, 0x00,
  0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x03, 0x20, 0x00, 0xC8,
  0x00, 0x22, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x06, 0x01, 0x80, 0xC1,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x0D, 0x07, 0x61, 0x8C, 0xE1,
  0xB0, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x07,
  0xBC, 0x03, 0xC0, 0x60, 0x10, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x1F, 0xBC, 0x07, 0x00, 0x60, 0x40, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x80, 0x06, 0x0E, 0x01, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00,
  0x64, 0x00, 0x0C, 0x40, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00,
  0x40, 0x80, 0x08, 0x08, 0x01, 0x81, 0x80, 0x30, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x10, 0x18, 0x01, 0x03, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x20,
  0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x38, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC2, 0x00, 0x30, 0x70, 0x1C, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0x9C, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x70,
  0x06, 0x7F, 0xC0, 0x98, 0x0C, 0x34, 0x00, 0xC7, 0x00, 0x08, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0x40, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x02,
  0x20, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x08, 0x00, 0x81, 0x80, 0x70,
  0x1C, 0x1C, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3E, 0xF0, 0x0C, 0x03, 0x03, 0x00, 0x30, 0x40, 0x06, 0x08,
  0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x80, 0x08, 0x18,
  0x03, 0x01, 0x81, 0x80, 0x18, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x38,
  0xE0, 0x1C, 0x06, 0x06, 0x00, 0x61, 0x80, 0x04, 0x60, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x20, 0x00, 0x64, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00,
  0x61, 0x80, 0x18, 0x1C, 0x0E, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x3D,
  0xE0, 0x1C, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x04, 0x30, 0x00, 0xC4, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00,
  0x33, 0x00, 0x0E, 0x60, 0x01, 0x84, 0x00, 0x50, 0xC0, 0x36, 0x0F, 0x1C,
  0xC0, 0x7E, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x40, 0x70, 0x0F, 0xF8, 0x00, 0x0E, 0x1C, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x07, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0,
  0xFB, 0xC2, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x10, 0x03, 0xFE, 0x04, 0xC0,
  0x38, 0x10, 0x12, 0x01, 0x80, 0x40, 0x58, 0x0C, 0x03, 0x01, 0x60, 0x60,
  0x0C, 0x05, 0x01, 0x00, 0x20, 0x14, 0x0C, 0x00, 0x80, 0x70, 0x30, 0x06,
  0x03, 0xC0, 0x80, 0x10, 0x0F, 0x02, 0x00, 0x40, 0x2C, 0x08, 0x03, 0x01,
  0xB0, 0x20, 0x0C, 0x04, 0xC0, 0xC0, 0x50, 0x33, 0x03, 0x02, 0x41, 0x84,
  0x07, 0xF1, 0xFC, 0x18, 0x07, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x50,
  0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00,
  0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x04, 0x01, 0x80, 0x10,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x04, 0x10, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC2,
  0x00, 0x0C, 0x10, 0x00, 0xC1, 0x80, 0x0C, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x02, 0x00, 0x30, 0x10, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x40, 0x00, 0xC2, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x0E, 0x00, 0x40, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x08, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x60, 0x01,
  0x80, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x11, 0x80, 0x00, 0x23,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x62, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x40, 0x00, 0xE0, 0x80, 0x03,
  0x03, 0x00, 0x3C, 0x06, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x20, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x81, 0xFF, 0xF0, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x07, 0xFC,
  0xC0, 0x08, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x20, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x20, 0x0F, 0x01, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x10, 0x30, 0x00, 0x18, 0x10, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x20, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x02, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x33, 0xC0,
  0x1F, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x04, 0x00, 0x18, 0x08, 0x00, 0x60,
  0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x18, 0x01, 0x00, 0xE0, 0x06,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x43,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x98, 0x00, 0x0A, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x02, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x40, 0x02, 0x00, 0x80, 0x06, 0x03, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x2C, 0x12, 0x00, 0x01, 0xA0, 0x48, 0x00, 0x0C,
  0x83, 0x20, 0x00, 0x26, 0x0C, 0xC0, 0x01, 0x98, 0x33, 0x00, 0x04, 0x60,
  0x8C, 0x00, 0x31, 0x02, 0x10, 0x01, 0x8C, 0x18, 0x40, 0x04, 0x30, 0x61,
  0x00, 0x30, 0xC1, 0x86, 0x00, 0x82, 0x04, 0x18, 0x06, 0x08, 0x10, 0x60,
  0x30, 0x60, 0xC0, 0x80, 0xC1, 0x83, 0x02, 0x06, 0x06, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x30, 0xC0, 0x41, 0x80, 0xC2, 0x03, 0x06, 0x03, 0x18, 0x0C,
  0x18, 0x04, 0xC0, 0x30, 0x40, 0x12, 0x00, 0x81, 0x00, 0x58, 0x02, 0x0C,
  0x01, 0xC0, 0x18, 0x30, 0x07, 0x00, 0x60, 0xC0, 0x18, 0x01, 0x00, 0x02,
  0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xF0, 0x00, 0x20,
  0x78, 0x00, 0x10, 0x24, 0x00, 0x08, 0x13, 0x00, 0x0C, 0x18, 0x80, 0x06,
  0x0C, 0x60, 0x02, 0x06, 0x10, 0x01, 0x02, 0x0C, 0x01, 0x81, 0x06, 0x00,
  0xC1, 0x81, 0x00, 0x60, 0xC0, 0xC0, 0x20, 0x60, 0x20, 0x10, 0x20, 0x18,
  0x18, 0x10, 0x0C, 0x0C, 0x18, 0x02, 0x06, 0x0C, 0x01, 0x82, 0x04, 0x00,
  0x41, 0x02, 0x00, 0x31, 0x83, 0x00, 0x08, 0xC1, 0x80, 0x06, 0x40, 0xC0,
  0x03, 0x20, 0x40, 0x00, 0x90, 0x20, 0x00, 0x78, 0x30, 0x00, 0x1C, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF9, 0xF0,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x20, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xF8, 0x02, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x30, 0x60, 0x03,
  0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00,
  0x30, 0x80, 0x03, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x03,
  0xF0, 0x1F, 0xF8, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xF9, 0xF0, 0x01, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x04, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x20, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0xF8, 0x02, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x30, 0x60,
  0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x08,
  0x00, 0x30, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x03, 0x81,
  0xFF, 0xE0, 0x10, 0x18, 0x03, 0x01, 0x80, 0x30, 0x08, 0x03, 0x00, 0xC0,
  0x20, 0x04, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03,
  0x04, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x0C, 0x00, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC2, 0x00, 0x38, 0x70, 0x1C, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18,
  0x60, 0x00, 0x08, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03,
  0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xC4, 0x00,
  0x04, 0x20, 0x00, 0x61, 0x00, 0x02, 0x08, 0x00, 0x30, 0x60, 0x01, 0x03,
  0x00, 0x18, 0x18, 0x00, 0x80, 0xC0, 0x0C, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x60, 0x04, 0x02, 0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00,
  0x02, 0x20, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x01, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x34, 0x00, 0x38, 0x00, 0x6C, 0x00, 0x58, 0x00,
  0x98, 0x01, 0xB0, 0x03, 0x30, 0x02, 0x60, 0x04, 0x60, 0x0C, 0xC0, 0x18,
  0xC0, 0x11, 0x80, 0x21, 0x80, 0x63, 0x00, 0xC3, 0x00, 0xC6, 0x01, 0x86,
  0x03, 0x04, 0x06, 0x0C, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x10,
  0x30, 0x20, 0x60, 0x20, 0x40, 0x40, 0x80, 0x41, 0x80, 0x83, 0x00, 0x82,
  0x01, 0x04, 0x01, 0x0C, 0x02, 0x18, 0x02, 0x10, 0x04, 0x20, 0x04, 0x60,
  0x0C, 0xC0, 0x08, 0x80, 0x19, 0x00, 0x13, 0x00, 0x36, 0x00, 0x24, 0x00,
  0x6C, 0x00, 0x58, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x02, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x20, 0x40, 0x00, 0x18, 0x60, 0x00, 0x04, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x33, 0x00, 0x00, 0x30, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x10, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0x20, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x08, 0x01, 0x81, 0x00, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0x40, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00,
  0x11, 0x80, 0x02, 0x60, 0x00, 0x6C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x02, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFC, 0x00, 0x83, 0x0C, 0x10, 0x41,
  0x04, 0x18, 0x60, 0x82, 0x08, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x08,
  0x20, 0x82, 0x0C, 0x30, 0x41, 0x04, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x03, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xB0, 0x00, 0x44, 0x00,
  0x31, 0x00, 0x18, 0x60, 0x04, 0x08, 0x03, 0x02, 0x01, 0x80, 0xC0, 0x40,
  0x10, 0x30, 0x04, 0x18, 0x01, 0x86, 0x00, 0x23, 0x00, 0x08, 0x80, 0x03,
  0x60, 0x00, 0xF0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0xC6, 0x18, 0xC3,
  0x08, 0x20, 0x00, 0x70, 0x00, 0x7F, 0x8C, 0x1C, 0x19, 0x06, 0x01, 0xA1,
  0x80, 0x14, 0x20, 0x03, 0x8C, 0x00, 0x71, 0x00, 0x0C, 0x60, 0x01, 0x88,
  0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0x41, 0x00, 0x68, 0x30,
  0x1B, 0x03, 0x0E, 0x60, 0x3F, 0x08, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x04, 0x00, 0x43, 0xF8, 0x0C, 0xC0, 0xC0, 0xD8,
  0x06, 0x0B, 0x00, 0x60, 0xE0, 0x02, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x23, 0x00, 0x02, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x18,
  0x50, 0x03, 0x05, 0x80, 0x70, 0x4C, 0x1C, 0x0C, 0x7F, 0x80, 0x00, 0x30,
  0x01, 0xFF, 0x07, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x18, 0x0F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x20, 0x20, 0x0F, 0xF1, 0x01, 0xC0, 0xD8, 0x18,
  0x02, 0xC1, 0x80, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x01, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x06,
  0x00, 0x38, 0x30, 0x02, 0xC0, 0xC0, 0x64, 0x03, 0x06, 0x20, 0x0F, 0xE1,
  0x00, 0x00, 0x30, 0x01, 0xFE, 0x07, 0x03, 0x0E, 0x03, 0x18, 0x01, 0x18,
  0x01, 0x30, 0x01, 0x20, 0x03, 0x60, 0x06, 0x60, 0x1C, 0x43, 0xF0, 0x7F,
  0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x1C, 0x0F, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x61,
  0x00, 0x1F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF1, 0x03, 0x81, 0x90, 0x60, 0x0B,
  0x0C, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0x62, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x04, 0x60, 0x00, 0xC6, 0x00,
  0x0C, 0x60, 0x00, 0x86, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38, 0x60,
  0x05, 0x83, 0x01, 0x90, 0x18, 0x31, 0x00, 0xFE, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x0C, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x04, 0x00, 0x87, 0xF0, 0x33, 0x03,
  0x06, 0xC0, 0x30, 0xB0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x63, 0x00, 0x0C,
  0x60, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x06, 0x00, 0x03, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x1F, 0x80, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x06, 0x02, 0x03,
  0x00, 0x81, 0x80, 0x60, 0x80, 0x18, 0xC0, 0x04, 0x60, 0x01, 0x38, 0x00,
  0xDB, 0x00, 0x3C, 0xC0, 0x0E, 0x18, 0x03, 0x06, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x06, 0x06, 0x01, 0x81, 0x00, 0x30, 0x40, 0x0C, 0x30, 0x01,
  0x80, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x08,
  0xFE, 0x07, 0xF0, 0x33, 0x06, 0x38, 0x30, 0x68, 0x04, 0xC0, 0x20, 0xA0,
  0x0D, 0x00, 0x61, 0xC0, 0x1C, 0x00, 0xC3, 0x00, 0x38, 0x01, 0x8C, 0x00,
  0x60, 0x02, 0x18, 0x00, 0xC0, 0x04, 0x30, 0x01, 0x00, 0x18, 0x40, 0x06,
  0x00, 0x31, 0x80, 0x0C, 0x00, 0x63, 0x00, 0x18, 0x00, 0x86, 0x00, 0x20,
  0x01, 0x08, 0x00, 0x40, 0x06, 0x10, 0x01, 0x80, 0x0C, 0x60, 0x03, 0x00,
  0x18, 0xC0, 0x06, 0x00, 0x21, 0x80, 0x08, 0x00, 0x42, 0x00, 0x10, 0x01,
  0x84, 0x00, 0x60, 0x03, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x87, 0xF0, 0x33, 0x03, 0x06, 0xC0, 0x30, 0xB0, 0x06, 0x1C, 0x00, 0xC7,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x08, 0x40, 0x01, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00, 0x84, 0x00, 0x31, 0x80,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x70, 0x30, 0x30, 0x06, 0x18,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B,
  0x00, 0x06, 0xC0, 0x01, 0x90, 0x00, 0xC6, 0x00, 0x61, 0xC0, 0x38, 0x38,
  0x38, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x04, 0x3F, 0x80, 0x33, 0x03,
  0x00, 0xD8, 0x06, 0x02, 0xC0, 0x18, 0x0E, 0x00, 0x20, 0x30, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0x83, 0x00,
  0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C,
  0x1C, 0x00, 0x30, 0x70, 0x01, 0x81, 0x40, 0x0C, 0x05, 0x80, 0x70, 0x13,
  0x07, 0x00, 0xC7, 0xF8, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xC4, 0x1C,
  0x0C, 0x86, 0x00, 0xB1, 0x80, 0x1E, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00,
  0xE1, 0x00, 0x2C, 0x30, 0x19, 0x03, 0x06, 0x20, 0x3F, 0x8C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x08, 0x08, 0xFC,
  0x33, 0x00, 0x6C, 0x00, 0xB0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x0E, 0x03, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x80, 0x18, 0xE0, 0x30, 0x3F, 0xE0, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x81, 0xFF, 0xC6, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE1, 0x0F, 0xC0, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x38,
  0xC0, 0x0E, 0x18, 0x03, 0x41, 0x00, 0xC8, 0x38, 0x73, 0x03, 0xF8, 0x60,
  0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0x88, 0x00, 0xC4, 0x00, 0xC2, 0x00,
  0x61, 0x00, 0x60, 0xC0, 0x20, 0x60, 0x30, 0x30, 0x10, 0x08, 0x18, 0x04,
  0x18, 0x02, 0x0C, 0x01, 0x0C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x32, 0x00,
  0x0B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00,
  0xF0, 0x07, 0x00, 0x6C, 0x01, 0x40, 0x1B, 0x00, 0xD0, 0x04, 0xC0, 0x24,
  0x03, 0x10, 0x19, 0x00, 0x84, 0x04, 0x40, 0x61, 0x03, 0x10, 0x10, 0x40,
  0x86, 0x0C, 0x10, 0x61, 0x82, 0x04, 0x10, 0x61, 0x81, 0x0C, 0x18, 0x40,
  0x42, 0x06, 0x30, 0x11, 0x80, 0x88, 0x06, 0x40, 0x26, 0x01, 0xB0, 0x09,
  0x00, 0x68, 0x02, 0xC0, 0x1E, 0x00, 0xB0, 0x07, 0x00, 0x28, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x02,
  0x00, 0xC0, 0x30, 0x18, 0x01, 0x03, 0x00, 0x18, 0x60, 0x00, 0x8C, 0x00,
  0x0D, 0x80, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x01, 0xB0, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0xC0, 0x80, 0x08, 0x0C,
  0x01, 0x80, 0x40, 0x30, 0x06, 0x06, 0x00, 0x20, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x10,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0xC0, 0x01, 0x01, 0x00, 0x02, 0x06, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x40, 0x00, 0x31, 0x80, 0x00, 0x26, 0x00, 0x00, 0x48, 0x00,
  0x00, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x03, 0xC0,
  0x0F, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x78, 0xF0, 0x18, 0x07,
  0xFE, 0x00, 0x3C,
};

const GFXglyph NotoSans_ExtraLightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 10, 11, 13, 4, -29 },
  { 44, 24, 29, 25, 1, -29 },
  { 131, 19, 32, 22, 2, -30 },
  { 207, 26, 29, 31, 3, -29 },
  { 302, 24, 29, 27, 2, -29 },
  { 389, 4, 11, 7, 4, -29 },
  { 395, 12, 35, 10, 1, -29 },
  { 448, 12, 35, 10, -3, -29 },
  { 501, 17, 17, 21, 5, -30 },
  { 538, 18, 18, 23, 3, -23 },
  { 579, 6, 10, 8, -2, -5 },
  { 587, 10, 2, 12, 1, -12 },
  { 590, 3, 3, 9, 1, -3 },
  { 592, 18, 29, 13, -2, -29 },
  { 658, 18, 29, 22, 3, -29 },
  { 724, 11, 29, 22, 6, -29 },
  { 764, 20, 29, 22, 0, -29 },
  { 837, 20, 29, 22, 1, -29 },
  { 910, 20, 29, 22, 1, -29 },
  { 983, 19, 29, 22, 2, -29 },
  { 1052, 19, 29, 22, 3, -29 },
  { 1121, 18, 29, 22, 4, -29 },
  { 1187, 19, 29, 22, 2, -29 },
  { 1256, 19, 29, 22, 2, -29 },
  { 1325, 7, 21, 9, 1, -21 },
  { 1344, 10, 26, 9, -2, -21 },
  { 1377, 18, 19, 23, 3, -24 },
  { 1420, 18, 10, 23, 3, -19 },
  { 1443, 18, 19, 23, 3, -24 },
  { 1486, 14, 29, 16, 3, -29 },
  { 1537, 30, 32, 33, 2, -28 },
  { 1657, 22, 29, 22, -2, -29 },
  { 1737, 21, 29, 24, 2, -29 },
  { 1814, 22, 29, 24, 3, -29 },
  { 1894, 23, 29, 27, 2, -29 },
  { 1978, 20, 29, 21, 2, -29 },
  { 2051, 20, 29, 19, 2, -29 },
  { 2124, 24, 29, 28, 3, -29 },
  { 2211, 25, 29, 27, 2, -29 },
  { 2302, 13, 29, 12, 0, -29 },
  { 2350, 17, 36, 10, -7, -29 },
  { 2427, 23, 29, 22, 2, -29 },
  { 2511, 15, 29, 20, 2, -29 },
  { 2566, 30, 29, 33, 2, -29 },
  { 2675, 25, 29, 27, 2, -29 },
  { 2766, 24, 29, 29, 3, -29 },
  { 2853, 20, 29, 22, 2, -29 },
  { 2926, 24, 36, 29, 3, -29 },
  { 3034, 20, 29, 23, 2, -29 },
  { 3107, 19, 29, 20, 1, -29 },
  { 3176, 19, 29, 20, 4, -29 },
  { 3245, 25, 29, 28, 3, -29 },
  { 3336, 21, 29, 22, 4, -29 },
  { 3413, 31, 29, 33, 5, -29 },
  { 3526, 25, 29, 20, -2, -29 },
  { 3617, 19, 29, 20, 4, -29 },
  { 3686, 23, 29, 21, 0, -29 },
  { 3770, 15, 35, 12, 0, -29 },
  { 3836, 6, 29, 13, 4, -29 },
  { 3858, 15, 35, 12, -3, -29 },
  { 3924, 18, 18, 22, 2, -29 },
  { 3965, 15, 2, 15, -3, 4 },
  { 3969, 5, 7, 9, 6, -31 },
  { 3974, 19, 22, 22, 2, -22 },
  { 4027, 20, 30, 23, 1, -30 },
  { 4102, 16, 22, 18, 2, -22 },
  { 4146, 21, 30, 23, 2, -30 },
  { 4225, 16, 22, 20, 2, -22 },
  { 4269, 22, 41, 11, -5, -31 },
  { 4382, 20, 32, 23, 1, -22 },
  { 4462, 19, 30, 22, 1, -30 },
  { 4534, 8, 29, 9, 1, -29 },
  { 4563, 15, 39, 9, -6, -29 },
  { 4637, 18, 30, 18, 1, -30 },
  { 4705, 8, 30, 9, 1, -30 },
  { 4735, 31, 22, 34, 1, -22 },
  { 4821, 19, 22, 22, 1, -22 },
  { 4874, 18, 22, 23, 2, -22 },
  { 4924, 22, 31, 23, -1, -22 },
  { 5010, 19, 31, 23, 2, -22 },
  { 5084, 15, 22, 15, 1, -22 },
  { 5126, 16, 22, 17, 0, -22 },
  { 5170, 11, 26, 13, 2, -26 },
  { 5206, 19, 21, 22, 2, -21 },
  { 5256, 17, 21, 17, 2, -21 },
  { 5301, 26, 21, 27, 2, -21 },
  { 5370, 20, 21, 18, -1, -21 },
  { 5423, 23, 31, 17, -4, -21 },
  { 5513, 18, 21, 18, -1, -21 },
  { 5561, 14, 35, 13, 1, -29 },
  { 5623, 1, 40, 22, 11, -30 },
  { 5628, 15, 35, 13, -2, -29 },
  { 5694, 18, 4, 23, 3, -16 },
};

const GFXfont NotoSans_ExtraLightItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRALIGHTITALIC40PT7B_H_
