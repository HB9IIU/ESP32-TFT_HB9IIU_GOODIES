#ifndef _NOTOSANS_EXTRALIGHTITALIC28PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x31, 0x08, 0x42, 0x31, 0x08, 0x42, 0x21, 0x00, 0x00,
  0x31, 0x80, 0x66, 0x89, 0x12, 0x24, 0x51, 0x22, 0x00, 0x00, 0x86, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x80, 0x10, 0x40, 0xFF, 0xFE,
  0x04, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x04, 0x00, 0x82,
  0x07, 0xFF, 0xF0, 0x20, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x08,
  0x20, 0x04, 0x10, 0x00, 0x00, 0x40, 0x02, 0x00, 0xFC, 0x19, 0x11, 0x88,
  0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x48, 0x01, 0xC0, 0x03, 0x80,
  0x26, 0x01, 0x18, 0x08, 0x40, 0x42, 0x04, 0x20, 0x23, 0x3D, 0x70, 0x18,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x8C, 0x40, 0x42, 0x10,
  0x21, 0x04, 0x08, 0x41, 0x04, 0x10, 0x42, 0x04, 0x11, 0x02, 0x04, 0x40,
  0x82, 0x27, 0xA0, 0x92, 0x14, 0x49, 0x85, 0xE2, 0x41, 0x01, 0x10, 0x40,
  0x88, 0x10, 0x62, 0x04, 0x10, 0x83, 0x08, 0x20, 0x84, 0x08, 0x23, 0x02,
  0x11, 0x80, 0x78, 0x01, 0xF0, 0x01, 0x04, 0x01, 0x02, 0x00, 0x81, 0x80,
  0x40, 0x80, 0x20, 0x40, 0x10, 0x40, 0x0C, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x06, 0x60, 0x06, 0x10, 0x34, 0x04, 0x12, 0x01, 0x12, 0x00, 0xC9, 0x00,
  0x28, 0x80, 0x08, 0x20, 0x1E, 0x18, 0x19, 0x07, 0xF0, 0x40, 0x69, 0x25,
  0x20, 0x03, 0x06, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x06, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20,
  0xC0, 0x01, 0x00, 0x20, 0x82, 0x0E, 0x20, 0x32, 0x00, 0xDF, 0x06, 0x00,
  0xA0, 0x31, 0x06, 0x10, 0x41, 0x80, 0x08, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x32, 0x24, 0x48, 0x80, 0xFE, 0xF0, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x07, 0xE0, 0x41, 0x84, 0x04, 0x60, 0x32,
  0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x1A, 0x00, 0x90, 0x04, 0x80, 0x46, 0x06, 0x10, 0x60,
  0x7C, 0x00, 0x06, 0x38, 0xD6, 0x28, 0x41, 0x02, 0x04, 0x08, 0x30, 0x40,
  0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x00, 0x03, 0xF8, 0x18, 0x30,
  0x80, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x60, 0x61, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x60, 0x3E,
  0x00, 0x0E, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x88, 0x0C, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x18, 0x00, 0x50,
  0x01, 0x20, 0x04, 0x80, 0x11, 0x00, 0x42, 0x01, 0x84, 0x06, 0x18, 0x18,
  0x20, 0x20, 0x40, 0x80, 0x82, 0x01, 0x08, 0x04, 0x3F, 0xFF, 0x80, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x07, 0xFC, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x3F, 0x80,
  0x41, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x88, 0x0C, 0x1F, 0xE0, 0x01, 0xF8, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x4F, 0xC3, 0x81, 0x30,
  0x09, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0xD0, 0x04, 0x80, 0x26, 0x02,
  0x18, 0x20, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x03, 0xF0, 0x10, 0x20, 0x80, 0xC2, 0x01, 0x18, 0x04, 0x60, 0x30,
  0x80, 0x83, 0x04, 0x06, 0x60, 0x0E, 0x00, 0xCC, 0x0C, 0x08, 0x60, 0x11,
  0x00, 0x4C, 0x01, 0x20, 0x04, 0xC0, 0x11, 0x00, 0xC6, 0x06, 0x07, 0xE0,
  0x03, 0xE0, 0x30, 0x41, 0x80, 0x84, 0x02, 0x20, 0x0C, 0x80, 0x12, 0x00,
  0xC8, 0x03, 0x20, 0x08, 0x80, 0x61, 0x02, 0x83, 0xF2, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x10, 0x3F, 0x80, 0x11,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x04, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x82, 0x10, 0x42, 0x08, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x3F, 0x10, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x08, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x0C, 0x01, 0x80,
  0x18, 0x10, 0x00, 0x41, 0x00, 0x01, 0x10, 0x00, 0x09, 0x01, 0xF8, 0x68,
  0x30, 0x41, 0x83, 0x02, 0x0C, 0x10, 0x20, 0x61, 0x01, 0x07, 0x08, 0x08,
  0x28, 0x40, 0xC1, 0x42, 0x04, 0x1A, 0x10, 0x60, 0x90, 0xC4, 0x88, 0x83,
  0xC7, 0x84, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0xE0,
  0x02, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84, 0x02, 0x08, 0x04,
  0x18, 0x10, 0x10, 0x60, 0x20, 0xFF, 0xC3, 0x00, 0x84, 0x01, 0x10, 0x02,
  0x20, 0x06, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x0F, 0xF8, 0x10, 0x18,
  0x20, 0x08, 0x40, 0x10, 0x80, 0x23, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10,
  0x18, 0x3F, 0xC0, 0x80, 0x61, 0x00, 0x42, 0x00, 0x44, 0x00, 0x98, 0x01,
  0x20, 0x06, 0x40, 0x08, 0x80, 0x31, 0x01, 0xC7, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x10,
  0x0F, 0xF0, 0x0F, 0xF0, 0x04, 0x06, 0x02, 0x00, 0x81, 0x00, 0x60, 0x80,
  0x10, 0xC0, 0x0C, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC8,
  0x00, 0x64, 0x00, 0x22, 0x00, 0x11, 0x00, 0x19, 0x80, 0x08, 0x80, 0x0C,
  0x40, 0x0C, 0x20, 0x0C, 0x10, 0x38, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x3F, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xFF, 0xC1, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xFF, 0x83, 0x00, 0x83, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x1F,
  0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x13, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x04, 0x10, 0x02, 0x0C, 0x03, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x86, 0x00, 0x21, 0x00, 0x18,
  0x40, 0x04, 0x10, 0x01, 0x07, 0xFF, 0xC2, 0x00, 0x10, 0x80, 0x0C, 0x20,
  0x02, 0x08, 0x00, 0x86, 0x00, 0x21, 0x00, 0x08, 0x40, 0x06, 0x10, 0x01,
  0x04, 0x00, 0x43, 0x00, 0x10, 0x0F, 0x81, 0x00, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x1F, 0x00, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0xF8, 0x00, 0x0C, 0x01, 0x84, 0x01, 0x02, 0x03,
  0x01, 0x03, 0x00, 0x83, 0x00, 0xC3, 0x00, 0x42, 0x00, 0x22, 0x00, 0x12,
  0x00, 0x0A, 0x80, 0x0A, 0x40, 0x06, 0x30, 0x02, 0x08, 0x01, 0x06, 0x01,
  0x81, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x18, 0x10, 0x04, 0x18, 0x03,
  0x00, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x7F, 0xF0, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xA0,
  0x03, 0x82, 0x80, 0x0A, 0x0A, 0x00, 0x48, 0x48, 0x01, 0x61, 0x20, 0x09,
  0x04, 0x80, 0x24, 0x11, 0x01, 0x10, 0x44, 0x0C, 0x42, 0x10, 0x22, 0x08,
  0x41, 0x08, 0x21, 0x04, 0x20, 0x84, 0x20, 0x86, 0x09, 0x82, 0x10, 0x24,
  0x10, 0x40, 0xA0, 0x41, 0x02, 0x81, 0x04, 0x0C, 0x04, 0x30, 0x30, 0x30,
  0x0C, 0x00, 0x43, 0x00, 0x10, 0xE0, 0x08, 0x28, 0x02, 0x0A, 0x00, 0x84,
  0x40, 0x21, 0x10, 0x08, 0x42, 0x04, 0x10, 0x81, 0x04, 0x20, 0x42, 0x04,
  0x10, 0x81, 0x0C, 0x20, 0x22, 0x08, 0x08, 0x86, 0x03, 0x21, 0x00, 0x48,
  0x40, 0x16, 0x10, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x10, 0x03, 0xFC, 0x03,
  0x03, 0x02, 0x00, 0xC2, 0x00, 0x22, 0x00, 0x19, 0x00, 0x05, 0x80, 0x02,
  0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x14, 0x00, 0x0B, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x04, 0x10, 0x06, 0x0C,
  0x06, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x10, 0x30, 0x20, 0x10, 0x40, 0x30,
  0x80, 0x23, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x04, 0x20, 0x30, 0x83,
  0xC1, 0xF4, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x03, 0x03, 0x02, 0x00,
  0xC2, 0x00, 0x22, 0x00, 0x19, 0x00, 0x05, 0x80, 0x02, 0x80, 0x01, 0x40,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x14, 0x00, 0x0B,
  0x00, 0x0C, 0x80, 0x04, 0x40, 0x04, 0x10, 0x06, 0x0C, 0x06, 0x01, 0xFC,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0F, 0xF0, 0x10, 0x18, 0x20, 0x10, 0x40, 0x30, 0x80, 0x23, 0x00, 0x44,
  0x01, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x30, 0xFF, 0x81, 0x04, 0x02, 0x04,
  0x04, 0x08, 0x18, 0x18, 0x20, 0x10, 0x40, 0x20, 0x80, 0x61, 0x00, 0x46,
  0x00, 0xC0, 0x07, 0xF8, 0x60, 0x44, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x20, 0x31, 0xFE, 0x00, 0xFF,
  0xF8, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x10, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x33, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40,
  0x02, 0x20, 0x03, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x33, 0x00, 0x11, 0x80, 0x08, 0x40, 0x08, 0x20, 0x0C, 0x08, 0x0C,
  0x03, 0xF8, 0x00, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04, 0xC0, 0x11,
  0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0xC1, 0x02, 0x04, 0x18, 0x10, 0x40,
  0x42, 0x00, 0x88, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x00,
  0x0C, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x34, 0x03, 0x00, 0x90, 0x14,
  0x06, 0x40, 0x50, 0x11, 0x02, 0x40, 0x44, 0x09, 0x02, 0x10, 0x44, 0x08,
  0x41, 0x10, 0x41, 0x08, 0x41, 0x04, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44,
  0x09, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x16, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x06, 0x00, 0xC0,
  0x80, 0x20, 0x20, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x43, 0x00, 0x08,
  0x80, 0x02, 0x40, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x06, 0x80,
  0x01, 0x20, 0x00, 0x84, 0x00, 0x41, 0x00, 0x20, 0x60, 0x18, 0x08, 0x0C,
  0x02, 0x02, 0x00, 0x43, 0x00, 0x10, 0x80, 0x0C, 0x00, 0xB0, 0x0C, 0x80,
  0x44, 0x04, 0x20, 0x40, 0x86, 0x04, 0x20, 0x22, 0x01, 0xB0, 0x05, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xC1, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x03,
  0xE0, 0x88, 0x88, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11, 0x11, 0x07,
  0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x07, 0xE0, 0x00, 0xC0, 0x0E, 0x00,
  0x50, 0x04, 0x40, 0x62, 0x02, 0x10, 0x20, 0x83, 0x02, 0x10, 0x11, 0x00,
  0x98, 0x03, 0x80, 0x10, 0xFF, 0xC0, 0xC4, 0x23, 0x07, 0xC4, 0x30, 0xA1,
  0x01, 0x88, 0x06, 0x20, 0x19, 0x00, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x13,
  0x00, 0xCC, 0x02, 0x10, 0x18, 0x40, 0xA1, 0x84, 0x83, 0xE6, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x47, 0x82, 0xC2,
  0x18, 0x09, 0x80, 0x4C, 0x02, 0x40, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x28,
  0x01, 0x40, 0x12, 0x00, 0xA8, 0x09, 0x40, 0x89, 0xF8, 0x00, 0x0F, 0xE3,
  0x04, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x00, 0x81, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x81, 0xF1, 0x06, 0x12, 0x10, 0x18,
  0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x30, 0x04, 0x60,
  0x08, 0xC0, 0x30, 0x80, 0xA1, 0x01, 0x83, 0x0D, 0x03, 0xE2, 0x00, 0x07,
  0xC3, 0x08, 0x80, 0xB0, 0x14, 0x07, 0x00, 0xA0, 0xE7, 0xF0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x81, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x03, 0xF8, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x98, 0x00, 0x60, 0x00, 0x07, 0xC4, 0x30, 0x91, 0x01, 0x48, 0x02, 0x20,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0xC0, 0x13, 0x00, 0x4C, 0x03, 0x10,
  0x14, 0x40, 0x61, 0x86, 0x83, 0xE2, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0xC7, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x47, 0xC2, 0xC3, 0x18, 0x09, 0x80, 0x4C,
  0x02, 0x40, 0x12, 0x01, 0xB0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x01,
  0x20, 0x09, 0x00, 0x48, 0x02, 0x00, 0x08, 0x40, 0x00, 0x08, 0x42, 0x21,
  0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x24, 0x0E, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x62, 0x04, 0x10, 0x41, 0x04, 0x08, 0x40, 0x44,
  0x02, 0x40, 0x26, 0x01, 0x48, 0x0C, 0x40, 0x41, 0x02, 0x08, 0x20, 0x21,
  0x01, 0x08, 0x04, 0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x31, 0x08, 0x42, 0x21, 0x08, 0x00, 0x13, 0xE1, 0xF0, 0xA1, 0x90, 0xCA,
  0x05, 0x02, 0x60, 0x30, 0x13, 0x01, 0x80, 0x90, 0x08, 0x04, 0x80, 0x40,
  0x2C, 0x04, 0x02, 0x40, 0x20, 0x12, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80,
  0x40, 0x28, 0x04, 0x02, 0x40, 0x20, 0x12, 0x01, 0x00, 0x80, 0x11, 0xF0,
  0xB0, 0xCE, 0x02, 0x60, 0x13, 0x00, 0x90, 0x04, 0x80, 0x6C, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x4C, 0x02, 0x40, 0x12, 0x00, 0x80, 0x0F,
  0xC1, 0x86, 0x20, 0x34, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x04, 0x78,
  0x0B, 0x08, 0x18, 0x08, 0x60, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x00, 0x8C,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x22, 0x80, 0x85, 0x02,
  0x09, 0xF8, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xC4, 0x30, 0x91, 0x01, 0x48, 0x02, 0x20,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0xC0, 0x13, 0x00, 0x4C, 0x03, 0x10,
  0x14, 0x40, 0x61, 0x86, 0x83, 0xE2, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x13, 0xC5, 0x81, 0x80, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x00, 0x0F, 0xE3, 0x04, 0xC0, 0x10, 0x03, 0x00, 0x20, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x0D, 0x01, 0x1F, 0xC0, 0x08,
  0x10, 0x10, 0x7F, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0xC0, 0x40, 0x7C, 0x20, 0x1B, 0x00, 0x90, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x1B, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03, 0x20, 0x11, 0x01,
  0x88, 0x14, 0x41, 0xA1, 0xF1, 0x00, 0xC0, 0x14, 0x02, 0x40, 0x24, 0x04,
  0x40, 0x44, 0x08, 0x41, 0x86, 0x10, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40,
  0x28, 0x02, 0x80, 0x30, 0x00, 0x80, 0x80, 0xE0, 0x60, 0x28, 0x18, 0x12,
  0x0A, 0x04, 0x82, 0x82, 0x21, 0x20, 0x88, 0x44, 0x62, 0x21, 0x10, 0x88,
  0x4C, 0x24, 0x12, 0x09, 0x04, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x30, 0x18,
  0x0C, 0x06, 0x00, 0x18, 0x04, 0x20, 0x20, 0xC1, 0x01, 0x08, 0x06, 0x60,
  0x0B, 0x00, 0x38, 0x00, 0x40, 0x03, 0x00, 0x12, 0x00, 0x88, 0x04, 0x10,
  0x30, 0x41, 0x80, 0x8C, 0x03, 0x00, 0x0C, 0x01, 0x04, 0x02, 0x04, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x04, 0x18, 0x02, 0x10, 0x02, 0x30,
  0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0xE0, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xFF,
  0xC0, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x01, 0x80, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x03, 0x80, 0x7C, 0x0C, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraLightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 20, 6, 1, -20 },
  { 14, 7, 7, 9, 3, -20 },
  { 21, 17, 20, 17, 1, -20 },
  { 64, 13, 23, 15, 1, -21 },
  { 102, 18, 20, 22, 2, -20 },
  { 147, 17, 20, 19, 1, -20 },
  { 190, 3, 7, 5, 3, -20 },
  { 193, 8, 24, 7, 1, -20 },
  { 217, 8, 24, 7, -2, -20 },
  { 241, 12, 12, 15, 3, -21 },
  { 259, 13, 13, 16, 2, -16 },
  { 281, 4, 7, 6, -1, -3 },
  { 285, 7, 1, 9, 1, -8 },
  { 286, 2, 2, 6, 1, -2 },
  { 287, 12, 20, 9, -1, -20 },
  { 317, 13, 20, 15, 2, -20 },
  { 350, 7, 20, 15, 5, -20 },
  { 368, 14, 20, 15, 0, -20 },
  { 403, 14, 20, 15, 1, -20 },
  { 438, 15, 20, 15, 0, -20 },
  { 476, 14, 20, 15, 1, -20 },
  { 511, 13, 20, 15, 2, -20 },
  { 544, 13, 20, 15, 3, -20 },
  { 577, 14, 20, 15, 1, -20 },
  { 612, 14, 20, 15, 1, -20 },
  { 647, 4, 15, 6, 1, -15 },
  { 655, 6, 19, 6, -1, -15 },
  { 670, 13, 13, 16, 2, -17 },
  { 692, 13, 6, 16, 2, -13 },
  { 702, 13, 13, 16, 2, -17 },
  { 724, 10, 20, 11, 2, -20 },
  { 749, 21, 23, 23, 2, -20 },
  { 810, 15, 20, 15, -1, -20 },
  { 848, 15, 20, 17, 1, -20 },
  { 886, 16, 20, 17, 2, -20 },
  { 926, 17, 20, 19, 1, -20 },
  { 969, 15, 20, 15, 1, -20 },
  { 1007, 15, 20, 14, 1, -20 },
  { 1045, 17, 20, 19, 2, -20 },
  { 1088, 18, 20, 19, 1, -20 },
  { 1133, 9, 20, 8, 0, -20 },
  { 1156, 12, 25, 7, -5, -20 },
  { 1194, 17, 20, 15, 1, -20 },
  { 1237, 11, 20, 14, 1, -20 },
  { 1265, 22, 20, 23, 1, -20 },
  { 1320, 18, 20, 19, 1, -20 },
  { 1365, 17, 20, 20, 2, -20 },
  { 1408, 15, 20, 16, 1, -20 },
  { 1446, 17, 25, 20, 2, -20 },
  { 1500, 15, 20, 16, 1, -20 },
  { 1538, 13, 20, 14, 1, -20 },
  { 1571, 13, 20, 14, 3, -20 },
  { 1604, 17, 20, 19, 2, -20 },
  { 1647, 14, 20, 15, 3, -20 },
  { 1682, 22, 20, 23, 3, -20 },
  { 1737, 18, 20, 14, -2, -20 },
  { 1782, 13, 20, 14, 3, -20 },
  { 1815, 16, 20, 15, 0, -20 },
  { 1855, 10, 24, 8, 0, -20 },
  { 1885, 4, 20, 9, 3, -20 },
  { 1895, 11, 24, 8, -2, -20 },
  { 1928, 13, 12, 16, 1, -20 },
  { 1948, 10, 1, 11, -2, 3 },
  { 1950, 4, 4, 7, 4, -21 },
  { 1952, 14, 15, 15, 1, -15 },
  { 1979, 13, 21, 16, 1, -21 },
  { 2014, 11, 15, 13, 2, -15 },
  { 2035, 15, 21, 16, 1, -21 },
  { 2075, 11, 15, 14, 2, -15 },
  { 2096, 16, 28, 8, -4, -21 },
  { 2152, 14, 22, 16, 1, -15 },
  { 2191, 13, 21, 16, 1, -21 },
  { 2226, 5, 20, 6, 1, -20 },
  { 2239, 10, 27, 6, -4, -20 },
  { 2273, 13, 21, 13, 1, -21 },
  { 2308, 5, 21, 6, 1, -21 },
  { 2322, 21, 15, 24, 1, -15 },
  { 2362, 13, 15, 16, 1, -15 },
  { 2387, 12, 15, 16, 2, -15 },
  { 2410, 15, 22, 16, -1, -15 },
  { 2452, 14, 22, 16, 1, -15 },
  { 2491, 10, 15, 11, 1, -15 },
  { 2510, 11, 15, 12, 0, -15 },
  { 2531, 8, 18, 9, 1, -18 },
  { 2549, 13, 15, 16, 2, -15 },
  { 2574, 12, 15, 12, 1, -15 },
  { 2597, 18, 15, 19, 2, -15 },
  { 2631, 14, 15, 13, -1, -15 },
  { 2658, 16, 22, 12, -3, -15 },
  { 2702, 12, 15, 12, 0, -15 },
  { 2725, 10, 24, 9, 1, -20 },
  { 2755, 1, 28, 15, 8, -21 },
  { 2759, 10, 24, 9, -1, -20 },
  { 2789, 13, 2, 16, 2, -11 },
};

const GFXfont NotoSans_ExtraLightItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRALIGHTITALIC28PT7B_H_
