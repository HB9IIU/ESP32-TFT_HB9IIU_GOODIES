#ifndef _NOTOSANS_EXTRALIGHTITALIC18PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x90, 0x08, 0x59, 0x99, 0xA0, 0x08, 0x82, 0x20,
  0x88, 0x44, 0x7F, 0xC4, 0x41, 0x20, 0x88, 0xFF, 0x88, 0x84, 0x41, 0x10,
  0x44, 0x00, 0x04, 0x04, 0x1F, 0x24, 0x48, 0x48, 0x28, 0x18, 0x0E, 0x12,
  0x12, 0x12, 0xFC, 0x20, 0x20, 0x70, 0x51, 0x12, 0x22, 0x44, 0x88, 0xA1,
  0x25, 0xA5, 0x4F, 0x51, 0x12, 0x22, 0x44, 0x88, 0xA1, 0x28, 0x38, 0x0E,
  0x02, 0x20, 0x84, 0x10, 0x81, 0x20, 0x28, 0x0E, 0x02, 0x23, 0x84, 0x50,
  0x52, 0x04, 0x41, 0x47, 0xCC, 0x6A, 0x80, 0x08, 0x88, 0x84, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x44,
  0x22, 0x11, 0x10, 0x08, 0x08, 0x88, 0x70, 0x1F, 0x28, 0x48, 0x04, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x29, 0x40,
  0xF0, 0x80, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0x80, 0x1E, 0x10, 0x88, 0x28, 0x14, 0x0C, 0x06, 0x05, 0x02,
  0x81, 0x40, 0xA0, 0x90, 0x87, 0x80, 0x13, 0xD1, 0x12, 0x22, 0x22, 0x44,
  0x40, 0x0F, 0x08, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x0F, 0xF0, 0x0F, 0x18, 0x40, 0x20, 0x10, 0x08, 0x08, 0x78,
  0x02, 0x00, 0x80, 0x40, 0x40, 0x2F, 0xE0, 0x00, 0x80, 0x60, 0x28, 0x12,
  0x09, 0x04, 0x41, 0x10, 0x84, 0x41, 0x3F, 0xF0, 0x20, 0x08, 0x02, 0x00,
  0x1F, 0x90, 0x08, 0x04, 0x04, 0x03, 0xE0, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x4F, 0xC0, 0x0F, 0x88, 0x08, 0x04, 0x04, 0x02, 0xF3, 0x85, 0x02,
  0x81, 0x40, 0xA0, 0x48, 0x47, 0xC0, 0xFF, 0x01, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1E, 0x10, 0x88, 0x24, 0x12,
  0x10, 0x90, 0x70, 0xC4, 0x81, 0x40, 0xA0, 0x50, 0x47, 0xC0, 0x1E, 0x21,
  0x41, 0x41, 0x41, 0x41, 0x43, 0x3D, 0x01, 0x02, 0x02, 0x04, 0xF8, 0x50,
  0x00, 0x20, 0x11, 0x00, 0x00, 0x00, 0x24, 0x48, 0x00, 0x81, 0x83, 0x06,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x00, 0x7C,
  0x04, 0x08, 0x10, 0x41, 0x04, 0x10, 0x40, 0x80, 0x00, 0x0C, 0x00, 0x03,
  0xE0, 0x30, 0x43, 0x00, 0x90, 0x02, 0x47, 0xC6, 0x21, 0x18, 0x84, 0x64,
  0x21, 0x90, 0x8A, 0x46, 0x28, 0xE7, 0x20, 0x00, 0x40, 0x00, 0xC3, 0x00,
  0xF0, 0x00, 0x01, 0x00, 0x40, 0x28, 0x12, 0x04, 0x82, 0x20, 0x88, 0x7E,
  0x10, 0x48, 0x14, 0x05, 0x01, 0x80, 0x40, 0x1F, 0x10, 0x48, 0x24, 0x12,
  0x0A, 0x09, 0xF8, 0x82, 0x40, 0xC0, 0x60, 0x50, 0x2F, 0xE0, 0x07, 0xC6,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x3F, 0x00, 0x1F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05,
  0x01, 0x40, 0x60, 0x28, 0x0A, 0x0C, 0xFC, 0x00, 0x1F, 0x90, 0x08, 0x04,
  0x02, 0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20, 0x10, 0x0F, 0xC0, 0x1F,
  0x90, 0x08, 0x04, 0x02, 0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x07, 0xE3, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0xE4,
  0x02, 0x80, 0x50, 0x09, 0x01, 0x20, 0x43, 0xF8, 0x20, 0x24, 0x04, 0x80,
  0x90, 0x12, 0x04, 0x80, 0x9F, 0xF2, 0x02, 0x40, 0x50, 0x12, 0x02, 0x40,
  0x48, 0x08, 0x1C, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0xE0,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x70, 0x20, 0x48, 0x22, 0x10, 0x88, 0x24, 0x16, 0x06, 0x81, 0x20,
  0x44, 0x21, 0x08, 0x22, 0x08, 0x81, 0x00, 0x20, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x42, 0x08, 0x20, 0xFC, 0x10, 0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x0A,
  0x50, 0x29, 0x21, 0x24, 0x85, 0x12, 0x24, 0x49, 0x12, 0x24, 0x48, 0xA1,
  0x21, 0x88, 0x84, 0x20, 0x20, 0x26, 0x04, 0xC0, 0x94, 0x12, 0x84, 0x88,
  0x91, 0x12, 0x22, 0x42, 0x50, 0x52, 0x06, 0x40, 0xC8, 0x08, 0x0F, 0x82,
  0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x09,
  0x01, 0x20, 0x43, 0xF0, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x0C,
  0xF8, 0x40, 0x40, 0x20, 0x10, 0x08, 0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0,
  0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x09, 0x01, 0x20, 0x43,
  0xB0, 0x08, 0x00, 0x80, 0x08, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x0A, 0x05,
  0x0C, 0xF8, 0x44, 0x41, 0x20, 0x90, 0x48, 0x10, 0x0F, 0x88, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x80, 0x40, 0x4F, 0xC0, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x12, 0x08, 0x7C, 0x00, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22,
  0x10, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x04, 0x00, 0x81, 0x06, 0x0C, 0x18,
  0x30, 0xA1, 0x42, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x22,
  0x85, 0x0A, 0x14, 0x10, 0x20, 0x40, 0x80, 0x10, 0x22, 0x08, 0x22, 0x04,
  0x40, 0x50, 0x0C, 0x01, 0x00, 0x50, 0x0A, 0x02, 0x20, 0x84, 0x20, 0x88,
  0x08, 0x81, 0xC0, 0xA0, 0x88, 0x84, 0x82, 0x41, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x00, 0x1F, 0xC0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0xFF, 0x00, 0x1E, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x70, 0x92,
  0x48, 0x92, 0x49, 0x12, 0x1E, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x70, 0x04, 0x0C, 0x12, 0x12, 0x22, 0x41,
  0x41, 0x81, 0xFE, 0xA4, 0x1D, 0x23, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x86, 0x7A, 0x20, 0x20, 0x20, 0x20, 0x4E, 0x51, 0x61, 0x41, 0x41, 0x81,
  0x81, 0x81, 0x82, 0xFC, 0x1E, 0x41, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80,
  0xF8, 0x00, 0x40, 0x20, 0x08, 0x02, 0x1C, 0x88, 0xA4, 0x12, 0x04, 0x81,
  0x20, 0x48, 0x22, 0x08, 0x86, 0x1E, 0x80, 0x1C, 0x45, 0x0A, 0x18, 0xDE,
  0x20, 0x40, 0x80, 0xF8, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x1F, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x30, 0x00, 0x0E, 0x44, 0x52, 0x09, 0x02, 0x40, 0x90, 0x24, 0x11,
  0x04, 0x43, 0x0F, 0x40, 0x10, 0x08, 0x02, 0x3F, 0x00, 0x20, 0x20, 0x20,
  0x20, 0x4E, 0x51, 0x61, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x20,
  0x24, 0x92, 0x92, 0x48, 0x02, 0x00, 0x00, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0xE0, 0x20, 0x20, 0x20, 0x20, 0x41,
  0x42, 0x44, 0x48, 0x50, 0xF0, 0x90, 0x88, 0x88, 0x84, 0x24, 0x94, 0x92,
  0x52, 0x49, 0x00, 0x4C, 0x72, 0x94, 0x58, 0x42, 0x82, 0x14, 0x20, 0xC1,
  0x06, 0x08, 0x30, 0x42, 0x84, 0x14, 0x20, 0x80, 0x4E, 0x51, 0x61, 0x41,
  0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x1C, 0x23, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x7C, 0x27, 0x14, 0x4C, 0x24, 0x12, 0x0A, 0x05, 0x02,
  0x81, 0x41, 0x3F, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1C, 0x91, 0x50, 0x50,
  0x28, 0x14, 0x0A, 0x09, 0x04, 0x86, 0x3D, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x4D, 0x46, 0x10, 0x42, 0x08, 0x20, 0x82, 0x00, 0x1E, 0x41, 0x02, 0x03,
  0x01, 0x01, 0x02, 0x05, 0xF0, 0x21, 0x3E, 0x84, 0x21, 0x10, 0x84, 0x21,
  0xC0, 0x41, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x86, 0x7A, 0x83,
  0x06, 0x14, 0x28, 0x91, 0x14, 0x28, 0x60, 0x80, 0x84, 0x18, 0x42, 0x8C,
  0x28, 0xA4, 0x92, 0x49, 0x28, 0xA2, 0x8A, 0x30, 0xC3, 0x04, 0x20, 0x20,
  0x44, 0x21, 0x10, 0x28, 0x0C, 0x03, 0x01, 0x40, 0x88, 0x22, 0x30, 0x40,
  0x10, 0x44, 0x11, 0x08, 0x42, 0x11, 0x02, 0x40, 0xA0, 0x28, 0x0C, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x38, 0x00, 0x3F, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x40, 0xFC, 0x06, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0xE0,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x02, 0x0A, 0x10, 0x40, 0x81, 0x02, 0x08, 0x60, 0xF8,
  0x83, 0x80,
};

const GFXglyph NotoSans_ExtraLightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 13, 4, 1, -13 },
  { 6, 4, 5, 6, 2, -13 },
  { 9, 10, 13, 11, 1, -13 },
  { 26, 8, 15, 10, 1, -14 },
  { 41, 11, 13, 14, 2, -13 },
  { 59, 11, 13, 12, 1, -13 },
  { 77, 2, 5, 3, 2, -13 },
  { 79, 5, 16, 5, 1, -13 },
  { 89, 5, 16, 5, -1, -13 },
  { 99, 8, 8, 10, 2, -14 },
  { 107, 9, 9, 10, 1, -11 },
  { 118, 3, 4, 4, -1, -2 },
  { 120, 4, 1, 6, 1, -5 },
  { 121, 1, 1, 4, 1, -1 },
  { 122, 8, 13, 6, -1, -13 },
  { 135, 9, 13, 10, 1, -13 },
  { 150, 4, 13, 10, 3, -13 },
  { 157, 9, 13, 10, 0, -13 },
  { 172, 9, 13, 10, 0, -13 },
  { 187, 10, 13, 10, 0, -13 },
  { 204, 9, 13, 10, 1, -13 },
  { 219, 9, 13, 10, 1, -13 },
  { 234, 8, 13, 10, 2, -13 },
  { 247, 9, 13, 10, 1, -13 },
  { 262, 8, 13, 10, 1, -13 },
  { 275, 2, 10, 4, 1, -10 },
  { 278, 4, 12, 4, -1, -10 },
  { 284, 9, 9, 10, 1, -11 },
  { 295, 9, 4, 10, 1, -8 },
  { 300, 9, 9, 10, 1, -11 },
  { 311, 7, 13, 7, 1, -13 },
  { 323, 14, 15, 15, 1, -13 },
  { 350, 10, 13, 10, -1, -13 },
  { 367, 9, 13, 11, 1, -13 },
  { 382, 10, 13, 11, 1, -13 },
  { 399, 10, 13, 12, 1, -13 },
  { 416, 9, 13, 10, 1, -13 },
  { 431, 9, 13, 9, 1, -13 },
  { 446, 11, 13, 12, 1, -13 },
  { 464, 11, 13, 12, 1, -13 },
  { 482, 6, 13, 5, 0, -13 },
  { 492, 7, 16, 4, -3, -13 },
  { 506, 10, 13, 10, 1, -13 },
  { 523, 6, 13, 9, 1, -13 },
  { 533, 14, 13, 15, 1, -13 },
  { 556, 11, 13, 12, 1, -13 },
  { 574, 11, 13, 13, 1, -13 },
  { 592, 9, 13, 10, 1, -13 },
  { 607, 11, 16, 13, 1, -13 },
  { 629, 9, 13, 10, 1, -13 },
  { 644, 9, 13, 9, 0, -13 },
  { 659, 8, 13, 9, 2, -13 },
  { 672, 10, 13, 12, 2, -13 },
  { 689, 9, 13, 10, 2, -13 },
  { 704, 14, 13, 15, 2, -13 },
  { 727, 11, 13, 9, -1, -13 },
  { 745, 9, 13, 9, 2, -13 },
  { 760, 10, 13, 10, 0, -13 },
  { 777, 7, 16, 5, 0, -13 },
  { 791, 3, 13, 6, 2, -13 },
  { 796, 7, 16, 5, -1, -13 },
  { 810, 8, 8, 10, 1, -13 },
  { 818, 7, 1, 7, -2, 2 },
  { 819, 2, 3, 4, 3, -14 },
  { 820, 8, 10, 10, 1, -10 },
  { 830, 8, 14, 10, 1, -14 },
  { 844, 7, 10, 8, 1, -10 },
  { 853, 10, 14, 10, 1, -14 },
  { 871, 7, 10, 9, 1, -10 },
  { 880, 10, 18, 5, -2, -14 },
  { 903, 10, 14, 10, 0, -10 },
  { 921, 8, 14, 10, 1, -14 },
  { 935, 3, 13, 4, 1, -13 },
  { 940, 7, 17, 4, -3, -13 },
  { 955, 8, 14, 8, 1, -14 },
  { 969, 3, 14, 4, 1, -14 },
  { 975, 13, 10, 15, 1, -10 },
  { 992, 8, 10, 10, 1, -10 },
  { 1002, 8, 10, 10, 1, -10 },
  { 1012, 9, 14, 10, 0, -10 },
  { 1028, 9, 14, 10, 1, -10 },
  { 1044, 6, 10, 7, 1, -10 },
  { 1052, 7, 10, 8, 0, -10 },
  { 1061, 5, 12, 6, 1, -12 },
  { 1069, 8, 10, 10, 1, -10 },
  { 1079, 7, 10, 8, 1, -10 },
  { 1088, 12, 10, 12, 1, -10 },
  { 1103, 10, 10, 8, -1, -10 },
  { 1116, 10, 14, 8, -2, -10 },
  { 1134, 8, 10, 8, 0, -10 },
  { 1144, 7, 16, 6, 0, -13 },
  { 1158, 1, 18, 10, 5, -14 },
  { 1161, 7, 16, 6, -1, -13 },
  { 1175, 9, 2, 10, 1, -7 },
};

const GFXfont NotoSans_ExtraLightItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRALIGHTITALIC18PT7B_H_
