#ifndef _NOTOSANS_EXTRALIGHTITALIC70PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x1C, 0x07, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x70,
  0x0C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xC0,
  0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xCE, 0x7F, 0x80, 0x1F, 0x07, 0x03, 0x80,
  0x1E, 0x03, 0x00, 0x40, 0x1E, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x00, 0x7C, 0x60,
  0x00, 0x00, 0x1F, 0xB0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x06, 0xF8, 0x00, 0x00, 0x03,
  0x1F, 0x00, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x01, 0x80, 0x3C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x3C, 0x07,
  0x00, 0x30, 0x3C, 0x03, 0xF8, 0x38, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x38, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x0C, 0x0C, 0x00, 0x1C,
  0x0E, 0x07, 0xF8, 0xC0, 0x01, 0xC1, 0xC1, 0xFF, 0xCE, 0x00, 0x18, 0x18,
  0x3C, 0x1E, 0xE0, 0x03, 0x83, 0x87, 0x00, 0xEE, 0x00, 0x70, 0x70, 0x60,
  0x07, 0xE0, 0x07, 0x0E, 0x0E, 0x00, 0x77, 0x00, 0xE0, 0xC1, 0xC0, 0x03,
  0x78, 0x1C, 0x1C, 0x1C, 0x00, 0x33, 0xFF, 0x83, 0x83, 0x80, 0x03, 0x1F,
  0xF0, 0x70, 0x38, 0x00, 0x30, 0x70, 0x06, 0x03, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x60, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0x30, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x38, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x07, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xDC, 0x00, 0x00, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x80, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x38, 0x00, 0x00, 0x1E, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x8F,
  0x03, 0x80, 0x00, 0x00, 0x73, 0x80, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x38,
  0x00, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x1C, 0x00, 0x00, 0x1C,
  0x70, 0x03, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x71, 0x8E,
  0x38, 0xE3, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xF0, 0x03, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x0F, 0x80, 0xC0,
  0x00, 0x1F, 0x0C, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0x7B, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF6, 0x00, 0x7B, 0x80, 0x7C, 0xE0,
  0x3C, 0x38, 0x3E, 0x0C, 0x1E, 0x07, 0x1F, 0x01, 0xCF, 0x00, 0x71, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x20, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x39, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x87, 0xF0,
  0x00, 0x18, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x3F, 0x80, 0x01, 0xC0, 0xFF, 0xF8, 0x00, 0xE1,
  0xFF, 0xFE, 0x00, 0x61, 0xE0, 0x07, 0x80, 0x73, 0xC0, 0x00, 0xE0, 0x3B,
  0x80, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x1C, 0x0D, 0x80, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3E, 0x06, 0x00,
  0x00, 0x1F, 0x81, 0xC0, 0x00, 0x0E, 0xC0, 0x78, 0x00, 0x07, 0x70, 0x0F,
  0x00, 0x03, 0x9C, 0x01, 0xE0, 0x03, 0xC7, 0x00, 0x3F, 0xFF, 0xC1, 0x80,
  0x03, 0xFF, 0xE0, 0xE0, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x0E,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x03,
  0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0x00, 0xF8,
  0x18, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x06, 0x1C, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC6,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x73, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xB8, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x1D, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00, 0xEC, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x07, 0x60, 0x01, 0x80, 0x00, 0x38, 0x00, 0x37, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x01, 0xB8, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1D, 0xC0,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x70, 0x00, 0x06, 0x00, 0x07,
  0x70, 0x03, 0x80, 0x00, 0x70, 0x00, 0x33, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x03, 0x98, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0xC0, 0x07, 0x00, 0x01,
  0xE0, 0x01, 0xC6, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x38, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x0D, 0xC0, 0x0E, 0x0E, 0x00,
  0x38, 0x00, 0xEE, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0x0E, 0x30, 0x0F, 0x03,
  0x80, 0x07, 0x81, 0xE1, 0xC0, 0xF0, 0x0C, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0x80, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x03, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xF0,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x1C, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x3D, 0xC0,
  0x00, 0x00, 0x03, 0xBC, 0xE0, 0x00, 0x00, 0x01, 0xB8, 0x38, 0x00, 0x00,
  0x01, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x37, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xDC, 0x00,
  0x00, 0x00, 0x0E, 0xE0, 0x03, 0x70, 0x00, 0x00, 0x00, 0x33, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x73, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x01, 0xCC, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x00, 0x00, 0x01,
  0xC6, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x06, 0x18, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x38, 0xE0, 0x03, 0x86, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x0E, 0x18,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x30, 0x60, 0x00, 0x00, 0x38, 0x30, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xE0, 0x70, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x0C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00,
  0x60, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60,
  0x70, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0x06, 0x00,
  0x06, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xCE, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0D, 0xC0,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x70, 0x03, 0x70, 0x00, 0x00, 0x06, 0x00, 0x37,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x73, 0x80,
  0x00, 0x00, 0xE0, 0x07, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0xC0, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0xE0, 0x00, 0x01,
  0xC0, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x80,
  0x0C, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x01,
  0x80, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x60, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x01,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x03, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x60, 0x03, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x30, 0x00, 0x00, 0x07, 0x60, 0x07, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x30, 0x00, 0x0F, 0xC0, 0x07, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18,
  0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x08, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xC0, 0x07,
  0xFF, 0xF0, 0x60, 0x07, 0xC0, 0x3C, 0x30, 0x07, 0x80, 0x06, 0x38, 0x07,
  0x00, 0x03, 0x98, 0x07, 0x00, 0x00, 0xCC, 0x07, 0x00, 0x00, 0x36, 0x07,
  0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x00,
  0x1F, 0x03, 0x80, 0x00, 0x1B, 0x01, 0xC0, 0x00, 0x1D, 0x80, 0xE0, 0x00,
  0x0D, 0xC0, 0x38, 0x00, 0x1C, 0xE0, 0x1C, 0x00, 0x1C, 0x60, 0x07, 0x00,
  0x1C, 0x30, 0x03, 0xE0, 0x3C, 0x18, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0x1F,
  0xF8, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x30, 0x3F, 0xFF, 0x00,
  0x1C, 0x3C, 0x01, 0xE0, 0x07, 0x1E, 0x00, 0x3C, 0x01, 0xCE, 0x00, 0x07,
  0x00, 0x67, 0x00, 0x00, 0xE0, 0x1B, 0x80, 0x00, 0x38, 0x0E, 0xC0, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C, 0x0D, 0x80, 0x00, 0x0E, 0x03, 0x60,
  0x00, 0x07, 0x81, 0xD8, 0x00, 0x03, 0xC0, 0x73, 0x00, 0x01, 0xE0, 0x18,
  0xE0, 0x00, 0xF0, 0x06, 0x1E, 0x00, 0xF8, 0x03, 0x83, 0xFF, 0xF8, 0x00,
  0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x00,
  0xF8, 0x01, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x2F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x80, 0xC0, 0x00,
  0x7F, 0xFF, 0x07, 0x00, 0x03, 0xE0, 0x0E, 0x1C, 0x00, 0x1E, 0x00, 0x1C,
  0x70, 0x00, 0xE0, 0x00, 0x39, 0x80, 0x07, 0x00, 0x00, 0x66, 0x00, 0x38,
  0x00, 0x00, 0xD8, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x0F,
  0x80, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00,
  0x0F, 0x80, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x01, 0xB0, 0x01,
  0xC0, 0x00, 0x0E, 0xC0, 0x07, 0x00, 0x00, 0x73, 0x00, 0x0E, 0x00, 0x03,
  0x9C, 0x00, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0x00, 0xE1, 0x80, 0x01,
  0xF0, 0x1F, 0x06, 0x00, 0x03, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0xFF, 0x80,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0x1E, 0x00, 0xF8, 0x00,
  0xE0, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x3F, 0x07, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x0C, 0x00,
  0x3F, 0xFF, 0x81, 0x80, 0x0F, 0x80, 0x3C, 0x30, 0x03, 0xC0, 0x03, 0x8E,
  0x00, 0xE0, 0x00, 0x39, 0x80, 0x38, 0x00, 0x03, 0x30, 0x0E, 0x00, 0x00,
  0x36, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x00, 0xF8, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xF0,
  0x18, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x01,
  0xB0, 0x0E, 0x00, 0x00, 0x76, 0x01, 0xC0, 0x00, 0x1D, 0xC0, 0x1C, 0x00,
  0x07, 0x38, 0x03, 0x80, 0x01, 0xC7, 0x00, 0x38, 0x00, 0xF0, 0xC0, 0x07,
  0xC0, 0x7C, 0x38, 0x00, 0x7F, 0xFE, 0x07, 0x00, 0x03, 0xFF, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x3F,
  0xF8, 0x00, 0x60, 0x7F, 0xFE, 0x00, 0x70, 0xF8, 0x07, 0x80, 0x38, 0xF0,
  0x01, 0xE0, 0x1C, 0xE0, 0x00, 0x70, 0x0C, 0xE0, 0x00, 0x1C, 0x06, 0xE0,
  0x00, 0x0E, 0x07, 0x60, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x03, 0x81, 0xF0,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x06, 0x0F, 0x00,
  0x00, 0x06, 0x1E, 0x00, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0x0E, 0x77, 0x00,
  0x00, 0x0C, 0xE3, 0x80, 0x00, 0x0D, 0xC3, 0x80, 0x00, 0x1F, 0x81, 0xC0,
  0x00, 0x1F, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x06, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x30, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0x87, 0x80, 0xF0, 0x1E, 0x01,
  0xE0, 0x1C, 0x70, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0xC7, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x06, 0x60, 0x00, 0x31, 0xC0, 0x00, 0xE0, 0x37, 0x00, 0x01,
  0x9C, 0x00, 0x07, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x38, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x60, 0x1F, 0xFC, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0x38,
  0x7C, 0x03, 0xC0, 0x1C, 0x78, 0x00, 0xF0, 0x0C, 0x70, 0x00, 0x38, 0x06,
  0x70, 0x00, 0x0E, 0x03, 0x70, 0x00, 0x07, 0x03, 0xB0, 0x00, 0x03, 0x81,
  0xF0, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x3F, 0xF8, 0x00, 0x06, 0x07, 0xFF,
  0xE0, 0x00, 0x30, 0xF8, 0x07, 0x80, 0x03, 0x8F, 0x00, 0x1E, 0x00, 0x18,
  0xE0, 0x00, 0x70, 0x00, 0xCE, 0x00, 0x01, 0xC0, 0x06, 0xE0, 0x00, 0x0E,
  0x00, 0x76, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x1F, 0x00,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x1B, 0x00, 0x00, 0x1C, 0x00, 0xD8,
  0x00, 0x01, 0xE0, 0x0E, 0xC0, 0x00, 0x1E, 0x00, 0x73, 0x00, 0x01, 0xE0,
  0x03, 0x9C, 0x00, 0x1E, 0x00, 0x18, 0x78, 0x03, 0xE0, 0x00, 0xC1, 0xFF,
  0xFC, 0x00, 0x0E, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x30, 0x01, 0xFF, 0xFC, 0x0C, 0x00, 0xF8,
  0x03, 0x83, 0x00, 0x78, 0x00, 0x71, 0xC0, 0x38, 0x00, 0x0E, 0x60, 0x1C,
  0x00, 0x01, 0x98, 0x0E, 0x00, 0x00, 0x36, 0x07, 0x00, 0x00, 0x0F, 0x81,
  0xC0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x07, 0x81, 0x80, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x00, 0xF8,
  0x1C, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x00, 0x3B, 0x01, 0xC0, 0x00, 0x1D,
  0xC0, 0x38, 0x00, 0x0E, 0x70, 0x0E, 0x00, 0x07, 0x1C, 0x01, 0xC0, 0x03,
  0x86, 0x00, 0x7C, 0x07, 0xC3, 0x80, 0x0F, 0xFF, 0xC0, 0xE0, 0x00, 0xFF,
  0xC0, 0x38, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x30, 0x1F, 0xF0, 0x0C, 0x1F, 0xFC, 0x03, 0x0F, 0x80,
  0x01, 0xC7, 0x00, 0x00, 0x63, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x10, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x7E,
  0x07, 0x00, 0x00, 0x36, 0x03, 0x80, 0x00, 0x33, 0x01, 0xC0, 0x00, 0x33,
  0x80, 0xF0, 0x00, 0x79, 0xC0, 0x38, 0x00, 0x78, 0xE0, 0x0F, 0x00, 0xF0,
  0x60, 0x07, 0xFF, 0xF0, 0x30, 0x00, 0xFF, 0xE0, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xB0, 0x00,
  0x0E, 0x70, 0x00, 0x1D, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xCC, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x63, 0x00, 0x03, 0x87,
  0x00, 0x07, 0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0xC0, 0x01, 0xC0, 0xC0,
  0x03, 0x87, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x38, 0x00, 0xE0, 0x30, 0x01,
  0xC1, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0xE0,
  0x70, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0C,
  0x01, 0xC0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x00,
  0xE0, 0x07, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70,
  0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x8E, 0x00, 0x07, 0x38,
  0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x67, 0x00, 0x00, 0xDC, 0x00,
  0x03, 0x30, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x00, 0x67, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x1F, 0xFF, 0x00, 0x01, 0x7C, 0x1F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraLightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 14, 51, 15, 2, -50 },
  { 91, 16, 18, 23, 8, -50 },
  { 127, 42, 50, 43, 2, -50 },
  { 390, 33, 57, 39, 3, -53 },
  { 626, 44, 52, 54, 6, -51 },
  { 912, 42, 52, 48, 3, -51 },
  { 1185, 6, 18, 13, 8, -50 },
  { 1199, 21, 61, 18, 2, -50 },
  { 1360, 21, 61, 18, -5, -50 },
  { 1521, 29, 30, 37, 9, -53 },
  { 1630, 33, 33, 40, 5, -41 },
  { 1767, 10, 17, 14, -3, -8 },
  { 1789, 16, 2, 22, 3, -20 },
  { 1793, 5, 6, 15, 2, -5 },
  { 1797, 31, 50, 22, -3, -50 },
  { 1991, 33, 52, 39, 4, -51 },
  { 2206, 18, 50, 39, 11, -50 },
  { 2319, 35, 51, 39, 1, -51 },
  { 2543, 35, 52, 39, 2, -51 },
  { 2771, 36, 50, 39, 1, -50 },
  { 2996, 35, 51, 39, 3, -50 },
  { 3220, 33, 52, 39, 5, -51 },
  { 3435, 32, 50, 39, 7, -50 },
  { 3635, 34, 52, 39, 3, -51 },
  { 3856, 34, 52, 39, 3, -51 },
  { 4077, 12, 39, 15, 2, -38 },
  { 4136, 17, 47, 15, -3, -38 },
  { 4236, 32, 32, 40, 5, -41 },
  { 4364, 32, 17, 40, 5, -33 },
  { 4432, 32, 32, 40, 5, -41 },
  { 4560, 24, 52, 29, 6, -51 },
  { 4716, 53, 55, 59, 4, -49 },
  { 5081, 39, 50, 39, -4, -50 },
  { 5325, 38, 50, 42, 3, -50 },
  { 5563, 38, 52, 42, 6, -51 },
  { 5810, 42, 50, 47, 3, -50 },
  { 6073, 36, 50, 37, 3, -50 },
  { 6298, 36, 50, 34, 3, -50 },
  { 6523, 40, 52, 48, 6, -51 },
  { 6783, 44, 50, 48, 3, -50 },
  { 7058, 23, 50, 20, 0, -50 },
  { 7202, 29, 62, 17, -12, -50 },
  { 7427, 41, 50, 38, 3, -50 },
  { 7684, 26, 50, 34, 3, -50 },
  { 7847, 54, 50, 57, 3, -50 },
  { 8185, 44, 50, 48, 3, -50 },
  { 8460, 42, 52, 50, 6, -51 },
  { 8733, 36, 50, 39, 3, -50 },
  { 8958, 42, 63, 50, 6, -51 },
  { 9289, 36, 50, 39, 3, -50 },
  { 9514, 35, 52, 35, 1, -51 },
  { 9742, 35, 50, 34, 6, -50 },
  { 9961, 42, 51, 48, 6, -50 },
  { 10229, 36, 50, 38, 7, -50 },
  { 10454, 55, 50, 58, 8, -50 },
  { 10798, 44, 50, 35, -4, -50 },
  { 11073, 34, 50, 34, 7, -50 },
  { 11286, 41, 50, 38, -1, -50 },
  { 11543, 27, 61, 21, -1, -50 },
  { 11749, 11, 50, 22, 7, -50 },
  { 11818, 26, 61, 21, -5, -50 },
  { 12017, 33, 31, 39, 3, -50 },
  { 12145, 27, 3, 26, -6, 7 },
  { 12156, 9, 12, 17, 10, -54 },
  { 12170, 33, 39, 39, 3, -38 },
  { 12331, 34, 54, 40, 2, -53 },
  { 12561, 28, 39, 32, 4, -38 },
  { 12698, 38, 54, 40, 3, -53 },
  { 12955, 28, 39, 35, 4, -38 },
  { 13092, 38, 71, 19, -9, -54 },
  { 13430, 35, 55, 40, 2, -38 },
  { 13671, 33, 53, 39, 2, -53 },
  { 13890, 14, 51, 15, 2, -51 },
  { 13980, 26, 68, 15, -10, -51 },
  { 14201, 32, 53, 32, 2, -53 },
  { 14413, 14, 53, 15, 2, -53 },
  { 14506, 53, 38, 59, 2, -38 },
  { 14758, 33, 38, 39, 2, -38 },
  { 14915, 32, 39, 40, 4, -38 },
  { 15071, 37, 54, 40, -1, -38 },
  { 15321, 34, 54, 40, 3, -38 },
  { 15551, 26, 38, 26, 2, -38 },
  { 15675, 27, 39, 30, 1, -38 },
  { 15807, 20, 47, 22, 4, -46 },
  { 15925, 33, 38, 39, 4, -37 },
  { 16082, 30, 37, 30, 3, -37 },
  { 16221, 45, 37, 47, 4, -37 },
  { 16430, 35, 37, 32, -2, -37 },
  { 16592, 41, 54, 30, -8, -37 },
  { 16869, 32, 37, 31, -1, -37 },
  { 17017, 25, 61, 23, 2, -50 },
  { 17208, 3, 70, 38, 19, -53 },
  { 17235, 25, 61, 23, -3, -50 },
  { 17426, 32, 7, 40, 5, -28 },
};

const GFXfont NotoSans_ExtraLightItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRALIGHTITALIC70PT7B_H_
