#ifndef _NOTOSANS_EXTRALIGHTITALIC32PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x21, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x42, 0x8D, 0x16, 0x28, 0x50,
  0xA3, 0x44, 0x00, 0x40, 0x80, 0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80,
  0x08, 0x30, 0x03, 0x04, 0x00, 0x40, 0x81, 0xFF, 0xFF, 0x01, 0x04, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01,
  0x02, 0x07, 0xFF, 0xFC, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x08,
  0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x01, 0xFF, 0x08, 0x44, 0x42, 0x03, 0x08, 0x08, 0x20, 0x30,
  0x80, 0xC6, 0x01, 0x90, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x23, 0x00,
  0x84, 0x02, 0x18, 0x08, 0x60, 0x21, 0x01, 0x0C, 0x84, 0x63, 0xFE, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x63, 0x10, 0x04,
  0x20, 0x80, 0x84, 0x08, 0x18, 0x40, 0x83, 0x08, 0x08, 0x20, 0x80, 0x84,
  0x08, 0x18, 0xC0, 0x81, 0x08, 0x08, 0x11, 0x1C, 0x83, 0x26, 0x28, 0x26,
  0x41, 0xC4, 0x48, 0x17, 0x88, 0x81, 0x01, 0x18, 0x10, 0x31, 0x01, 0x02,
  0x10, 0x30, 0x41, 0x02, 0x08, 0x10, 0x21, 0x81, 0x06, 0x10, 0x10, 0x42,
  0x01, 0x8C, 0x40, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x18, 0x60, 0x02, 0x02,
  0x00, 0x20, 0x30, 0x06, 0x03, 0x00, 0x60, 0x20, 0x06, 0x02, 0x00, 0x20,
  0x40, 0x02, 0x18, 0x00, 0x16, 0x00, 0x01, 0xC0, 0x00, 0x6C, 0x00, 0x18,
  0x40, 0x33, 0x02, 0x02, 0x60, 0x30, 0x64, 0x01, 0x04, 0x40, 0x08, 0x8C,
  0x00, 0x50, 0xC0, 0x07, 0x04, 0x00, 0x60, 0x40, 0x09, 0x03, 0x03, 0x18,
  0x1F, 0xC0, 0xC0, 0x57, 0xAA, 0x00, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04,
  0x00, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18, 0x00, 0x01, 0x00, 0x08,
  0x00, 0x41, 0x82, 0x06, 0x20, 0x0D, 0x00, 0x1F, 0xE0, 0xC0, 0x09, 0x01,
  0x88, 0x18, 0x60, 0x81, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x13, 0x32, 0x64, 0xC8, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xF0, 0x0C, 0x10, 0x30, 0x10, 0xC0, 0x31, 0x00, 0x66, 0x00, 0x48, 0x00,
  0xB0, 0x01, 0x40, 0x02, 0x80, 0x0D, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x09, 0x00, 0x33, 0x00, 0x46, 0x01,
  0x84, 0x06, 0x0C, 0x18, 0x07, 0xE0, 0x00, 0x01, 0x07, 0x0D, 0x33, 0x62,
  0x82, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x00, 0xFC, 0x03, 0x06, 0x04, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x06, 0x06, 0x18, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0xF0, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0xC0, 0x70,
  0x7F, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x40, 0x01, 0x60, 0x01,
  0x20, 0x01, 0x10, 0x01, 0x88, 0x01, 0x84, 0x01, 0x86, 0x01, 0x82, 0x00,
  0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0xC0, 0x10,
  0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x03, 0xFF, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x13, 0xC0, 0x1C,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0xC0, 0x60, 0x7F,
  0xC0, 0x00, 0x7E, 0x03, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xCF, 0xC1, 0x30, 0xC2, 0x80, 0x46,
  0x00, 0xD8, 0x01, 0xB0, 0x01, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x13, 0x00,
  0x22, 0x00, 0x84, 0x03, 0x04, 0x0C, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x03, 0x06, 0x04, 0x03, 0x0C,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x03, 0x0C, 0x02, 0x04, 0x04, 0x02,
  0x18, 0x01, 0xE0, 0x03, 0xE0, 0x0C, 0x30, 0x30, 0x08, 0x60, 0x0C, 0x40,
  0x04, 0x40, 0x04, 0xC0, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x60, 0x18, 0x30,
  0x30, 0x1F, 0xE0, 0x01, 0xF8, 0x06, 0x0C, 0x0C, 0x06, 0x08, 0x02, 0x10,
  0x03, 0x10, 0x03, 0x30, 0x03, 0x20, 0x03, 0x20, 0x03, 0x20, 0x03, 0x30,
  0x06, 0x10, 0x0E, 0x18, 0x1A, 0x0F, 0xE6, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0xFF,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x0C, 0x10, 0x20, 0xC1, 0x04, 0x08, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x80,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x0C, 0x18, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFD, 0xF0, 0x03, 0x80, 0x18,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x02, 0x30, 0x00, 0x02,
  0x20, 0x3F, 0xC1, 0x40, 0x60, 0x81, 0x40, 0x80, 0x81, 0xC1, 0x00, 0x81,
  0x81, 0x01, 0x81, 0x82, 0x01, 0x03, 0x82, 0x01, 0x02, 0x82, 0x03, 0x02,
  0x82, 0x03, 0x06, 0x82, 0x05, 0x04, 0x83, 0x0D, 0x08, 0x81, 0xF9, 0xF0,
  0xC0, 0x40, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x0C, 0xC0, 0x02,
  0x30, 0x01, 0x84, 0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x10, 0x04, 0x04,
  0x03, 0x01, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x10, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x21, 0x00, 0x08, 0xC0, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x1C, 0x00,
  0x04, 0x0F, 0xF8, 0x04, 0x07, 0x02, 0x00, 0xC1, 0x00, 0x21, 0x80, 0x18,
  0xC0, 0x0C, 0x40, 0x04, 0x20, 0x02, 0x10, 0x03, 0x18, 0x03, 0x0F, 0xFE,
  0x07, 0xFE, 0x02, 0x00, 0xC1, 0x00, 0x21, 0x80, 0x08, 0x80, 0x04, 0x40,
  0x02, 0x20, 0x03, 0x30, 0x01, 0x98, 0x01, 0x88, 0x01, 0x84, 0x03, 0x83,
  0xFF, 0x00, 0x00, 0xFF, 0x01, 0xC0, 0xC1, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x40, 0x3F, 0xC0, 0x0F, 0xF0, 0x02, 0x0F, 0x80, 0x80, 0x30, 0x20, 0x06,
  0x18, 0x00, 0x86, 0x00, 0x31, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x4C,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x36, 0x00,
  0x0D, 0x00, 0x02, 0x40, 0x01, 0x90, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x30,
  0x80, 0x18, 0x20, 0x38, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0x00, 0xE0, 0x70, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x7F, 0xA0, 0x00, 0x68, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xCC, 0x00, 0x21, 0x00, 0x08,
  0x60, 0x02, 0x0E, 0x03, 0x80, 0xFF, 0x80, 0x0C, 0x00, 0x30, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00,
  0x41, 0x00, 0x04, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x20, 0x00, 0x82, 0x00, 0x08, 0x60, 0x01, 0x84, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x80, 0x02, 0x08,
  0x00, 0x20, 0x80, 0x02, 0x00, 0x07, 0xE0, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x3F,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x81, 0xF8, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x30, 0x20, 0x18, 0x18, 0x08,
  0x06, 0x04, 0x01, 0x06, 0x00, 0x43, 0x00, 0x11, 0x80, 0x0C, 0xC0, 0x02,
  0x70, 0x00, 0xA4, 0x00, 0x31, 0x80, 0x08, 0x20, 0x06, 0x0C, 0x01, 0x01,
  0x00, 0x40, 0x60, 0x10, 0x08, 0x0C, 0x03, 0x03, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x02, 0x08, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x3F,
  0xF8, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0A, 0x00,
  0x0A, 0x1A, 0x00, 0x1A, 0x12, 0x00, 0x12, 0x12, 0x00, 0x36, 0x12, 0x00,
  0x24, 0x13, 0x00, 0x44, 0x31, 0x00, 0xC4, 0x21, 0x00, 0x8C, 0x21, 0x01,
  0x8C, 0x21, 0x01, 0x08, 0x21, 0x02, 0x08, 0x61, 0x86, 0x08, 0x40, 0x84,
  0x18, 0x40, 0x8C, 0x10, 0x40, 0x88, 0x10, 0xC0, 0x90, 0x10, 0xC0, 0x90,
  0x10, 0x80, 0xE0, 0x30, 0x80, 0x60, 0x20, 0x80, 0x40, 0x20, 0x0C, 0x00,
  0x30, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0xA0, 0x02, 0x1A, 0x00, 0x21, 0x30,
  0x06, 0x11, 0x00, 0x41, 0x18, 0x04, 0x10, 0x80, 0x43, 0x08, 0x0C, 0x20,
  0x40, 0xC2, 0x04, 0x08, 0x20, 0x60, 0x82, 0x02, 0x08, 0x60, 0x21, 0x84,
  0x01, 0x10, 0x40, 0x11, 0x04, 0x01, 0x90, 0xC0, 0x09, 0x0C, 0x00, 0xF0,
  0x80, 0x06, 0x08, 0x00, 0x60, 0x80, 0x02, 0x00, 0x01, 0xFC, 0x00, 0xE0,
  0x60, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00,
  0x1A, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00,
  0x90, 0x00, 0x33, 0x00, 0x04, 0x20, 0x01, 0x06, 0x00, 0x60, 0x60, 0x30,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x08, 0x1C, 0x08, 0x06, 0x08, 0x03, 0x18,
  0x03, 0x18, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x20,
  0x04, 0x20, 0x1C, 0x3F, 0xF0, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0xE0, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00,
  0x04, 0x40, 0x00, 0x98, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x34, 0x00, 0x06, 0x80, 0x00, 0x90, 0x00, 0x33, 0x00, 0x04, 0x20, 0x01,
  0x06, 0x00, 0x60, 0x60, 0x30, 0x03, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x08, 0x1C,
  0x08, 0x06, 0x08, 0x03, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x03,
  0x10, 0x02, 0x30, 0x06, 0x20, 0x0C, 0x20, 0x38, 0x3F, 0xC0, 0x20, 0x40,
  0x60, 0x40, 0x40, 0x60, 0x40, 0x20, 0x40, 0x20, 0xC0, 0x30, 0xC0, 0x10,
  0x80, 0x18, 0x80, 0x08, 0x80, 0x08, 0x03, 0xFC, 0x0C, 0x0C, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x10, 0x0C, 0x3F,
  0xE0, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x98, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x02, 0x20, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x18, 0x60, 0x02, 0x04,
  0x00, 0x80, 0xE0, 0x60, 0x07, 0xF8, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0x90,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x61, 0x00, 0x20, 0x80, 0x30,
  0x60, 0x10, 0x30, 0x18, 0x08, 0x08, 0x04, 0x0C, 0x02, 0x04, 0x01, 0x04,
  0x00, 0x82, 0x00, 0x42, 0x00, 0x31, 0x00, 0x19, 0x00, 0x05, 0x80, 0x02,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x80, 0x08, 0x01, 0xC0,
  0x0C, 0x00, 0xA0, 0x06, 0x00, 0xD0, 0x05, 0x00, 0x48, 0x02, 0x80, 0x24,
  0x02, 0x40, 0x22, 0x01, 0x20, 0x11, 0x01, 0x90, 0x18, 0x80, 0x8C, 0x08,
  0x60, 0xC6, 0x0C, 0x30, 0x41, 0x04, 0x18, 0x60, 0x86, 0x0C, 0x20, 0x42,
  0x06, 0x30, 0x23, 0x01, 0x10, 0x11, 0x00, 0x98, 0x08, 0x80, 0x48, 0x04,
  0x80, 0x2C, 0x02, 0x40, 0x14, 0x01, 0x60, 0x0A, 0x00, 0xA0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x02, 0x00, 0x10, 0x20,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x01, 0x81, 0x80, 0x08, 0x10, 0x00,
  0x82, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x01, 0x98, 0x00, 0x30, 0x80,
  0x06, 0x08, 0x00, 0x40, 0x40, 0x08, 0x04, 0x01, 0x00, 0x60, 0x30, 0x02,
  0x06, 0x00, 0x20, 0xC0, 0x01, 0x00, 0x80, 0x03, 0xC0, 0x06, 0x40, 0x04,
  0x40, 0x08, 0x60, 0x18, 0x20, 0x30, 0x20, 0x20, 0x20, 0x40, 0x10, 0xC0,
  0x10, 0x80, 0x11, 0x00, 0x1B, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x0F, 0xC0, 0x86, 0x10, 0x84, 0x21, 0x0C, 0x21, 0x08, 0x42, 0x08, 0x42,
  0x10, 0x86, 0x10, 0x84, 0x20, 0x07, 0xF0, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x0F, 0xC0, 0x00,
  0xC0, 0x03, 0x00, 0x1A, 0x00, 0x48, 0x02, 0x20, 0x18, 0xC0, 0x41, 0x02,
  0x04, 0x18, 0x18, 0x40, 0x22, 0x00, 0x98, 0x02, 0x40, 0x06, 0x00, 0x10,
  0xFF, 0xF8, 0x88, 0x46, 0x21, 0x07, 0xE4, 0x18, 0x68, 0x40, 0x51, 0x00,
  0x66, 0x00, 0xC8, 0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x32,
  0x00, 0x44, 0x00, 0x88, 0x03, 0x10, 0x0A, 0x30, 0x2C, 0x20, 0xD0, 0x3E,
  0x20, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0xF8, 0x13, 0x04, 0x14, 0x06, 0x18, 0x02, 0x18,
  0x02, 0x30, 0x03, 0x30, 0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60,
  0x06, 0x60, 0x04, 0x60, 0x04, 0x60, 0x08, 0x60, 0x18, 0x90, 0x30, 0x8F,
  0xC0, 0x07, 0xF8, 0x60, 0x44, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x08, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x0F, 0xC4, 0x0C, 0x12,
  0x08, 0x07, 0x08, 0x03, 0x0C, 0x01, 0x84, 0x00, 0x46, 0x00, 0x62, 0x00,
  0x31, 0x00, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x20, 0x06, 0x10, 0x06, 0x08,
  0x03, 0x06, 0x02, 0x81, 0x06, 0x40, 0x7C, 0x60, 0x07, 0xE0, 0x60, 0x84,
  0x06, 0x40, 0x36, 0x01, 0xA0, 0x09, 0x00, 0xD8, 0x78, 0xFE, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x08, 0x1F, 0xC0,
  0x00, 0x0F, 0x80, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x02, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xF1, 0x06, 0x09,
  0x08, 0x05, 0x10, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x40, 0x06,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0x40, 0x18, 0x40, 0x18,
  0x60, 0x28, 0x20, 0xC8, 0x1F, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x80, 0xC0, 0xF7, 0x80, 0x3E, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x7C, 0x13, 0x04, 0x28, 0x0C, 0x60, 0x08, 0xC0, 0x13, 0x00, 0x26, 0x00,
  0xC8, 0x01, 0x10, 0x02, 0x20, 0x04, 0xC0, 0x09, 0x00, 0x32, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x30, 0x06, 0x40, 0x0C, 0x0C, 0x30, 0x00, 0x00, 0x01,
  0x86, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0x08,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x81, 0x60, 0x30, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x03, 0x18,
  0x08, 0x20, 0x60, 0x41, 0x80, 0x86, 0x03, 0x18, 0x04, 0x60, 0x09, 0x80,
  0x17, 0x00, 0x31, 0x00, 0xC2, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x30, 0x08, 0x40, 0x18, 0x04, 0x10, 0x43, 0x08, 0x20, 0x86, 0x18,
  0x41, 0x04, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x19,
  0xF8, 0x7E, 0x12, 0x08, 0xC3, 0x14, 0x0D, 0x01, 0x18, 0x06, 0x01, 0x18,
  0x06, 0x01, 0x30, 0x04, 0x01, 0x30, 0x0C, 0x01, 0x20, 0x08, 0x03, 0x20,
  0x08, 0x03, 0x20, 0x08, 0x02, 0x60, 0x08, 0x02, 0x40, 0x18, 0x02, 0x40,
  0x10, 0x06, 0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0xC0, 0x10, 0x04, 0x80,
  0x30, 0x0C, 0x18, 0xF8, 0x26, 0x08, 0x50, 0x18, 0xC0, 0x11, 0x80, 0x26,
  0x00, 0x4C, 0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x09, 0x80, 0x12, 0x00,
  0x64, 0x00, 0x88, 0x01, 0x30, 0x02, 0x60, 0x0C, 0x80, 0x18, 0x07, 0xF0,
  0x30, 0x63, 0x00, 0xC8, 0x01, 0x60, 0x05, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00, 0x44, 0x03,
  0x18, 0x18, 0x3F, 0x80, 0x06, 0x3E, 0x01, 0x30, 0x40, 0x50, 0x18, 0x18,
  0x02, 0x06, 0x00, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x02, 0x08, 0x00,
  0x82, 0x00, 0x21, 0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x06, 0x00, 0x81,
  0x80, 0x60, 0xD0, 0x30, 0x23, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x07, 0xE2,
  0x18, 0x24, 0x40, 0x29, 0x00, 0x66, 0x00, 0xC8, 0x01, 0xB0, 0x03, 0x40,
  0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x64, 0x00, 0xC8, 0x03, 0x10, 0x06,
  0x30, 0x14, 0x20, 0xC8, 0x3E, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x19, 0xF1, 0x30, 0x14, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x07, 0xF0, 0xC0,
  0x44, 0x00, 0x20, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x98, 0x18, 0x7F,
  0x80, 0x08, 0x08, 0x04, 0x02, 0x0F, 0xF9, 0x00, 0x80, 0x40, 0x20, 0x30,
  0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F,
  0x80, 0x30, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x26, 0x00, 0x48, 0x01,
  0x90, 0x02, 0x20, 0x04, 0x40, 0x09, 0x80, 0x32, 0x00, 0x64, 0x00, 0x88,
  0x03, 0x10, 0x0A, 0x20, 0x34, 0x60, 0xD0, 0x7E, 0x20, 0x80, 0x1C, 0x00,
  0xA0, 0x0D, 0x00, 0x48, 0x06, 0x60, 0x21, 0x02, 0x08, 0x30, 0x41, 0x02,
  0x18, 0x10, 0x80, 0x8C, 0x06, 0x40, 0x14, 0x00, 0xA0, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xA0, 0x28, 0x0A, 0x06, 0x81,
  0x20, 0x48, 0x12, 0x0C, 0x82, 0x20, 0x88, 0x22, 0x18, 0x84, 0x21, 0x08,
  0x42, 0x10, 0xC8, 0x32, 0x0C, 0x81, 0x20, 0xD0, 0x14, 0x05, 0x01, 0x40,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x18, 0x00, 0x08, 0x03, 0x0C, 0x02,
  0x04, 0x04, 0x06, 0x08, 0x02, 0x10, 0x03, 0x20, 0x01, 0x60, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x20,
  0x30, 0x10, 0x60, 0x10, 0xC0, 0x08, 0x02, 0x00, 0x60, 0x40, 0x08, 0x08,
  0x03, 0x01, 0x00, 0x40, 0x30, 0x18, 0x06, 0x02, 0x00, 0x40, 0x80, 0x08,
  0x10, 0x01, 0x04, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0xCC, 0x00, 0x09,
  0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x04, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xE0,
  0x00, 0x60, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x01, 0xE0, 0x38, 0x01, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x1C, 0x00, 0x40,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x06, 0x00, 0x70, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x18, 0x0F,
  0x00, 0x1C, 0x02, 0xC7, 0x06, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraLightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 7, 8, 10, 4, -23 },
  { 26, 19, 23, 20, 1, -23 },
  { 81, 14, 26, 18, 2, -24 },
  { 127, 20, 23, 25, 3, -23 },
  { 185, 20, 23, 22, 1, -23 },
  { 243, 2, 8, 6, 4, -23 },
  { 245, 9, 28, 8, 1, -23 },
  { 277, 9, 28, 8, -2, -23 },
  { 309, 13, 13, 17, 4, -24 },
  { 331, 15, 15, 18, 2, -19 },
  { 360, 4, 8, 6, -1, -4 },
  { 364, 8, 1, 10, 1, -9 },
  { 365, 2, 2, 7, 1, -2 },
  { 366, 14, 23, 10, -1, -23 },
  { 407, 15, 23, 18, 2, -23 },
  { 451, 8, 23, 18, 5, -23 },
  { 474, 16, 23, 18, 0, -23 },
  { 520, 16, 23, 18, 1, -23 },
  { 566, 17, 23, 18, 0, -23 },
  { 615, 16, 23, 18, 1, -23 },
  { 661, 15, 23, 18, 2, -23 },
  { 705, 15, 23, 18, 3, -23 },
  { 749, 16, 23, 18, 1, -23 },
  { 795, 16, 23, 18, 1, -23 },
  { 841, 5, 17, 7, 1, -17 },
  { 852, 7, 21, 7, -1, -17 },
  { 871, 15, 15, 18, 2, -19 },
  { 900, 15, 7, 18, 2, -15 },
  { 914, 15, 15, 18, 2, -19 },
  { 943, 11, 23, 13, 3, -23 },
  { 975, 24, 26, 27, 2, -23 },
  { 1053, 18, 23, 18, -2, -23 },
  { 1105, 17, 23, 19, 2, -23 },
  { 1154, 17, 23, 19, 3, -23 },
  { 1203, 18, 23, 22, 2, -23 },
  { 1255, 16, 23, 17, 2, -23 },
  { 1301, 16, 23, 16, 2, -23 },
  { 1347, 18, 23, 22, 3, -23 },
  { 1399, 20, 23, 22, 2, -23 },
  { 1457, 11, 23, 9, 0, -23 },
  { 1489, 13, 29, 8, -5, -23 },
  { 1537, 18, 23, 18, 2, -23 },
  { 1589, 11, 23, 16, 2, -23 },
  { 1621, 24, 23, 26, 2, -23 },
  { 1690, 20, 23, 22, 2, -23 },
  { 1748, 19, 23, 23, 3, -23 },
  { 1803, 16, 23, 18, 2, -23 },
  { 1849, 19, 28, 23, 3, -23 },
  { 1916, 16, 23, 18, 2, -23 },
  { 1962, 15, 23, 16, 1, -23 },
  { 2006, 16, 23, 16, 3, -23 },
  { 2052, 19, 23, 22, 3, -23 },
  { 2107, 17, 23, 17, 3, -23 },
  { 2156, 25, 23, 27, 4, -23 },
  { 2228, 20, 23, 16, -2, -23 },
  { 2286, 16, 23, 16, 3, -23 },
  { 2332, 18, 23, 17, 0, -23 },
  { 2384, 12, 28, 10, 0, -23 },
  { 2426, 5, 23, 10, 3, -23 },
  { 2441, 12, 28, 10, -2, -23 },
  { 2483, 14, 14, 18, 2, -23 },
  { 2508, 13, 1, 12, -3, 3 },
  { 2510, 4, 6, 8, 5, -25 },
  { 2513, 15, 17, 18, 2, -17 },
  { 2545, 16, 24, 18, 1, -24 },
  { 2593, 13, 17, 14, 2, -17 },
  { 2621, 17, 24, 18, 2, -24 },
  { 2672, 13, 17, 16, 2, -17 },
  { 2700, 17, 32, 9, -4, -24 },
  { 2768, 16, 25, 18, 1, -17 },
  { 2818, 15, 24, 18, 1, -24 },
  { 2863, 6, 23, 7, 1, -23 },
  { 2881, 11, 31, 7, -4, -23 },
  { 2924, 15, 24, 14, 1, -24 },
  { 2969, 6, 24, 7, 1, -24 },
  { 2987, 24, 17, 27, 1, -17 },
  { 3038, 15, 17, 18, 1, -17 },
  { 3070, 14, 17, 18, 2, -17 },
  { 3100, 18, 24, 18, -1, -17 },
  { 3154, 15, 24, 18, 2, -17 },
  { 3199, 12, 17, 12, 1, -17 },
  { 3225, 13, 17, 14, 0, -17 },
  { 3253, 9, 21, 10, 2, -21 },
  { 3277, 15, 17, 18, 2, -17 },
  { 3309, 13, 17, 14, 2, -17 },
  { 3337, 20, 17, 21, 2, -17 },
  { 3380, 16, 17, 15, -1, -17 },
  { 3414, 19, 25, 14, -4, -17 },
  { 3474, 14, 17, 14, 0, -17 },
  { 3504, 11, 28, 11, 1, -23 },
  { 3543, 1, 32, 17, 9, -24 },
  { 3547, 12, 28, 11, -2, -23 },
  { 3589, 15, 3, 18, 2, -13 },
};

const GFXfont NotoSans_ExtraLightItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRALIGHTITALIC32PT7B_H_
