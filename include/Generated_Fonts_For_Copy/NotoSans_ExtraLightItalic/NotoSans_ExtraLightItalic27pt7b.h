#ifndef _NOTOSANS_EXTRALIGHTITALIC27PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x20, 0x00, 0x04,
  0x30, 0x45, 0x14, 0x52, 0x8A, 0x28, 0x80, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x3F, 0xFF, 0x04, 0x10, 0x04,
  0x10, 0x04, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFC, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x80, 0x20, 0x80, 0x20, 0x80, 0x00, 0xC0, 0x04,
  0x01, 0xFC, 0x11, 0x11, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20, 0x19, 0x00,
  0x68, 0x00, 0xE0, 0x05, 0x80, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x04,
  0x47, 0x2C, 0x07, 0x80, 0x10, 0x00, 0x80, 0x04, 0x00, 0x04, 0x00, 0x8D,
  0x00, 0x88, 0x40, 0x88, 0x20, 0x84, 0x10, 0x42, 0x08, 0x42, 0x04, 0x41,
  0x02, 0x60, 0x82, 0x27, 0x41, 0x24, 0x71, 0x24, 0x29, 0xB2, 0x13, 0x12,
  0x08, 0x11, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20, 0x88, 0x10, 0x88,
  0x08, 0xCC, 0x07, 0xC0, 0x00, 0x40, 0x03, 0xB0, 0x04, 0x18, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x0C, 0x10, 0x04, 0x20, 0x06, 0xC0, 0x03, 0x00,
  0x0D, 0x00, 0x30, 0x81, 0x60, 0xC1, 0x40, 0x42, 0x80, 0x24, 0x80, 0x3C,
  0x80, 0x18, 0xC0, 0x38, 0x60, 0x44, 0x3F, 0x86, 0x55, 0xA8, 0x03, 0x04,
  0x08, 0x18, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x60, 0x06, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x02, 0x00, 0x20, 0x82,
  0x06, 0x20, 0x1C, 0x10, 0x7F, 0x0A, 0x01, 0x20, 0x21, 0x04, 0x10, 0x01,
  0x80, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x32, 0x24, 0x48,
  0xFC, 0xB0, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x01, 0x80, 0xEE, 0x18, 0x31,
  0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x41, 0x03,
  0xE0, 0x06, 0x14, 0xCE, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0x00, 0x40, 0x0E, 0xE0, 0xC0, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x3F, 0xFC, 0x00, 0x80, 0x7B, 0x86, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x7E, 0x00, 0xF0, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x20, 0x31,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x12, 0x00, 0x88, 0x06,
  0x20, 0x31, 0x00, 0x84, 0x04, 0x10, 0x20, 0x41, 0x03, 0x08, 0x08, 0x40,
  0x23, 0xFF, 0xF0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x07, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x05, 0xC0, 0x38, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x62, 0x03, 0x07, 0xF0, 0x00, 0x00, 0x70,
  0x1C, 0xC3, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x4F,
  0x82, 0x82, 0x28, 0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x46, 0x02, 0x10, 0x20, 0x7E, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x3B, 0x82, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x21,
  0x02, 0x04, 0x60, 0x1C, 0x03, 0xE0, 0x60, 0x86, 0x02, 0x20, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x32, 0x01, 0x18, 0x10, 0x7F, 0x00, 0x01, 0x80, 0x33,
  0x02, 0x04, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09,
  0x00, 0xCC, 0x0E, 0x31, 0xA0, 0x61, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x41, 0xFC, 0x00, 0x31, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x8C, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x84,
  0x10, 0x80, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x0C, 0x1C, 0xC0, 0x08, 0x02, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x08, 0x10, 0x00,
  0x21, 0x00, 0x01, 0x18, 0x0E, 0x04, 0x81, 0x8C, 0x28, 0x30, 0x41, 0x41,
  0x02, 0x0A, 0x10, 0x10, 0x50, 0x81, 0x02, 0x84, 0x08, 0x28, 0x20, 0x41,
  0x21, 0x06, 0x11, 0x08, 0x51, 0x88, 0x3C, 0x78, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x31, 0x00, 0x42, 0x01,
  0x04, 0x02, 0x08, 0x08, 0x10, 0x30, 0x20, 0x7F, 0xC1, 0x80, 0x42, 0x00,
  0x88, 0x01, 0x10, 0x02, 0x40, 0x05, 0x80, 0x0A, 0x00, 0x18, 0x0F, 0xF8,
  0x10, 0x08, 0x20, 0x18, 0x40, 0x11, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08,
  0x04, 0x1F, 0xF0, 0x40, 0xE0, 0x80, 0x61, 0x00, 0x42, 0x00, 0x8C, 0x01,
  0x10, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0xC3, 0xFE, 0x00, 0x00, 0x20,
  0x07, 0xBC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0xFF, 0x00,
  0x0F, 0xF0, 0x08, 0x0C, 0x08, 0x06, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x03,
  0x20, 0x02, 0x60, 0x06, 0x40, 0x04, 0x40, 0x08, 0x40, 0x30, 0x40, 0xE0,
  0xFF, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x1F, 0xF0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xFF, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x03, 0xDF, 0x04, 0x01, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x7E, 0x80, 0x86, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x60, 0x08, 0x30, 0x08,
  0x0F, 0xF0, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x31, 0x00,
  0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x1F, 0xFE, 0x10, 0x01, 0x08,
  0x00, 0x84, 0x00, 0x42, 0x00, 0x23, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08,
  0x40, 0x04, 0x20, 0x06, 0x20, 0x02, 0x00, 0x0F, 0x81, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x3E, 0x00, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x8C, 0x07, 0x00, 0x08, 0x03, 0x08, 0x04, 0x08, 0x08, 0x08,
  0x30, 0x10, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x12, 0x00, 0x16, 0x00, 0x29,
  0x00, 0x31, 0x00, 0x21, 0x80, 0x20, 0x80, 0x60, 0xC0, 0x40, 0x40, 0x40,
  0x60, 0x40, 0x20, 0x40, 0x30, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0F, 0xFC, 0x0C, 0x00, 0x18, 0x60, 0x01,
  0xC3, 0x00, 0x0C, 0x14, 0x00, 0xA1, 0x20, 0x0D, 0x09, 0x00, 0x48, 0x48,
  0x04, 0x82, 0x40, 0x24, 0x12, 0x02, 0x21, 0x08, 0x31, 0x08, 0x41, 0x08,
  0x42, 0x10, 0x82, 0x10, 0x84, 0x30, 0x88, 0x21, 0x04, 0xC1, 0x08, 0x14,
  0x18, 0x40, 0xC0, 0x82, 0x06, 0x04, 0x20, 0x20, 0x20, 0x0C, 0x00, 0x86,
  0x00, 0x43, 0x00, 0x21, 0x40, 0x31, 0x20, 0x10, 0x88, 0x08, 0x44, 0x04,
  0x23, 0x02, 0x10, 0x82, 0x10, 0x41, 0x08, 0x10, 0x84, 0x08, 0x42, 0x02,
  0x23, 0x01, 0x21, 0x00, 0x90, 0x80, 0x28, 0x40, 0x14, 0x20, 0x06, 0x20,
  0x02, 0x00, 0x00, 0xC0, 0x07, 0x3C, 0x0C, 0x06, 0x10, 0x02, 0x30, 0x01,
  0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x06, 0x40, 0x04,
  0x60, 0x08, 0x30, 0x30, 0x0F, 0xE0, 0x0F, 0xF0, 0x20, 0x20, 0x80, 0x42,
  0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x18, 0x80, 0xC3,
  0xFC, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x3C, 0x0C, 0x06, 0x10, 0x02,
  0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x06,
  0x40, 0x04, 0x60, 0x08, 0x30, 0x30, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x0F, 0xF0, 0x20, 0x20, 0x80, 0x42,
  0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x18, 0x87, 0x83,
  0xF8, 0x08, 0x20, 0x20, 0x41, 0x81, 0x04, 0x04, 0x10, 0x08, 0x40, 0x21,
  0x00, 0x88, 0x01, 0x00, 0x00, 0x80, 0x7B, 0xC6, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x20, 0x21, 0xFE,
  0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x00, 0x10,
  0x01, 0x88, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x10,
  0x80, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01, 0x08, 0x00,
  0x8C, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x80, 0x10, 0x40, 0x10, 0x30,
  0x30, 0x07, 0xF0, 0x00, 0x80, 0x0E, 0x00, 0x28, 0x01, 0x20, 0x0C, 0x80,
  0x23, 0x01, 0x84, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10,
  0x80, 0x42, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x38, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x80, 0x20, 0x0C, 0x02, 0x80, 0xE0, 0x14, 0x05, 0x01, 0xA0,
  0x28, 0x09, 0x02, 0x20, 0x48, 0x11, 0x04, 0x41, 0x08, 0x22, 0x08, 0x42,
  0x10, 0x82, 0x10, 0x84, 0x11, 0x04, 0x40, 0x88, 0x22, 0x04, 0x81, 0x30,
  0x24, 0x09, 0x01, 0x40, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x14, 0x03, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x04, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x20,
  0x80, 0x10, 0xC0, 0x08, 0x40, 0x02, 0x40, 0x01, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x24, 0x00, 0x22, 0x00, 0x20, 0x80, 0x20, 0x40,
  0x30, 0x20, 0x30, 0x08, 0x10, 0x04, 0x30, 0x01, 0x00, 0x80, 0x1C, 0x01,
  0x20, 0x08, 0x80, 0x84, 0x08, 0x20, 0xC0, 0x84, 0x04, 0x40, 0x24, 0x01,
  0x20, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x0F, 0x80, 0x88, 0x88, 0x44,
  0x44, 0x44, 0x22, 0x22, 0x22, 0x11, 0x10, 0x07, 0xC0, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0x80,
  0x00, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x42, 0x04, 0x10, 0x20, 0x82,
  0x02, 0x20, 0x11, 0x00, 0x90, 0x05, 0x00, 0x10, 0xFF, 0xC0, 0x99, 0x12,
  0x01, 0x00, 0x76, 0x46, 0x0A, 0x60, 0x22, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x02, 0xC0, 0x24, 0x01, 0x20, 0x19, 0x80, 0xC4, 0x0A, 0x20, 0xA0, 0xF9,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x42,
  0x02, 0x6E, 0x3C, 0x11, 0x40, 0x4C, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05,
  0x00, 0x68, 0x02, 0x40, 0x12, 0x01, 0x28, 0x19, 0x41, 0x89, 0xF8, 0x00,
  0x01, 0x81, 0xCC, 0x60, 0x18, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x62, 0x07, 0x34,
  0x10, 0x28, 0x60, 0x30, 0x80, 0x62, 0x00, 0x84, 0x01, 0x08, 0x02, 0x30,
  0x04, 0x40, 0x18, 0x80, 0x21, 0x80, 0xC1, 0x02, 0x82, 0x09, 0x03, 0xE2,
  0x00, 0x02, 0x07, 0x33, 0x05, 0x81, 0x40, 0x60, 0x18, 0x1B, 0xF8, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x23, 0xF0, 0x00, 0x1C, 0x01, 0x90,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x03, 0xF8, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x73, 0x46,
  0x0A, 0x60, 0x32, 0x01, 0xA0, 0x09, 0x00, 0x48, 0x02, 0xC0, 0x14, 0x01,
  0xA0, 0x09, 0x80, 0xC4, 0x0A, 0x20, 0x90, 0xF9, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x03, 0x0F, 0xE0, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0xC1, 0x33, 0x2C, 0x12, 0x81, 0x30, 0x12,
  0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x40, 0x08, 0xC0, 0x00, 0x00, 0x46, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x44, 0x21, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x3C,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x03, 0x30, 0x42, 0x08, 0x21, 0x02, 0x20, 0x24, 0x04, 0xC0, 0x54, 0x06,
  0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0xC0, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x31, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x00, 0x01,
  0x80, 0x81, 0x66, 0x33, 0x28, 0x24, 0x13, 0x01, 0x81, 0x30, 0x10, 0x12,
  0x03, 0x01, 0x20, 0x20, 0x14, 0x02, 0x01, 0x40, 0x20, 0x34, 0x02, 0x02,
  0x40, 0x40, 0x24, 0x04, 0x02, 0x80, 0x40, 0x28, 0x04, 0x04, 0x80, 0xC0,
  0x40, 0x00, 0x80, 0x9B, 0x8B, 0x04, 0x50, 0x33, 0x01, 0x10, 0x08, 0x80,
  0x4C, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12,
  0x01, 0x00, 0x01, 0x00, 0x73, 0x06, 0x04, 0x40, 0x22, 0x00, 0xA0, 0x05,
  0x00, 0x28, 0x01, 0xC0, 0x1E, 0x00, 0xB0, 0x04, 0x80, 0x44, 0x02, 0x30,
  0x60, 0x7E, 0x00, 0x00, 0x40, 0x26, 0xE1, 0x60, 0x85, 0x01, 0x18, 0x04,
  0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x04,
  0x50, 0x31, 0x41, 0x84, 0xFC, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x01, 0x80, 0x77, 0x46, 0x0A, 0x60, 0x32, 0x01,
  0xA0, 0x09, 0x00, 0x48, 0x02, 0xC0, 0x14, 0x01, 0xA0, 0x09, 0x80, 0xC4,
  0x0A, 0x20, 0x90, 0xF9, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x85, 0xD2, 0xC0, 0xA0, 0x30, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x00, 0x03, 0x03,
  0x9C, 0xC0, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x09, 0x03, 0x1F, 0xC0, 0x08, 0x10, 0x10, 0x10, 0xFF,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xC0,
  0x78, 0x30, 0x09, 0x00, 0x48, 0x06, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x04, 0x40, 0x22, 0x01, 0x30, 0x18, 0x81, 0x44, 0x14, 0x1F, 0x20,
  0x80, 0x34, 0x02, 0x40, 0x44, 0x0C, 0x40, 0x84, 0x10, 0x41, 0x04, 0x20,
  0x22, 0x02, 0x40, 0x2C, 0x02, 0x80, 0x30, 0x03, 0x00, 0xC0, 0xC0, 0xD0,
  0x30, 0x24, 0x14, 0x11, 0x05, 0x04, 0x42, 0x43, 0x10, 0x90, 0x84, 0x44,
  0x21, 0x11, 0x10, 0x48, 0x44, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x00, 0x18, 0x0C, 0x20, 0x40, 0x42, 0x01, 0x18,
  0x02, 0xC0, 0x0A, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x80, 0x22, 0x01, 0x0C,
  0x08, 0x10, 0x60, 0x43, 0x00, 0x80, 0x0C, 0x03, 0x04, 0x02, 0x04, 0x04,
  0x04, 0x0C, 0x04, 0x08, 0x04, 0x10, 0x04, 0x10, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0xB0, 0x00, 0x40, 0x00,
  0x1F, 0xF0, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0F, 0xF8, 0x03, 0x83, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x18, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x30, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x83, 0x80, 0x38, 0x1C, 0x71, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 7, 9, 3, -19 },
  { 19, 16, 19, 17, 1, -19 },
  { 57, 13, 22, 15, 1, -20 },
  { 93, 17, 20, 21, 2, -20 },
  { 136, 16, 20, 18, 1, -20 },
  { 176, 2, 7, 5, 3, -19 },
  { 178, 8, 23, 7, 1, -19 },
  { 201, 8, 23, 7, -2, -19 },
  { 224, 12, 11, 14, 3, -20 },
  { 241, 12, 13, 15, 2, -16 },
  { 261, 4, 6, 5, -1, -3 },
  { 264, 6, 1, 8, 1, -8 },
  { 265, 2, 2, 6, 1, -2 },
  { 266, 12, 19, 9, -1, -19 },
  { 295, 12, 20, 15, 2, -20 },
  { 325, 7, 19, 15, 4, -19 },
  { 342, 14, 20, 15, 0, -20 },
  { 377, 13, 20, 15, 1, -20 },
  { 410, 14, 19, 15, 0, -19 },
  { 444, 14, 19, 15, 1, -19 },
  { 478, 13, 20, 15, 2, -20 },
  { 511, 12, 19, 15, 3, -19 },
  { 540, 13, 20, 15, 1, -20 },
  { 573, 13, 20, 15, 1, -20 },
  { 606, 4, 14, 6, 1, -14 },
  { 613, 6, 17, 6, -1, -14 },
  { 626, 12, 12, 15, 2, -16 },
  { 644, 12, 7, 15, 2, -13 },
  { 655, 12, 12, 15, 2, -16 },
  { 673, 10, 20, 11, 2, -20 },
  { 698, 21, 21, 23, 1, -19 },
  { 754, 15, 19, 15, -1, -19 },
  { 790, 15, 19, 16, 1, -19 },
  { 826, 15, 20, 16, 2, -20 },
  { 864, 16, 19, 18, 1, -19 },
  { 902, 14, 19, 14, 1, -19 },
  { 936, 14, 19, 13, 1, -19 },
  { 970, 16, 20, 19, 2, -20 },
  { 1010, 17, 19, 18, 1, -19 },
  { 1051, 9, 19, 8, 0, -19 },
  { 1073, 12, 24, 6, -5, -19 },
  { 1109, 16, 19, 15, 1, -19 },
  { 1147, 10, 19, 13, 1, -19 },
  { 1171, 21, 19, 22, 1, -19 },
  { 1221, 17, 19, 18, 1, -19 },
  { 1262, 16, 20, 19, 2, -20 },
  { 1302, 14, 19, 15, 1, -19 },
  { 1336, 16, 25, 19, 2, -20 },
  { 1386, 14, 19, 15, 1, -19 },
  { 1420, 13, 20, 13, 1, -20 },
  { 1453, 14, 19, 13, 2, -19 },
  { 1487, 17, 19, 19, 2, -19 },
  { 1528, 14, 19, 15, 3, -19 },
  { 1562, 21, 19, 22, 3, -19 },
  { 1612, 17, 19, 13, -2, -19 },
  { 1653, 13, 19, 13, 3, -19 },
  { 1684, 15, 19, 15, 0, -19 },
  { 1720, 10, 23, 8, 0, -19 },
  { 1749, 4, 19, 9, 3, -19 },
  { 1759, 10, 23, 8, -2, -19 },
  { 1788, 13, 12, 15, 1, -19 },
  { 1808, 10, 1, 10, -2, 3 },
  { 1810, 3, 5, 6, 4, -21 },
  { 1812, 13, 15, 15, 1, -15 },
  { 1837, 13, 21, 15, 1, -21 },
  { 1872, 11, 15, 12, 1, -15 },
  { 1893, 15, 21, 15, 1, -21 },
  { 1933, 10, 15, 13, 2, -15 },
  { 1952, 14, 27, 7, -3, -21 },
  { 2000, 13, 21, 15, 1, -15 },
  { 2035, 12, 21, 15, 1, -21 },
  { 2067, 5, 20, 6, 1, -20 },
  { 2080, 10, 26, 6, -4, -20 },
  { 2113, 12, 21, 12, 1, -21 },
  { 2145, 5, 21, 6, 1, -21 },
  { 2159, 20, 15, 23, 1, -15 },
  { 2197, 13, 15, 15, 1, -15 },
  { 2222, 13, 15, 15, 1, -15 },
  { 2247, 14, 21, 15, 0, -15 },
  { 2284, 13, 21, 15, 1, -15 },
  { 2319, 10, 15, 10, 1, -15 },
  { 2338, 11, 15, 11, 0, -15 },
  { 2359, 8, 18, 8, 1, -18 },
  { 2377, 13, 14, 15, 1, -14 },
  { 2400, 12, 14, 11, 1, -14 },
  { 2421, 18, 14, 18, 1, -14 },
  { 2453, 14, 14, 12, -1, -14 },
  { 2478, 16, 21, 11, -3, -14 },
  { 2520, 12, 14, 12, 0, -14 },
  { 2541, 9, 23, 9, 1, -19 },
  { 2567, 1, 28, 15, 7, -21 },
  { 2571, 9, 23, 9, -1, -19 },
  { 2597, 12, 3, 15, 2, -11 },
};

const GFXfont NotoSans_ExtraLightItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRALIGHTITALIC27PT7B_H_
