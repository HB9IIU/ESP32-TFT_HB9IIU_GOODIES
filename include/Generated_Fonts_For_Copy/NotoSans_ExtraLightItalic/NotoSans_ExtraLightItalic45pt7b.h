#ifndef _NOTOSANS_EXTRALIGHTITALIC45PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81,
  0xC0, 0x30, 0xCC, 0x32, 0x0D, 0x83, 0x60, 0x98, 0x24, 0x19, 0x06, 0xC1,
  0x30, 0x48, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80,
  0x40, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x08,
  0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x40,
  0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x04, 0x01, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x08, 0x00, 0x08, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x07, 0xFE,
  0x00, 0xF3, 0x7C, 0x0E, 0x10, 0x20, 0xC0, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0x60, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x80, 0x06, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x62, 0x00, 0x01, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x6E, 0x00, 0x02, 0x18, 0x00, 0x10, 0x60, 0x01, 0x81, 0x00,
  0x0C, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x30, 0x01, 0x83,
  0x80, 0x0C, 0x38, 0x70, 0x47, 0x83, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x06, 0x0C, 0x30, 0x00, 0xC1,
  0x81, 0x00, 0x18, 0x30, 0x18, 0x03, 0x02, 0x01, 0x80, 0x20, 0x60, 0x18,
  0x06, 0x06, 0x01, 0x80, 0xC0, 0x40, 0x18, 0x18, 0x0C, 0x01, 0x81, 0x80,
  0xC0, 0x10, 0x30, 0x0C, 0x01, 0x06, 0x00, 0xC0, 0x30, 0xC0, 0x08, 0x03,
  0x0C, 0x10, 0x80, 0x21, 0x8F, 0xE8, 0x06, 0x31, 0x87, 0xC0, 0x42, 0x30,
  0x3C, 0x0C, 0x62, 0x03, 0x61, 0x8C, 0x60, 0x17, 0xF1, 0x84, 0x01, 0x18,
  0x10, 0xC0, 0x10, 0x03, 0x0C, 0x03, 0x00, 0x60, 0xC0, 0x30, 0x0C, 0x08,
  0x03, 0x00, 0x80, 0x80, 0x30, 0x18, 0x18, 0x02, 0x03, 0x01, 0x80, 0x60,
  0x60, 0x18, 0x06, 0x04, 0x01, 0x80, 0x40, 0xC0, 0x18, 0x0C, 0x18, 0x00,
  0xC1, 0x83, 0x00, 0x0C, 0x30, 0x60, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x10, 0x00, 0x60, 0x02, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x30, 0x30, 0x01, 0x8C, 0x03, 0x00, 0x63, 0x00, 0x30, 0x0C, 0xC0,
  0x06, 0x03, 0x18, 0x00, 0x60, 0x66, 0x00, 0x06, 0x18, 0xC0, 0x00, 0xC6,
  0x18, 0x00, 0x0D, 0x83, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00,
  0x07, 0x80, 0xC0, 0x01, 0x98, 0x1C, 0x00, 0xE1, 0x81, 0xE0, 0xF0, 0x30,
  0x0F, 0xF8, 0x03, 0x80, 0x33, 0x26, 0x66, 0x44, 0xCC, 0x80, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x02,
  0x01, 0xC0, 0x40, 0x0E, 0x08, 0x00, 0x73, 0x00, 0x03, 0x40, 0xE0, 0x1F,
  0xFC, 0x03, 0x80, 0x00, 0x90, 0x00, 0x62, 0x00, 0x18, 0x60, 0x06, 0x04,
  0x01, 0x80, 0xC0, 0x20, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x18, 0x30, 0xC1, 0x86,
  0x0C, 0x10, 0x60, 0x83, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00,
  0x70, 0x38, 0x07, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00,
  0x43, 0x00, 0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x02,
  0x40, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x00, 0xC0, 0x30, 0x07, 0x87, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x0E,
  0x03, 0xE0, 0x66, 0x1C, 0x67, 0x04, 0xE0, 0xC4, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xE0, 0x01, 0xE0, 0xE0, 0x0E, 0x00, 0x60, 0x08, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0xE0, 0x20, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00,
  0xE0, 0x7C, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x33,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x02, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x18, 0x00, 0x80, 0x60,
  0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x82, 0x00,
  0x1C, 0x0F, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0x02, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x3E, 0x00, 0x8F, 0xFC, 0x0C, 0xC0,
  0x30, 0x6C, 0x00, 0xC2, 0x80, 0x03, 0x1C, 0x00, 0x19, 0xC0, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x66, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x18, 0x30,
  0x01, 0x80, 0xC0, 0x18, 0x03, 0x83, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80,
  0x0E, 0x07, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01,
  0x80, 0x80, 0x0E, 0x03, 0x00, 0x70, 0x06, 0x03, 0x80, 0x0E, 0x38, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0x18, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x70, 0x30, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x08,
  0xC0, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x40,
  0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x38, 0x07, 0x03, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x30, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x02, 0x18,
  0x00, 0x08, 0x60, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x78,
  0x30, 0x03, 0x40, 0xE0, 0x3B, 0x00, 0xFF, 0x8C, 0x00, 0xF0, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x30, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0xE1, 0xE0, 0xE2, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x0F, 0x80, 0x31, 0x80, 0x1F, 0xFC, 0x04, 0x40, 0x1C,
  0x02, 0x01, 0x30, 0x0E, 0x01, 0x80, 0x48, 0x03, 0x00, 0x60, 0x16, 0x01,
  0x80, 0x18, 0x05, 0x80, 0xC0, 0x04, 0x01, 0x60, 0x30, 0x03, 0x00, 0x50,
  0x08, 0x00, 0xC0, 0x34, 0x06, 0x00, 0x20, 0x0D, 0x01, 0x80, 0x18, 0x03,
  0xC0, 0x60, 0x06, 0x01, 0xB0, 0x18, 0x01, 0x80, 0x64, 0x06, 0x00, 0xE0,
  0x31, 0x01, 0x80, 0x78, 0x0C, 0x40, 0x30, 0x36, 0x0E, 0x18, 0x0E, 0x38,
  0xC7, 0x06, 0x01, 0xF8, 0x1F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x04, 0x00, 0x03, 0x02, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x60, 0x01, 0x80, 0x3F, 0xFF, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x0C,
  0x00, 0x02, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x05, 0x80, 0x00, 0x03,
  0x01, 0xFF, 0xF0, 0x01, 0x01, 0xFC, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x07,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x18, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x60, 0x40, 0x01, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7C, 0x07, 0x00, 0xE0, 0x01,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x03, 0xE0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0xFF, 0x00, 0x0C, 0x00,
  0x78, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x70, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x08, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x0E, 0x00, 0x80, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0x80, 0x7C, 0x03, 0x80, 0x02, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xCC, 0x00, 0x7F, 0xF3, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x02, 0x01, 0xC0, 0x01, 0x80,
  0x3C, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x18, 0x08,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x01, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x80, 0x01, 0xFE, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x40, 0x00, 0xE0, 0x30, 0x00, 0x70,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0x60,
  0xE0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xCF, 0x00, 0x00, 0x26, 0xC0, 0x00, 0x1B, 0x18, 0x00, 0x07, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0B, 0x03,
  0x40, 0x00, 0x06, 0x80, 0x90, 0x00, 0x03, 0x60, 0x26, 0x00, 0x00, 0xD8,
  0x19, 0x80, 0x00, 0x66, 0x06, 0x60, 0x00, 0x11, 0x81, 0x98, 0x00, 0x0C,
  0x40, 0x42, 0x00, 0x06, 0x30, 0x30, 0x80, 0x01, 0x8C, 0x0C, 0x30, 0x00,
  0xC3, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0xC3, 0x00, 0x18, 0x20, 0x20, 0xC0,
  0x0C, 0x18, 0x18, 0x10, 0x03, 0x06, 0x06, 0x04, 0x01, 0x81, 0x81, 0x81,
  0x80, 0x60, 0x60, 0x60, 0x60, 0x30, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x03, 0x00, 0x83, 0x00, 0xC0, 0xC0, 0x20, 0xC0, 0x20,
  0x30, 0x0C, 0x60, 0x18, 0x08, 0x03, 0x10, 0x06, 0x06, 0x00, 0xCC, 0x01,
  0x81, 0x80, 0x36, 0x00, 0x60, 0x60, 0x05, 0x80, 0x10, 0x10, 0x01, 0xC0,
  0x0C, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x0C, 0x07, 0x80, 0x00,
  0x60, 0x34, 0x00, 0x03, 0x01, 0x30, 0x00, 0x10, 0x09, 0x80, 0x01, 0x80,
  0xC6, 0x00, 0x0C, 0x06, 0x30, 0x00, 0x60, 0x30, 0xC0, 0x03, 0x01, 0x06,
  0x00, 0x10, 0x18, 0x10, 0x01, 0x80, 0xC0, 0xC0, 0x0C, 0x06, 0x06, 0x00,
  0x60, 0x30, 0x18, 0x02, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x02, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x03, 0x02, 0x01, 0x00,
  0x18, 0x30, 0x18, 0x00, 0x61, 0x80, 0xC0, 0x03, 0x0C, 0x06, 0x00, 0x08,
  0x60, 0x30, 0x00, 0x62, 0x01, 0x00, 0x03, 0x30, 0x18, 0x00, 0x0D, 0x80,
  0xC0, 0x00, 0x6C, 0x06, 0x00, 0x01, 0x40, 0x20, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x30, 0x1C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x02, 0x07, 0xE0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0x83, 0x00, 0x06, 0x04, 0x00, 0x38, 0x18, 0x01, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x30, 0x1C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x02, 0x0F, 0xE0, 0x0C, 0x00, 0x70, 0x18, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x0E, 0x04, 0x00, 0x70, 0x1F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x40, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x04,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0xE0, 0x01, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x70, 0x3E, 0x0F,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0x60, 0x03,
  0x80, 0x07, 0x81, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x10, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x74, 0x00, 0x0E, 0x00,
  0x06, 0x40, 0x00, 0xA0, 0x00, 0xC4, 0x00, 0x1A, 0x00, 0x0C, 0x40, 0x01,
  0xA0, 0x00, 0xC4, 0x00, 0x32, 0x00, 0x18, 0x40, 0x03, 0x20, 0x01, 0x84,
  0x00, 0x22, 0x00, 0x30, 0x60, 0x06, 0x20, 0x03, 0x06, 0x00, 0x43, 0x00,
  0x60, 0x60, 0x0C, 0x30, 0x06, 0x06, 0x00, 0x83, 0x00, 0xC0, 0x60, 0x18,
  0x30, 0x0C, 0x06, 0x01, 0x03, 0x00, 0x80, 0x60, 0x30, 0x30, 0x18, 0x06,
  0x03, 0x03, 0x01, 0x00, 0x60, 0x60, 0x30, 0x30, 0x06, 0x06, 0x03, 0x03,
  0x00, 0x60, 0xC0, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x06, 0x00, 0x61, 0x80,
  0x10, 0xC0, 0x06, 0x18, 0x01, 0x0C, 0x00, 0x23, 0x00, 0x11, 0x80, 0x02,
  0x30, 0x01, 0x18, 0x00, 0x26, 0x00, 0x11, 0x00, 0x02, 0x60, 0x01, 0x30,
  0x00, 0x24, 0x00, 0x1A, 0x00, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0x28, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x20,
  0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x04, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x02, 0x03, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xC0,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x20, 0x30, 0x30, 0x30, 0x10, 0x10,
  0x10, 0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04,
  0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x10, 0x00, 0x30, 0x80, 0x01, 0x86,
  0x00, 0x18, 0x10, 0x01, 0x80, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x80, 0x60, 0x06, 0x06, 0x00, 0x30, 0x60, 0x00, 0x83, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x00, 0x00, 0x98, 0x00, 0x07, 0x80, 0x00, 0x30, 0xFF,
  0xFF, 0x80, 0xC6, 0x18, 0x43, 0x0C, 0x20, 0x00, 0xFE, 0x08, 0x0E, 0x3C,
  0x41, 0xC0, 0x26, 0x1C, 0x00, 0xB0, 0xC0, 0x05, 0x0C, 0x00, 0x38, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0xE0, 0xC0, 0x0D, 0x06,
  0x00, 0xC8, 0x18, 0x0C, 0xC0, 0xE1, 0xC6, 0x03, 0xF8, 0x20, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0xFE, 0x01, 0x8E, 0x3C, 0x06, 0x60, 0x38, 0x12, 0x00,
  0x60, 0x50, 0x00, 0xC3, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80,
  0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xE0, 0x01, 0x86, 0x80, 0x0C, 0x13,
  0x00, 0x60, 0x47, 0x07, 0x03, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x3C,
  0x3C, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x83, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x7F, 0x0C, 0x01, 0xE3, 0x8C, 0x07, 0x00, 0xCC, 0x0E, 0x00, 0x68, 0x0C,
  0x00, 0x28, 0x18, 0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x20,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40,
  0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x40, 0x60, 0x03, 0xC0, 0x60,
  0x06, 0xC0, 0x70, 0x0C, 0xC0, 0x38, 0x70, 0x80, 0x1F, 0xE0, 0x80, 0x00,
  0xFE, 0x00, 0xF1, 0xC0, 0x70, 0x18, 0x30, 0x03, 0x18, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x03, 0xB0, 0x01, 0xCC, 0x03, 0xC3,
  0xFF, 0xC0, 0xFC, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x83, 0xC1, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x40,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x82, 0x01, 0xE3, 0x8C, 0x0E, 0x01, 0x98, 0x38,
  0x01, 0xA0, 0x60, 0x01, 0x41, 0x80, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00,
  0x0E, 0x10, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC2, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0x80, 0x02, 0x81, 0x80, 0x0F, 0x03,
  0x00, 0x36, 0x07, 0x00, 0xCC, 0x07, 0x0F, 0x10, 0x07, 0xF8, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x1C,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x83, 0xF8,
  0x0C, 0x78, 0xE0, 0x66, 0x01, 0x82, 0x60, 0x0C, 0x16, 0x00, 0x21, 0xE0,
  0x01, 0x0E, 0x00, 0x08, 0x60, 0x00, 0x43, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x40, 0x00, 0xC6, 0x00, 0x06,
  0x00, 0x00, 0x80, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x07, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x0E,
  0x0C, 0x00, 0xE0, 0x60, 0x0C, 0x02, 0x00, 0xC0, 0x10, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0xF0, 0x00, 0x4D, 0x80, 0x02, 0xC6, 0x00, 0x3C, 0x30,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x60, 0x00, 0x06, 0x1F, 0xC0, 0x7F, 0x00, 0xC7, 0x3C, 0x1C,
  0x70, 0x13, 0x01, 0x86, 0x03, 0x02, 0x40, 0x19, 0x80, 0x60, 0x50, 0x03,
  0x60, 0x04, 0x1E, 0x00, 0x78, 0x00, 0xC3, 0x80, 0x0E, 0x00, 0x18, 0x60,
  0x01, 0xC0, 0x02, 0x0C, 0x00, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x18,
  0x60, 0x00, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x00, 0x61, 0x80, 0x06, 0x00,
  0x08, 0x20, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x61, 0x80, 0x02,
  0x00, 0x0C, 0x30, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x00, 0x20, 0x80,
  0x03, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x01, 0x86, 0x00, 0x18, 0x00, 0x30,
  0xC0, 0x03, 0x00, 0x04, 0x10, 0x00, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x00,
  0x30, 0x06, 0x0F, 0xE0, 0x18, 0xF3, 0xC0, 0x66, 0x01, 0x81, 0x30, 0x06,
  0x0D, 0x80, 0x08, 0x3C, 0x00, 0x30, 0xE0, 0x00, 0x83, 0x00, 0x02, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20,
  0xC0, 0x01, 0x82, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x01, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x0F, 0x1E,
  0x01, 0xC0, 0x18, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x32, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x83,
  0x00, 0x18, 0x1C, 0x01, 0x80, 0x78, 0x38, 0x01, 0xFF, 0x00, 0x01, 0x83,
  0xF8, 0x01, 0x8E, 0x3C, 0x01, 0x18, 0x0E, 0x01, 0x30, 0x06, 0x01, 0x60,
  0x03, 0x03, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1E, 0x00, 0x18, 0x1A, 0x00,
  0x30, 0x1B, 0x00, 0x60, 0x11, 0xC1, 0xC0, 0x10, 0xFF, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x04, 0x07, 0x8E,
  0x30, 0x70, 0x0C, 0xC3, 0x80, 0x1A, 0x0C, 0x00, 0x28, 0x60, 0x00, 0xE3,
  0x00, 0x03, 0x8C, 0x00, 0x0E, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x0C, 0x00, 0x14, 0x18,
  0x00, 0xF0, 0x60, 0x06, 0xC0, 0xC0, 0x33, 0x03, 0x87, 0x08, 0x07, 0xF8,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x06, 0x1F, 0x83, 0x1E,
  0x41, 0x18, 0x00, 0x90, 0x00, 0x50, 0x00, 0x78, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xFF, 0x01, 0xE1, 0xF0, 0x60, 0x04, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x30, 0x03,
  0x8F, 0x03, 0xC0, 0xFF, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x08, 0x1F, 0x80, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x41, 0x00,
  0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x02,
  0x08, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x30, 0x40, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x3C, 0x30, 0x00,
  0xA0, 0x60, 0x04, 0x81, 0x80, 0x66, 0x03, 0x87, 0x18, 0x07, 0xF8, 0x60,
  0xC0, 0x00, 0x78, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x04, 0x04, 0x01, 0x80,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x00,
  0x82, 0x00, 0x10, 0xC0, 0x02, 0x30, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x01,
  0xB0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x1A, 0x00, 0x38, 0x00, 0xD0, 0x01, 0xC0, 0x0C, 0x80, 0x1E, 0x00, 0x64,
  0x00, 0xD0, 0x06, 0x20, 0x0C, 0x80, 0x31, 0x80, 0x64, 0x01, 0x0C, 0x06,
  0x20, 0x18, 0x60, 0x31, 0x00, 0x83, 0x03, 0x0C, 0x0C, 0x18, 0x18, 0x60,
  0x60, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC3, 0x01,
  0x84, 0x06, 0x18, 0x0C, 0x60, 0x11, 0x80, 0x62, 0x00, 0x8C, 0x03, 0x30,
  0x04, 0xC0, 0x09, 0x00, 0x26, 0x00, 0x58, 0x01, 0x20, 0x02, 0x80, 0x0B,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x23, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x19, 0x00, 0x00, 0x63, 0x00, 0x01, 0x82,
  0x00, 0x06, 0x06, 0x00, 0x18, 0x04, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x70, 0x00, 0x30, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x08, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00,
  0x40, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x0B, 0xDF, 0x00, 0x70, 0x0F, 0x0F, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraLightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 32, 10, 1, -32 },
  { 37, 10, 11, 15, 5, -32 },
  { 51, 26, 32, 28, 2, -32 },
  { 155, 21, 37, 25, 2, -34 },
  { 253, 28, 34, 35, 4, -33 },
  { 372, 27, 33, 31, 2, -33 },
  { 484, 4, 11, 8, 5, -32 },
  { 490, 12, 39, 11, 2, -32 },
  { 549, 13, 39, 11, -3, -32 },
  { 613, 19, 19, 24, 5, -34 },
  { 659, 21, 21, 26, 3, -26 },
  { 715, 7, 11, 9, -2, -5 },
  { 725, 10, 2, 14, 2, -13 },
  { 728, 3, 3, 10, 1, -3 },
  { 730, 20, 32, 14, -2, -32 },
  { 810, 21, 33, 25, 3, -33 },
  { 897, 12, 32, 25, 7, -32 },
  { 945, 23, 33, 25, 0, -33 },
  { 1040, 23, 33, 25, 1, -33 },
  { 1135, 23, 32, 25, 1, -32 },
  { 1227, 22, 32, 25, 2, -32 },
  { 1315, 21, 33, 25, 3, -33 },
  { 1402, 20, 32, 25, 5, -32 },
  { 1482, 22, 33, 25, 2, -33 },
  { 1573, 22, 33, 25, 2, -33 },
  { 1664, 8, 24, 10, 1, -24 },
  { 1688, 11, 30, 10, -2, -24 },
  { 1730, 21, 21, 26, 3, -27 },
  { 1786, 21, 10, 26, 3, -21 },
  { 1813, 21, 21, 26, 3, -27 },
  { 1869, 15, 33, 18, 4, -33 },
  { 1931, 34, 36, 38, 2, -32 },
  { 2084, 25, 32, 25, -2, -32 },
  { 2184, 24, 32, 27, 2, -32 },
  { 2280, 24, 33, 27, 4, -33 },
  { 2379, 27, 32, 30, 2, -32 },
  { 2487, 23, 32, 24, 2, -32 },
  { 2579, 23, 32, 22, 2, -32 },
  { 2671, 26, 33, 31, 4, -33 },
  { 2779, 29, 32, 31, 2, -32 },
  { 2895, 15, 32, 13, 0, -32 },
  { 2955, 19, 40, 11, -8, -32 },
  { 3050, 26, 32, 25, 2, -32 },
  { 3154, 17, 32, 22, 2, -32 },
  { 3222, 34, 32, 37, 2, -32 },
  { 3358, 29, 32, 31, 2, -32 },
  { 3474, 27, 33, 32, 4, -33 },
  { 3586, 23, 32, 25, 2, -32 },
  { 3678, 27, 41, 32, 4, -33 },
  { 3817, 23, 32, 25, 2, -32 },
  { 3909, 22, 33, 22, 1, -33 },
  { 4000, 22, 32, 22, 4, -32 },
  { 4088, 27, 32, 31, 4, -32 },
  { 4196, 23, 32, 24, 5, -32 },
  { 4288, 36, 32, 37, 5, -32 },
  { 4432, 29, 32, 22, -3, -32 },
  { 4548, 22, 32, 22, 4, -32 },
  { 4636, 26, 32, 24, 0, -32 },
  { 4740, 17, 39, 14, 0, -32 },
  { 4823, 8, 32, 14, 4, -32 },
  { 4855, 17, 39, 14, -3, -32 },
  { 4938, 21, 20, 25, 2, -32 },
  { 4991, 17, 1, 17, -4, 5 },
  { 4994, 5, 7, 11, 7, -34 },
  { 4999, 21, 24, 25, 2, -24 },
  { 5062, 22, 34, 26, 1, -34 },
  { 5156, 19, 24, 20, 2, -24 },
  { 5213, 24, 34, 26, 2, -34 },
  { 5315, 18, 24, 22, 3, -24 },
  { 5369, 25, 45, 12, -6, -34 },
  { 5510, 23, 35, 26, 1, -24 },
  { 5611, 21, 34, 25, 1, -34 },
  { 5701, 9, 33, 10, 1, -33 },
  { 5739, 16, 44, 10, -6, -33 },
  { 5827, 21, 34, 20, 1, -34 },
  { 5917, 9, 34, 10, 1, -34 },
  { 5956, 35, 24, 38, 1, -24 },
  { 6061, 22, 24, 25, 1, -24 },
  { 6127, 21, 24, 25, 2, -24 },
  { 6190, 24, 35, 26, -1, -24 },
  { 6295, 22, 35, 26, 2, -24 },
  { 6392, 17, 24, 17, 1, -24 },
  { 6443, 18, 24, 19, 0, -24 },
  { 6497, 13, 30, 14, 2, -30 },
  { 6546, 22, 24, 25, 2, -24 },
  { 6612, 19, 24, 19, 2, -24 },
  { 6669, 29, 24, 30, 2, -24 },
  { 6756, 23, 24, 21, -2, -24 },
  { 6825, 26, 35, 19, -5, -24 },
  { 6939, 21, 24, 20, -1, -24 },
  { 7002, 16, 39, 15, 1, -32 },
  { 7080, 1, 45, 24, 13, -34 },
  { 7086, 16, 39, 15, -2, -32 },
  { 7164, 21, 4, 26, 3, -18 },
};

const GFXfont NotoSans_ExtraLightItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRALIGHTITALIC45PT7B_H_
