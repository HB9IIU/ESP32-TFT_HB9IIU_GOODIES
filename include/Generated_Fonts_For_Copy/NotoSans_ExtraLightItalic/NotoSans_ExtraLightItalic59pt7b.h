#ifndef _NOTOSANS_EXTRALIGHTITALIC59PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x1C, 0x0C, 0x60, 0x31, 0x81, 0xC6,
  0x06, 0x38, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0x80, 0xC6,
  0x03, 0x18, 0x0C, 0x60, 0x21, 0x01, 0x8C, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x03, 0xF3, 0x3F, 0x00, 0xF0, 0xC0, 0x60, 0x38, 0x18, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x01, 0xE6, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xDF, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x60, 0x38, 0x20, 0x0C, 0x1E,
  0x07, 0xC1, 0x8F, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0x01, 0xE3, 0xC0, 0x00, 0x30, 0x0C, 0x06, 0x00,
  0x03, 0x80, 0xC0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x60,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x1C,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x03,
  0x00, 0xE0, 0x06, 0x00, 0x38, 0x06, 0x00, 0x70, 0x01, 0x80, 0x60, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x70, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x30, 0x18, 0x30, 0x01, 0x83, 0x07, 0xF9, 0x80,
  0x1C, 0x38, 0x71, 0xEC, 0x00, 0xC1, 0x87, 0x03, 0xE0, 0x0E, 0x18, 0x70,
  0x0F, 0x80, 0x61, 0x87, 0x00, 0x6C, 0x06, 0x1C, 0x30, 0x03, 0x78, 0xE0,
  0xC1, 0x80, 0x19, 0xFE, 0x0C, 0x18, 0x00, 0xC1, 0xC0, 0xE0, 0xC0, 0x06,
  0x00, 0x0E, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x07, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x70, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x0C, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x06, 0x01, 0x80,
  0x07, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x07, 0x03, 0x80, 0xC0, 0x00, 0x1E, 0x78, 0x0E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x03, 0x0F,
  0x00, 0x00, 0x00, 0x37, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x01, 0x0E, 0x00, 0xC0, 0x00, 0xC3, 0x80, 0x0C, 0x00,
  0x18, 0xE0, 0x01, 0xC0, 0x06, 0x38, 0x00, 0x1C, 0x01, 0xC6, 0x00, 0x01,
  0x80, 0x31, 0xC0, 0x00, 0x38, 0x0E, 0x30, 0x00, 0x03, 0x83, 0x86, 0x00,
  0x00, 0x30, 0x60, 0xC0, 0x00, 0x03, 0x18, 0x18, 0x00, 0x00, 0x77, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x03, 0x8E, 0x03, 0x80, 0x00,
  0xE0, 0xC0, 0x3C, 0x00, 0xF8, 0x1C, 0x03, 0xFB, 0xFC, 0x01, 0xC0, 0x1F,
  0xFE, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x61, 0x86, 0x38,
  0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x01, 0x00, 0x30, 0x01, 0xE0, 0x18, 0x00, 0x78,
  0x0C, 0x00, 0x0F, 0x06, 0x00, 0x01, 0xE2, 0x00, 0x00, 0x39, 0x00, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xD8, 0x00,
  0x01, 0xC4, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x01, 0xC0, 0x60,
  0x03, 0xC0, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07,
  0x03, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFE, 0x40, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00,
  0x18, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x07, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0x70, 0x3C, 0xE0, 0xE1,
  0x87, 0x83, 0x1C, 0x0E, 0xF0, 0x1C, 0x80, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x07, 0x00, 0x20, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x03, 0x80, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x0E,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0D,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3E,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF0, 0x70,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x81, 0xFE, 0x00, 0x30, 0x7F, 0xF8, 0x03, 0x1E, 0x03, 0xC0, 0x73,
  0x80, 0x0E, 0x06, 0x60, 0x00, 0x70, 0x6C, 0x00, 0x03, 0x07, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30,
  0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xF0,
  0x00, 0x38, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0xFE, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x18, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x36,
  0x0E, 0x00, 0x06, 0xE0, 0x70, 0x01, 0xCC, 0x03, 0xC0, 0xF8, 0xC0, 0x1F,
  0xFE, 0x1C, 0x00, 0x7F, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x80, 0x0F, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0xF0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x07, 0x83, 0xC1, 0xC0, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0x8F, 0x83,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0x06, 0x00, 0x07, 0xFF, 0xC0,
  0x18, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0xE3, 0x00, 0x0E, 0x00, 0x30, 0x03,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x19, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xCC,
  0x00, 0xE0, 0x00, 0xC0, 0x06, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x36, 0x00,
  0x60, 0x00, 0x60, 0x03, 0xB0, 0x03, 0x00, 0x03, 0x00, 0x1D, 0x80, 0x30,
  0x00, 0x18, 0x00, 0xCC, 0x01, 0x80, 0x01, 0xC0, 0x06, 0xE0, 0x0C, 0x00,
  0x0C, 0x00, 0x37, 0x00, 0x60, 0x00, 0x60, 0x03, 0xB8, 0x07, 0x00, 0x07,
  0x00, 0x19, 0x80, 0x38, 0x00, 0x38, 0x01, 0xCC, 0x01, 0xC0, 0x03, 0x80,
  0x0C, 0x60, 0x0E, 0x00, 0x1C, 0x00, 0xE3, 0x80, 0x30, 0x01, 0xA0, 0x06,
  0x1C, 0x01, 0x80, 0x19, 0x80, 0x70, 0x60, 0x0E, 0x01, 0x8C, 0x07, 0x03,
  0x00, 0x3C, 0x78, 0x79, 0xF0, 0x18, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x03,
  0xE0, 0x06, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0xC0, 0x18,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xC0,
  0x01, 0xF0, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x01, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0x80, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x01, 0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00,
  0x1F, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x8F,
  0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0xF3, 0x00, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x00, 0x19,
  0xD8, 0x00, 0x00, 0x0E, 0xE7, 0x00, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x00,
  0xF8, 0x38, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0x60, 0x0D, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0xB8, 0x07, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x33, 0x00, 0x00, 0x00,
  0xCC, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x0C, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0xE3, 0x00, 0x00, 0x06, 0x38, 0x07, 0x18, 0x00, 0x00, 0x71, 0x80,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x0C,
  0x30, 0x00, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x38, 0x06, 0x06,
  0x00, 0x01, 0xC1, 0x80, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x00, 0xE0, 0x60, 0x0C, 0x0C, 0x00, 0x06, 0x07, 0x00, 0xE0, 0x60, 0x00,
  0x60, 0x30, 0x06, 0x03, 0x80, 0x07, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x0C, 0x03, 0x00, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x1C,
  0x00, 0xC0, 0x60, 0x07, 0x00, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x80, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x01, 0x80, 0x0E,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x31, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x9C,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x6C, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x0F, 0x80, 0x00, 0x03,
  0x00, 0x6C, 0x00, 0x00, 0x18, 0x06, 0x70, 0x00, 0x01, 0xC0, 0x31, 0x80,
  0x00, 0x0C, 0x01, 0x8C, 0x00, 0x00, 0x60, 0x0C, 0x70, 0x00, 0x03, 0x00,
  0xE1, 0x80, 0x00, 0x38, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x30, 0x00,
  0x0C, 0x01, 0x81, 0x80, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xE0,
  0x30, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x06, 0x00, 0x38, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x07, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x07, 0x00, 0xE0, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0x03, 0x01, 0x80, 0x30, 0x00, 0x18, 0x0C, 0x01, 0x80,
  0x00, 0xE0, 0x60, 0x1C, 0x00, 0x03, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x38,
  0x06, 0x00, 0x00, 0x61, 0x80, 0x30, 0x00, 0x03, 0x0C, 0x01, 0x80, 0x00,
  0x1C, 0x60, 0x1C, 0x00, 0x00, 0x67, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x06,
  0x00, 0x00, 0x0D, 0x80, 0x30, 0x00, 0x00, 0x6C, 0x01, 0x80, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0E, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x38,
  0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80,
  0x01, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0xF8, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x80, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x10, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xB8,
  0x00, 0x03, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x80,
  0x00, 0x76, 0x00, 0x01, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x06, 0x38, 0x00,
  0x0E, 0x60, 0x00, 0x38, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC1, 0x80, 0x01,
  0xC6, 0x00, 0x07, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x60, 0x00, 0xE0, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x01, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x0C, 0x07, 0x00,
  0x30, 0x06, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x70, 0x38, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x07,
  0x07, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x5C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x03,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x38, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC1,
  0xC1, 0x83, 0x83, 0x03, 0x07, 0x06, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFF, 0x03, 0x00, 0xF8, 0x3C, 0x60, 0x1E, 0x00, 0xC6, 0x03, 0x80, 0x06,
  0x60, 0x70, 0x00, 0x26, 0x0E, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x3C, 0x1C,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x36, 0x0E, 0x00,
  0x03, 0xC0, 0x60, 0x00, 0x6C, 0x07, 0x00, 0x0C, 0xC0, 0x70, 0x01, 0x8C,
  0x03, 0x80, 0x70, 0xC0, 0x1F, 0xFE, 0x18, 0x00, 0xFF, 0x81, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x07, 0xC0, 0x03, 0x83, 0xFF, 0x00, 0x30, 0xF8, 0x78, 0x03,
  0x1C, 0x01, 0xC0, 0x33, 0x80, 0x0E, 0x07, 0x60, 0x00, 0x60, 0x6C, 0x00,
  0x07, 0x06, 0x80, 0x00, 0x30, 0x78, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30,
  0xF0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x18, 0x68, 0x00, 0x03, 0x86, 0xC0, 0x00, 0x70, 0x6C,
  0x00, 0x0E, 0x06, 0x60, 0x01, 0xC0, 0xC7, 0x00, 0x78, 0x0C, 0x3F, 0x7F,
  0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x7C, 0x0F, 0x01, 0xE0, 0x01, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x60, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xFC, 0x07, 0x00, 0x0F, 0xFE, 0x0C, 0x00, 0x7C, 0x1E,
  0x18, 0x01, 0xE0, 0x06, 0x30, 0x07, 0x00, 0x06, 0x60, 0x1C, 0x00, 0x0D,
  0xC0, 0x70, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x0D, 0x80, 0x30, 0x00, 0x1B, 0x00, 0x70, 0x00,
  0xE6, 0x00, 0xE0, 0x03, 0x8C, 0x00, 0xE0, 0x1E, 0x30, 0x00, 0xFD, 0xF0,
  0x60, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x07, 0x03, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x1C, 0x00,
  0x03, 0x18, 0x00, 0x07, 0x38, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00,
  0x1C, 0x70, 0x00, 0x78, 0x70, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x04, 0x00, 0x7F, 0xF0,
  0x20, 0x07, 0xC1, 0xE1, 0x80, 0x3C, 0x00, 0xC6, 0x01, 0xC0, 0x01, 0x98,
  0x0E, 0x00, 0x06, 0x60, 0x70, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x0F, 0x81, 0xC0, 0x00, 0x6C, 0x03, 0x00, 0x03, 0xB0, 0x0E, 0x00,
  0x1C, 0xC0, 0x38, 0x00, 0xE7, 0x00, 0x70, 0x0F, 0x18, 0x00, 0xFD, 0xF0,
  0x60, 0x01, 0xFF, 0x81, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x08, 0x00, 0x1C, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x00, 0xE0, 0xFF,
  0xE0, 0x18, 0x7C, 0x3E, 0x03, 0x1C, 0x01, 0xC0, 0x67, 0x00, 0x1C, 0x1D,
  0x80, 0x01, 0x83, 0x60, 0x00, 0x30, 0x6C, 0x00, 0x06, 0x0F, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x18, 0x78, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x40, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x02, 0x0E, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x03,
  0x00, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x70,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x3C, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x33, 0xB8, 0x00, 0x06, 0xE3,
  0x00, 0x00, 0xF8, 0x70, 0x00, 0x3E, 0x06, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x18, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xC3, 0xC3, 0xC0,
  0x78, 0x78, 0x06, 0x38, 0x06, 0x0E, 0x00, 0xE0, 0x33, 0x00, 0x38, 0xE0,
  0x07, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x1B, 0x00, 0x06, 0x60, 0x00,
  0xE0, 0xD0, 0x00, 0x36, 0x00, 0x07, 0x07, 0x80, 0x01, 0xA0, 0x00, 0x38,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C,
  0x00, 0x30, 0x3F, 0xF8, 0x03, 0x0F, 0xC7, 0xC0, 0x31, 0xC0, 0x1C, 0x03,
  0x38, 0x00, 0xE0, 0x76, 0x00, 0x06, 0x06, 0xC0, 0x00, 0x60, 0x6C, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x60, 0x70, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C,
  0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0xF0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0xFF,
  0xC0, 0x01, 0x87, 0xC3, 0xC0, 0x03, 0x1C, 0x01, 0xC0, 0x06, 0x70, 0x01,
  0xC0, 0x19, 0x80, 0x01, 0x80, 0x36, 0x00, 0x03, 0x80, 0x6C, 0x00, 0x03,
  0x00, 0xF0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x30, 0x1A, 0x00, 0x00, 0xE0, 0x36, 0x00,
  0x03, 0x80, 0x6C, 0x00, 0x0E, 0x00, 0xCC, 0x00, 0x38, 0x03, 0x9C, 0x01,
  0xE0, 0x06, 0x1F, 0xBF, 0x80, 0x0C, 0x0F, 0xFC, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x01, 0xFF, 0xC0, 0x80,
  0x3E, 0x0F, 0x0C, 0x03, 0xC0, 0x0C, 0x60, 0x38, 0x00, 0x33, 0x03, 0x80,
  0x01, 0x98, 0x38, 0x00, 0x07, 0x81, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x00,
  0x01, 0xB0, 0x18, 0x00, 0x1D, 0x80, 0xE0, 0x01, 0xCC, 0x07, 0x00, 0x1C,
  0xE0, 0x1C, 0x03, 0xC6, 0x00, 0x7E, 0xF8, 0x30, 0x01, 0xFF, 0x81, 0x80,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x78, 0x0C, 0x0F, 0xF0, 0x30, 0xF8, 0x80,
  0xC7, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xF0, 0x0F, 0x81, 0xF8, 0x3C, 0x00, 0x20, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x08, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x3F, 0xDF, 0xC0,
  0x1F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0xEF, 0x00, 0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x18, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0x60, 0xE0, 0x00, 0x36, 0x0E, 0x00,
  0x06, 0xC0, 0x60, 0x00, 0xCC, 0x07, 0x00, 0x18, 0xC0, 0x78, 0x07, 0x0C,
  0x03, 0xF7, 0xE0, 0xC0, 0x0F, 0xF8, 0x18, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x70, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0E,
  0x00, 0x38, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x60, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x6E, 0x00, 0x07,
  0x00, 0x03, 0xB8, 0x00, 0x34, 0x00, 0x0C, 0x60, 0x00, 0xD8, 0x00, 0x71,
  0x80, 0x06, 0x60, 0x01, 0x86, 0x00, 0x19, 0x80, 0x06, 0x18, 0x00, 0xC6,
  0x00, 0x30, 0x60, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x07, 0x06,
  0x00, 0x61, 0x80, 0x18, 0x18, 0x03, 0x06, 0x00, 0xE0, 0x60, 0x0C, 0x18,
  0x03, 0x01, 0x80, 0x60, 0x60, 0x1C, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x03, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x70, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x1C, 0x30, 0x03, 0x0E, 0x00, 0x70,
  0xC0, 0x0C, 0x30, 0x01, 0xC6, 0x00, 0x31, 0xC0, 0x03, 0x38, 0x00, 0xC6,
  0x00, 0x0C, 0xC0, 0x03, 0x18, 0x00, 0x37, 0x00, 0x0C, 0xC0, 0x00, 0xD8,
  0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0x7C, 0x7E, 0x00, 0x3E, 0x00,
  0xFC, 0x0E, 0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraLightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 43, 13, 2, -42 },
  { 66, 14, 15, 19, 6, -42 },
  { 93, 35, 42, 37, 2, -42 },
  { 277, 27, 48, 32, 3, -45 },
  { 439, 37, 44, 45, 5, -43 },
  { 643, 35, 44, 40, 3, -43 },
  { 836, 6, 15, 11, 6, -42 },
  { 848, 17, 51, 15, 2, -42 },
  { 957, 17, 51, 15, -4, -42 },
  { 1066, 25, 26, 32, 7, -45 },
  { 1148, 28, 28, 34, 4, -35 },
  { 1246, 9, 15, 12, -3, -7 },
  { 1263, 14, 2, 18, 2, -17 },
  { 1267, 4, 5, 13, 2, -4 },
  { 1270, 27, 42, 19, -3, -42 },
  { 1412, 27, 44, 32, 4, -43 },
  { 1561, 15, 42, 32, 9, -42 },
  { 1640, 29, 43, 32, 1, -43 },
  { 1796, 30, 44, 32, 1, -43 },
  { 1961, 30, 42, 32, 1, -42 },
  { 2119, 30, 43, 32, 2, -42 },
  { 2281, 28, 44, 32, 4, -43 },
  { 2435, 27, 42, 32, 6, -42 },
  { 2577, 28, 44, 32, 3, -43 },
  { 2731, 28, 44, 32, 3, -43 },
  { 2885, 9, 33, 13, 2, -32 },
  { 2923, 14, 40, 13, -3, -32 },
  { 2993, 28, 27, 34, 4, -35 },
  { 3088, 28, 14, 34, 4, -28 },
  { 3137, 28, 27, 34, 4, -35 },
  { 3232, 20, 44, 24, 5, -43 },
  { 3342, 45, 47, 49, 3, -42 },
  { 3607, 33, 42, 32, -3, -42 },
  { 3781, 31, 42, 35, 3, -42 },
  { 3944, 32, 44, 35, 5, -43 },
  { 4120, 35, 42, 40, 3, -42 },
  { 4304, 30, 42, 31, 3, -42 },
  { 4462, 30, 42, 29, 3, -42 },
  { 4620, 34, 44, 41, 5, -43 },
  { 4807, 37, 42, 40, 3, -42 },
  { 5002, 19, 42, 17, 0, -42 },
  { 5102, 24, 52, 14, -10, -42 },
  { 5258, 34, 42, 32, 3, -42 },
  { 5437, 21, 42, 29, 3, -42 },
  { 5548, 45, 42, 48, 3, -42 },
  { 5785, 37, 42, 40, 3, -42 },
  { 5980, 35, 44, 42, 5, -43 },
  { 6173, 30, 42, 33, 3, -42 },
  { 6331, 35, 53, 42, 5, -43 },
  { 6563, 30, 42, 33, 3, -42 },
  { 6721, 29, 44, 29, 1, -43 },
  { 6881, 29, 42, 29, 5, -42 },
  { 7034, 36, 43, 41, 5, -42 },
  { 7228, 30, 42, 32, 6, -42 },
  { 7386, 46, 42, 49, 7, -42 },
  { 7628, 37, 42, 29, -3, -42 },
  { 7823, 28, 42, 29, 6, -42 },
  { 7970, 34, 42, 32, 0, -42 },
  { 8149, 23, 51, 18, -1, -42 },
  { 8296, 9, 42, 19, 6, -42 },
  { 8344, 22, 51, 18, -4, -42 },
  { 8485, 27, 26, 33, 3, -42 },
  { 8573, 23, 2, 22, -5, 6 },
  { 8579, 7, 9, 14, 9, -45 },
  { 8587, 28, 33, 33, 3, -32 },
  { 8703, 28, 46, 34, 2, -45 },
  { 8864, 24, 33, 27, 3, -32 },
  { 8963, 31, 46, 34, 3, -45 },
  { 9142, 24, 33, 29, 3, -32 },
  { 9241, 33, 59, 16, -8, -45 },
  { 9485, 30, 46, 34, 2, -32 },
  { 9658, 27, 45, 33, 2, -45 },
  { 9810, 12, 43, 13, 2, -43 },
  { 9875, 21, 57, 13, -8, -43 },
  { 10025, 27, 45, 27, 2, -45 },
  { 10177, 12, 45, 13, 2, -45 },
  { 10245, 45, 32, 50, 2, -32 },
  { 10425, 28, 32, 33, 2, -32 },
  { 10537, 27, 33, 33, 3, -32 },
  { 10649, 31, 46, 34, -1, -32 },
  { 10828, 29, 46, 34, 3, -32 },
  { 10995, 22, 32, 22, 2, -32 },
  { 11083, 23, 33, 25, 1, -32 },
  { 11178, 17, 40, 19, 3, -39 },
  { 11263, 28, 32, 33, 3, -31 },
  { 11375, 25, 31, 25, 3, -31 },
  { 11472, 38, 31, 39, 3, -31 },
  { 11620, 30, 31, 27, -2, -31 },
  { 11737, 34, 45, 25, -6, -31 },
  { 11929, 27, 31, 26, -1, -31 },
  { 12034, 22, 51, 20, 1, -42 },
  { 12175, 2, 59, 32, 16, -45 },
  { 12190, 21, 51, 20, -3, -42 },
  { 12324, 28, 6, 34, 4, -24 },
};

const GFXfont NotoSans_ExtraLightItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRALIGHTITALIC59PT7B_H_
