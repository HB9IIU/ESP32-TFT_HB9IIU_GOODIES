#ifndef _NOTOSANS_EXTRALIGHTITALIC8PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xE0, 0x29, 0x96, 0xAF, 0xB0, 0x36, 0x62, 0x3E, 0xCE,
  0xBD, 0xD6, 0xDC, 0x32, 0x88, 0xD9, 0x7C, 0xC0, 0x2A, 0x49, 0x20, 0x24,
  0x92, 0xB0, 0x5F, 0x00, 0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00,
  0x76, 0xDB, 0x80, 0x75, 0x50, 0x71, 0x12, 0x4E, 0x71, 0x17, 0x1F, 0x13,
  0x55, 0xF2, 0x34, 0x61, 0x1F, 0x73, 0x5B, 0xC0, 0xF2, 0x24, 0x88, 0x35,
  0x57, 0x9F, 0x35, 0x97, 0x1E, 0x42, 0x42, 0x80, 0x3B, 0x10, 0xFC, 0x89,
  0xC0, 0xD6, 0xA0, 0x39, 0x1B, 0xEB, 0xBE, 0x07, 0x80, 0x22, 0x57, 0x99,
  0x32, 0x52, 0xE8, 0xF8, 0x78, 0x88, 0x8E, 0x32, 0x52, 0x98, 0xF8, 0x34,
  0x74, 0x8E, 0x34, 0x47, 0x88, 0x78, 0x8B, 0x9F, 0x4A, 0x52, 0xF8, 0xC4,
  0x69, 0x25, 0x00, 0x24, 0x94, 0xB0, 0x4A, 0x98, 0xC9, 0x48, 0x49, 0x29,
  0xC0, 0x45, 0x14, 0xDB, 0xB6, 0x90, 0x4A, 0x5A, 0xB9, 0xC4, 0x79, 0x99,
  0x9E, 0x35, 0x56, 0x88, 0x79, 0x99, 0x9E, 0x20, 0x35, 0x56, 0x99, 0x34,
  0x42, 0x1E, 0xF4, 0x44, 0x88, 0x8C, 0x65, 0x29, 0x70, 0x99, 0xAA, 0xC8,
  0x96, 0x9A, 0x76, 0x92, 0x40, 0x4A, 0x88, 0xCA, 0x48, 0x9A, 0xC8, 0x88,
  0x78, 0x88, 0x84, 0x78, 0x69, 0x49, 0x30, 0xFC, 0x24, 0x92, 0x70, 0x22,
  0x59, 0xE0, 0x80, 0x79, 0x9E, 0x46, 0x59, 0x9F, 0x78, 0x8E, 0x09, 0x55,
  0x29, 0x70, 0x7E, 0x8E, 0x37, 0x22, 0x44, 0x4C, 0x79, 0x9E, 0x1E, 0x46,
  0x59, 0x99, 0x46, 0xA0, 0x20, 0xA4, 0x94, 0x45, 0x6C, 0xAA, 0x56, 0xA0,
  0x7E, 0x59, 0x65, 0x79, 0x99, 0x79, 0x9F, 0x79, 0x9F, 0x88, 0x79, 0x9E,
  0x12, 0x72, 0x40, 0xE8, 0xF0, 0xEA, 0x4C, 0x59, 0x9E, 0x9A, 0xA4, 0xA6,
  0xA5, 0x24, 0x74, 0x4A, 0x4A, 0x94, 0x44, 0x60, 0x74, 0x4E, 0x29, 0x65,
  0x30, 0xFF, 0x49, 0x34, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 5, 6, 6, 1, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 1, 1, -6 },
  { 20, 3, 7, 2, 0, -6 },
  { 23, 3, 7, 2, -1, -6 },
  { 26, 3, 3, 4, 1, -6 },
  { 28, 3, 4, 5, 1, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 3, 6, 4, 1, -6 },
  { 39, 2, 6, 4, 1, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 3, 6, 4, 1, -6 },
  { 56, 4, 6, 4, 1, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 2, 5, 2, 0, -4 },
  { 68, 3, 4, 5, 1, -5 },
  { 70, 3, 2, 5, 1, -4 },
  { 71, 3, 4, 5, 1, -5 },
  { 73, 2, 6, 3, 1, -6 },
  { 75, 6, 7, 7, 0, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 5, 6, 5, 0, -6 },
  { 88, 4, 6, 5, 1, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 4, 6, 4, 0, -6 },
  { 101, 4, 6, 6, 1, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 3, 6, 2, 0, -6 },
  { 111, 3, 7, 2, -1, -6 },
  { 114, 5, 6, 4, 0, -6 },
  { 118, 3, 6, 4, 0, -6 },
  { 121, 6, 6, 7, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 4, 6, 6, 1, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 4, 7, 6, 1, -6 },
  { 140, 4, 6, 5, 0, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 1, -6 },
  { 149, 5, 6, 6, 1, -6 },
  { 153, 4, 6, 4, 1, -6 },
  { 156, 6, 6, 7, 1, -6 },
  { 161, 5, 6, 4, 0, -6 },
  { 165, 4, 6, 4, 1, -6 },
  { 168, 5, 6, 4, 0, -6 },
  { 172, 3, 7, 2, 0, -6 },
  { 175, 1, 6, 3, 1, -6 },
  { 176, 3, 7, 2, -1, -6 },
  { 179, 4, 4, 4, 0, -6 },
  { 181, 3, 1, 3, -1, 0 },
  { 182, 1, 1, 2, 1, -6 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 4, 6, 5, 0, -6 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 5, 6, 5, 0, -6 },
  { 194, 4, 4, 4, 0, -4 },
  { 196, 4, 8, 2, -1, -6 },
  { 200, 4, 6, 5, 0, -4 },
  { 203, 4, 6, 4, 0, -6 },
  { 206, 2, 6, 2, 0, -6 },
  { 208, 3, 8, 2, -1, -6 },
  { 211, 4, 6, 4, 0, -6 },
  { 214, 2, 6, 2, 0, -6 },
  { 216, 6, 4, 7, 0, -4 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 4, 4, 5, 0, -4 },
  { 223, 4, 6, 5, 0, -4 },
  { 226, 4, 6, 5, 0, -4 },
  { 229, 3, 4, 3, 0, -4 },
  { 231, 3, 4, 3, 0, -4 },
  { 233, 3, 5, 3, 0, -5 },
  { 235, 4, 4, 4, 0, -4 },
  { 237, 4, 4, 3, 0, -4 },
  { 239, 6, 4, 5, 0, -4 },
  { 242, 4, 4, 4, 0, -4 },
  { 244, 5, 6, 3, -1, -4 },
  { 248, 4, 4, 4, 0, -4 },
  { 250, 3, 7, 3, 0, -6 },
  { 253, 1, 8, 4, 2, -6 },
  { 254, 3, 7, 3, 0, -6 },
  { 257, 3, 1, 5, 1, -3 },
};

const GFXfont NotoSans_ExtraLightItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRALIGHTITALIC8PT7B_H_
