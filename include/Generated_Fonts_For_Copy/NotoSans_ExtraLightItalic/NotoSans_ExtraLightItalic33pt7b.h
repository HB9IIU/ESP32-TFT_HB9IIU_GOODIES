#ifndef _NOTOSANS_EXTRALIGHTITALIC33PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81,
  0x06, 0x08, 0x10, 0x20, 0x40, 0x00, 0x00, 0x00, 0x30, 0x60, 0x62, 0x85,
  0x0A, 0x3C, 0x50, 0xA1, 0x42, 0x88, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00,
  0x40, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x83, 0x00,
  0x10, 0x20, 0x3F, 0xFF, 0xF0, 0x10, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x60, 0x40, 0x04, 0x08, 0x00, 0x40, 0x80, 0xFF, 0xFF,
  0xC0, 0x81, 0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x18, 0x10, 0x01, 0x02,
  0x00, 0x10, 0x20, 0x03, 0x06, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x1F, 0xE0, 0xC4, 0x63, 0x08, 0x04, 0x30, 0x18, 0x40, 0x30, 0x80, 0x61,
  0x00, 0x42, 0x00, 0x6C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x5C, 0x00, 0x8C,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0xC0, 0x21, 0x10, 0x8C, 0x3F,
  0xF0, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x30,
  0xCC, 0x01, 0x08, 0x20, 0x10, 0xC1, 0x01, 0x04, 0x08, 0x18, 0x20, 0x40,
  0x83, 0x02, 0x08, 0x10, 0x10, 0x80, 0x80, 0x8C, 0x04, 0x0C, 0x40, 0x20,
  0x44, 0x7D, 0x06, 0x44, 0x28, 0x26, 0x41, 0xE2, 0x26, 0x0C, 0xE2, 0x20,
  0x60, 0x31, 0x03, 0x03, 0x08, 0x10, 0x10, 0xC0, 0x81, 0x04, 0x04, 0x18,
  0x20, 0x61, 0x81, 0x02, 0x08, 0x0C, 0x10, 0x80, 0x21, 0x0C, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1C, 0x60, 0x01, 0x03, 0x00, 0x20, 0x10, 0x02, 0x01,
  0x00, 0x20, 0x10, 0x02, 0x03, 0x00, 0x20, 0x20, 0x02, 0x0C, 0x00, 0x11,
  0x80, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x40, 0x01, 0x86, 0x01, 0x30,
  0x30, 0x36, 0x01, 0x02, 0x40, 0x08, 0x44, 0x00, 0xCC, 0xC0, 0x05, 0x8C,
  0x00, 0x30, 0x40, 0x07, 0x06, 0x00, 0xD8, 0x30, 0x30, 0x81, 0xFE, 0x04,
  0x69, 0x2D, 0x24, 0x80, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x00,
  0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x80, 0x30, 0x00, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x0C,
  0x0C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x10, 0x20, 0x40, 0xE1, 0x00, 0xC4,
  0x00, 0xE7, 0xC0, 0xE0, 0x0D, 0x00, 0x64, 0x03, 0x08, 0x18, 0x20, 0x40,
  0xC0, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x13, 0x32, 0x64,
  0xC8, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0xF0,
  0x06, 0x38, 0x10, 0x10, 0x40, 0x31, 0x80, 0x22, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x60, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x1B, 0x00, 0x26, 0x00, 0xC4,
  0x01, 0x0C, 0x04, 0x0C, 0x30, 0x0F, 0xC0, 0x01, 0x81, 0x83, 0x43, 0x26,
  0x16, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x00, 0x7C,
  0x00, 0xE3, 0x01, 0x80, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0xF8, 0x07, 0x8E, 0x0C, 0x03, 0x08, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x18, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x30, 0x7F,
  0xC0, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x90,
  0x00, 0x88, 0x00, 0x8C, 0x00, 0x84, 0x00, 0xC2, 0x00, 0xC1, 0x00, 0xC1,
  0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x40, 0x10, 0x40, 0x18, 0x40,
  0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x07, 0xFC, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC3, 0x01, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0x01, 0xE1, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0xC0, 0x67, 0xF0, 0x58, 0x18, 0x70, 0x0C, 0x60, 0x04, 0xC0,
  0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0x40,
  0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x01, 0xF0, 0x07, 0x1C, 0x0C, 0x06, 0x08, 0x02,
  0x18, 0x03, 0x18, 0x03, 0x18, 0x02, 0x18, 0x02, 0x08, 0x04, 0x0C, 0x18,
  0x06, 0x30, 0x01, 0xC0, 0x0E, 0xE0, 0x38, 0x30, 0x60, 0x18, 0xC0, 0x08,
  0x80, 0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0xC0, 0x10,
  0x60, 0x70, 0x3F, 0xC0, 0x01, 0xF0, 0x0E, 0x30, 0x30, 0x30, 0x80, 0x33,
  0x00, 0x24, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x05, 0x80,
  0x19, 0x00, 0x73, 0x01, 0xE3, 0x0E, 0x83, 0xF1, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x7F,
  0x00, 0x08, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x1F, 0x0E, 0x38, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x00,
  0x40, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x1E, 0x04, 0x40, 0x71,
  0x83, 0x40, 0x40, 0x40, 0xA0, 0x40, 0x60, 0x70, 0x60, 0x20, 0x70, 0x20,
  0x10, 0x38, 0x30, 0x08, 0x14, 0x10, 0x0C, 0x0A, 0x08, 0x04, 0x0D, 0x04,
  0x06, 0x04, 0x82, 0x03, 0x06, 0x41, 0x82, 0x86, 0x20, 0x7E, 0x3E, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x05, 0x80, 0x01, 0xB0, 0x00, 0x22,
  0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x02, 0x06,
  0x00, 0xC0, 0xC0, 0x10, 0x08, 0x06, 0x01, 0x00, 0xFF, 0xE0, 0x30, 0x04,
  0x04, 0x00, 0x81, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x23, 0x00, 0x04,
  0x40, 0x00, 0x98, 0x00, 0x16, 0x00, 0x03, 0x07, 0xE0, 0x07, 0xFF, 0x02,
  0x00, 0xC1, 0x00, 0x30, 0x80, 0x08, 0xC0, 0x04, 0x60, 0x02, 0x20, 0x03,
  0x10, 0x01, 0x08, 0x01, 0x8C, 0x03, 0x87, 0xFE, 0x02, 0x01, 0xC1, 0x00,
  0x30, 0x80, 0x08, 0xC0, 0x04, 0x60, 0x03, 0x20, 0x01, 0x10, 0x00, 0x88,
  0x00, 0x4C, 0x00, 0x44, 0x00, 0x62, 0x01, 0xC1, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x70, 0xF0, 0x70, 0x04, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x80, 0xC0, 0x3F, 0xE0, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x20, 0x0C, 0x04,
  0x00, 0xC0, 0x80, 0x0C, 0x30, 0x00, 0x86, 0x00, 0x18, 0x80, 0x03, 0x10,
  0x00, 0x22, 0x00, 0x04, 0xC0, 0x00, 0x98, 0x00, 0x12, 0x00, 0x06, 0x40,
  0x00, 0xC8, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0xC8, 0x00, 0x11, 0x00,
  0x04, 0x20, 0x01, 0x8C, 0x00, 0x61, 0x00, 0x38, 0x20, 0x3C, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x3F,
  0xFC, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x3F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x38, 0x7C, 0x1C, 0x00, 0x86, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFD, 0x00, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x22, 0x00, 0x04, 0x60, 0x00,
  0x84, 0x00, 0x30, 0x40, 0x06, 0x0E, 0x01, 0x80, 0x7F, 0xE0, 0x04, 0x00,
  0x10, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80,
  0x02, 0x18, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x61, 0x00, 0x04, 0x30,
  0x00, 0x43, 0xFF, 0xFC, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x00, 0x86,
  0x00, 0x08, 0x60, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x10,
  0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x30, 0x07, 0xE0,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x4E, 0x03, 0xE0, 0x00,
  0x04, 0x00, 0x61, 0x80, 0x18, 0x20, 0x06, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x30, 0x10, 0x06, 0x0C, 0x00, 0x83, 0x00, 0x10, 0xC0, 0x02, 0x30, 0x00,
  0xCC, 0x00, 0x1A, 0x80, 0x02, 0x98, 0x00, 0x61, 0x00, 0x08, 0x30, 0x03,
  0x02, 0x00, 0x60, 0x60, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x0C,
  0x01, 0x01, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x04, 0x00, 0x01,
  0x87, 0x00, 0x01, 0xC2, 0x80, 0x01, 0xC1, 0x40, 0x00, 0xA0, 0xA0, 0x00,
  0xD0, 0xD0, 0x00, 0x58, 0x68, 0x00, 0x48, 0x26, 0x00, 0x24, 0x11, 0x00,
  0x22, 0x08, 0x80, 0x31, 0x0C, 0x40, 0x11, 0x86, 0x20, 0x18, 0x82, 0x10,
  0x08, 0x41, 0x0C, 0x08, 0x20, 0x82, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x40,
  0x86, 0x08, 0x20, 0x42, 0x04, 0x10, 0x22, 0x02, 0x08, 0x1B, 0x03, 0x0C,
  0x05, 0x01, 0x84, 0x03, 0x80, 0x82, 0x01, 0x80, 0x41, 0x00, 0x80, 0x60,
  0x04, 0x00, 0x10, 0xC0, 0x01, 0x0E, 0x00, 0x10, 0xA0, 0x03, 0x0A, 0x00,
  0x31, 0xB0, 0x02, 0x19, 0x00, 0x21, 0x18, 0x02, 0x10, 0x80, 0x61, 0x08,
  0x04, 0x30, 0x40, 0x43, 0x04, 0x04, 0x20, 0x60, 0x42, 0x02, 0x0C, 0x20,
  0x30, 0x86, 0x01, 0x08, 0x40, 0x10, 0x84, 0x00, 0x98, 0x40, 0x09, 0x84,
  0x00, 0xD0, 0xC0, 0x05, 0x08, 0x00, 0x50, 0x80, 0x03, 0x08, 0x00, 0x30,
  0x00, 0xFC, 0x00, 0x70, 0xE0, 0x18, 0x06, 0x04, 0x00, 0x61, 0x00, 0x06,
  0x60, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xC4,
  0x00, 0x30, 0x40, 0x0C, 0x0E, 0x07, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x0F,
  0xFC, 0x08, 0x06, 0x08, 0x03, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x03, 0x30, 0x02, 0x30, 0x06, 0x20, 0x1C, 0x3F,
  0xE0, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x70, 0xE0, 0x18, 0x06, 0x04, 0x00, 0x61, 0x00, 0x06, 0x60, 0x00, 0xD8,
  0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x02, 0x80,
  0x00, 0x50, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x30, 0x40,
  0x0C, 0x0E, 0x07, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x07, 0xC0, 0x0F,
  0xFC, 0x08, 0x06, 0x08, 0x03, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x03, 0x30, 0x02, 0x30, 0x0C, 0x3F, 0xF8, 0x3F,
  0xC0, 0x20, 0x40, 0x60, 0x60, 0x60, 0x20, 0x40, 0x30, 0x40, 0x10, 0x40,
  0x10, 0xC0, 0x18, 0x80, 0x08, 0x80, 0x08, 0x80, 0x0C, 0x00, 0xFC, 0x07,
  0x8F, 0x0C, 0x01, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x80, 0x60, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x31,
  0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x23, 0x00, 0x06,
  0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x04, 0x60, 0x00,
  0xC4, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0xC0, 0x01, 0x88, 0x00,
  0x18, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0xC0,
  0x06, 0x04, 0x00, 0xC0, 0x30, 0x38, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0xA0,
  0x00, 0xD0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10,
  0xC0, 0x18, 0x60, 0x08, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x06,
  0x01, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00, 0x31, 0x80, 0x18, 0x80, 0x04,
  0xC0, 0x02, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x28, 0x01, 0x40, 0x1A, 0x00, 0x50,
  0x04, 0x80, 0x34, 0x01, 0x20, 0x09, 0x00, 0x8C, 0x06, 0x40, 0x23, 0x01,
  0x10, 0x18, 0xC0, 0xC4, 0x04, 0x30, 0x21, 0x03, 0x0C, 0x18, 0x40, 0x81,
  0x04, 0x10, 0x60, 0x43, 0x04, 0x10, 0x10, 0x81, 0x0C, 0x04, 0x20, 0x42,
  0x01, 0x10, 0x18, 0x80, 0x44, 0x06, 0x40, 0x12, 0x01, 0x90, 0x04, 0x80,
  0x6C, 0x01, 0x60, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x02, 0x00, 0x18, 0x18, 0x00, 0x80,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x40, 0xC0, 0x02, 0x04,
  0x00, 0x08, 0x40, 0x00, 0x44, 0x00, 0x03, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x28, 0x00, 0x02, 0x60, 0x00, 0x31, 0x00,
  0x03, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x10, 0x0C, 0x01, 0x00,
  0x20, 0x18, 0x01, 0x81, 0x80, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01, 0xC0,
  0x02, 0x40, 0x06, 0x40, 0x04, 0x60, 0x08, 0x20, 0x18, 0x20, 0x30, 0x30,
  0x20, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x19, 0x00, 0x0B, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0xFC, 0x00, 0x83, 0x04, 0x10, 0x41, 0x06, 0x08, 0x20, 0x82, 0x08, 0x30,
  0x41, 0x04, 0x10, 0x41, 0x82, 0x08, 0x20, 0x83, 0x03, 0xF0, 0x7F, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0xFC, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x02, 0x80, 0x09, 0x00,
  0x33, 0x00, 0x42, 0x01, 0x04, 0x06, 0x08, 0x08, 0x08, 0x20, 0x10, 0xC0,
  0x21, 0x00, 0x26, 0x00, 0x58, 0x00, 0xA0, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC4, 0x62, 0x10, 0x03, 0xC0, 0x1C, 0xE4, 0x60, 0x49, 0x80, 0x72,
  0x00, 0xCC, 0x01, 0x90, 0x03, 0x60, 0x06, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x24, 0x00, 0xC8, 0x01, 0x90, 0x06, 0x20, 0x1C, 0x60, 0x68, 0x61, 0x90,
  0x7C, 0x60, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x78, 0x09, 0xCC, 0x1A, 0x06, 0x14, 0x03,
  0x18, 0x01, 0x18, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x03,
  0x20, 0x02, 0x60, 0x02, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x70, 0x18,
  0x98, 0x30, 0x8F, 0xE0, 0x01, 0xF0, 0x78, 0xC6, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x70, 0x20, 0xFE, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x03, 0x86, 0x0E, 0x32, 0x0C, 0x05, 0x0C, 0x02, 0x84, 0x00, 0xC6,
  0x00, 0x62, 0x00, 0x23, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x06,
  0x20, 0x02, 0x10, 0x03, 0x08, 0x01, 0x84, 0x01, 0x43, 0x01, 0x40, 0xC3,
  0x20, 0x3F, 0x10, 0x00, 0x01, 0xE0, 0x31, 0x86, 0x06, 0x20, 0x12, 0x00,
  0xB0, 0x05, 0x00, 0x58, 0x0E, 0xCF, 0xC7, 0xC0, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x30, 0x20, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x02, 0x60, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x83, 0x8C, 0x83, 0x01, 0x43, 0x00, 0xA1, 0x00, 0x31,
  0x80, 0x18, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01,
  0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x61, 0x00, 0x70, 0xC0, 0x50, 0x30,
  0xC8, 0x0F, 0xC4, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0xE1, 0xC0, 0x1F, 0x80, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x3C,
  0x09, 0xCC, 0x34, 0x04, 0x50, 0x08, 0xC0, 0x11, 0x80, 0x26, 0x00, 0x4C,
  0x00, 0x90, 0x01, 0x20, 0x06, 0x40, 0x09, 0x80, 0x12, 0x00, 0x24, 0x00,
  0xC8, 0x01, 0x90, 0x02, 0x60, 0x04, 0x80, 0x08, 0x06, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1,
  0x02, 0x04, 0x08, 0x30, 0x40, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x02, 0x60, 0x1E, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x01,
  0x08, 0x0C, 0x30, 0x30, 0x40, 0xC0, 0x83, 0x01, 0x0C, 0x06, 0x30, 0x08,
  0xC0, 0x13, 0x00, 0x2B, 0x00, 0x62, 0x01, 0x86, 0x02, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x10, 0x18, 0x60, 0x10, 0x80, 0x30, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x10, 0x60, 0x80, 0x00, 0x70, 0x1E, 0x04, 0xCE, 0x31,
  0x84, 0x81, 0x30, 0x62, 0x80, 0xA0, 0x11, 0x80, 0x50, 0x08, 0xC0, 0x30,
  0x04, 0xC0, 0x18, 0x02, 0x60, 0x08, 0x03, 0x20, 0x04, 0x01, 0x10, 0x06,
  0x00, 0x88, 0x02, 0x00, 0x4C, 0x01, 0x00, 0x24, 0x00, 0x80, 0x32, 0x00,
  0xC0, 0x11, 0x00, 0x60, 0x08, 0x80, 0x20, 0x04, 0xC0, 0x10, 0x06, 0x40,
  0x08, 0x03, 0x00, 0x00, 0x78, 0x19, 0xCE, 0x12, 0x02, 0x14, 0x02, 0x18,
  0x03, 0x18, 0x02, 0x30, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20,
  0x04, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0,
  0x08, 0x80, 0x18, 0x01, 0xE0, 0x1E, 0x70, 0x60, 0x31, 0x80, 0x22, 0x00,
  0x68, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x14,
  0x00, 0x28, 0x00, 0xD0, 0x01, 0x30, 0x06, 0x20, 0x18, 0x60, 0x60, 0x3F,
  0x80, 0x00, 0x1E, 0x00, 0x9C, 0xC0, 0x48, 0x18, 0x14, 0x03, 0x06, 0x00,
  0x41, 0x80, 0x10, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30,
  0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x41, 0x80, 0x30, 0x70,
  0x18, 0x36, 0x0C, 0x08, 0xFE, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xC1, 0x0E, 0x32, 0x18, 0x0A, 0x30, 0x0A, 0x20, 0x06, 0x60, 0x06,
  0x40, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08,
  0x80, 0x18, 0x80, 0x18, 0x80, 0x38, 0xC0, 0x58, 0x61, 0x90, 0x3F, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x70, 0x9D, 0x12, 0x01, 0x40, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x03, 0xE0, 0x71, 0xC6, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x80, 0x04, 0xC0, 0xC3, 0xFC,
  0x00, 0x08, 0x04, 0x04, 0x02, 0x03, 0x07, 0xFC, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x03, 0xE0, 0x30, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x26, 0x00, 0x48,
  0x00, 0x90, 0x03, 0x20, 0x06, 0x40, 0x09, 0x80, 0x12, 0x00, 0x64, 0x00,
  0xC8, 0x03, 0x90, 0x06, 0x20, 0x14, 0x60, 0xC8, 0x7E, 0x30, 0x80, 0x0E,
  0x00, 0x48, 0x03, 0x20, 0x08, 0xC0, 0x61, 0x01, 0x04, 0x0C, 0x10, 0x20,
  0x41, 0x01, 0x0C, 0x04, 0x20, 0x19, 0x80, 0x24, 0x00, 0xB0, 0x02, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xA0, 0x28, 0x0D,
  0x01, 0x40, 0x48, 0x12, 0x06, 0x40, 0x98, 0x22, 0x08, 0xC3, 0x10, 0x42,
  0x10, 0xC4, 0x11, 0x86, 0x20, 0x88, 0x32, 0x04, 0xC1, 0x90, 0x24, 0x05,
  0x01, 0x20, 0x28, 0x0A, 0x01, 0x80, 0x50, 0x0C, 0x03, 0x00, 0x40, 0x18,
  0x00, 0x0C, 0x03, 0x82, 0x03, 0x01, 0x81, 0x00, 0x41, 0x00, 0x21, 0x00,
  0x09, 0x00, 0x05, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xA0, 0x00, 0x90,
  0x00, 0x84, 0x00, 0x82, 0x00, 0x81, 0x80, 0xC0, 0x40, 0xC0, 0x30, 0xC0,
  0x08, 0x00, 0x02, 0x00, 0x30, 0x20, 0x04, 0x02, 0x00, 0xC0, 0x30, 0x08,
  0x03, 0x01, 0x80, 0x10, 0x10, 0x01, 0x03, 0x00, 0x10, 0x20, 0x01, 0x06,
  0x00, 0x18, 0x40, 0x01, 0x88, 0x00, 0x09, 0x80, 0x00, 0x90, 0x00, 0x0B,
  0x00, 0x00, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x08,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x00,
  0x30, 0x0F, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0xE0, 0x06, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x02, 0x00, 0x3C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x0F,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0xF0, 0x00, 0x3F, 0x01, 0xC1, 0xC6,
  0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraLightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 24, 7, 1, -24 },
  { 22, 7, 9, 11, 4, -24 },
  { 30, 20, 24, 21, 1, -24 },
  { 90, 15, 27, 18, 2, -25 },
  { 141, 21, 24, 25, 3, -24 },
  { 204, 20, 24, 22, 1, -24 },
  { 264, 3, 9, 6, 4, -24 },
  { 268, 10, 29, 8, 1, -24 },
  { 305, 9, 29, 8, -2, -24 },
  { 338, 14, 14, 18, 4, -25 },
  { 363, 16, 15, 19, 2, -19 },
  { 393, 4, 8, 7, -1, -4 },
  { 397, 8, 2, 10, 1, -10 },
  { 399, 2, 2, 7, 1, -2 },
  { 400, 14, 24, 10, -1, -24 },
  { 442, 15, 24, 18, 2, -24 },
  { 487, 9, 24, 18, 5, -24 },
  { 514, 17, 24, 18, 0, -24 },
  { 565, 16, 24, 18, 1, -24 },
  { 613, 17, 24, 18, 0, -24 },
  { 664, 17, 24, 18, 1, -24 },
  { 715, 16, 24, 18, 2, -24 },
  { 763, 15, 24, 18, 4, -24 },
  { 808, 16, 24, 18, 2, -24 },
  { 856, 15, 24, 18, 2, -24 },
  { 901, 5, 18, 7, 1, -18 },
  { 913, 8, 22, 7, -2, -18 },
  { 935, 16, 15, 19, 2, -19 },
  { 965, 16, 8, 19, 2, -16 },
  { 981, 16, 15, 19, 2, -19 },
  { 1011, 11, 24, 13, 3, -24 },
  { 1044, 25, 26, 28, 2, -23 },
  { 1126, 19, 24, 18, -2, -24 },
  { 1183, 17, 24, 20, 2, -24 },
  { 1234, 18, 24, 20, 3, -24 },
  { 1288, 19, 24, 22, 2, -24 },
  { 1345, 16, 24, 18, 2, -24 },
  { 1393, 16, 24, 16, 2, -24 },
  { 1441, 19, 24, 23, 3, -24 },
  { 1498, 20, 24, 22, 2, -24 },
  { 1558, 11, 24, 10, 0, -24 },
  { 1591, 14, 30, 8, -6, -24 },
  { 1644, 19, 24, 18, 2, -24 },
  { 1701, 12, 24, 16, 2, -24 },
  { 1737, 25, 24, 27, 2, -24 },
  { 1812, 20, 24, 22, 2, -24 },
  { 1872, 19, 24, 24, 3, -24 },
  { 1929, 16, 24, 18, 2, -24 },
  { 1977, 19, 30, 24, 3, -24 },
  { 2049, 16, 24, 19, 2, -24 },
  { 2097, 16, 24, 16, 1, -24 },
  { 2145, 16, 24, 16, 3, -24 },
  { 2193, 20, 24, 23, 3, -24 },
  { 2253, 17, 24, 18, 3, -24 },
  { 2304, 26, 24, 27, 4, -24 },
  { 2382, 21, 24, 16, -2, -24 },
  { 2445, 16, 24, 16, 3, -24 },
  { 2493, 19, 24, 18, 0, -24 },
  { 2550, 12, 29, 10, 0, -24 },
  { 2594, 6, 24, 10, 3, -24 },
  { 2612, 12, 29, 10, -2, -24 },
  { 2656, 15, 15, 18, 2, -24 },
  { 2685, 13, 2, 12, -3, 3 },
  { 2689, 4, 5, 8, 5, -25 },
  { 2692, 15, 18, 18, 2, -18 },
  { 2726, 16, 25, 19, 1, -25 },
  { 2776, 13, 18, 15, 2, -18 },
  { 2806, 17, 25, 19, 2, -25 },
  { 2860, 13, 18, 16, 2, -18 },
  { 2890, 18, 33, 9, -4, -25 },
  { 2965, 17, 26, 19, 1, -18 },
  { 3021, 15, 25, 18, 1, -25 },
  { 3068, 7, 24, 7, 1, -24 },
  { 3089, 13, 32, 7, -5, -24 },
  { 3141, 15, 25, 15, 1, -25 },
  { 3188, 7, 25, 7, 1, -25 },
  { 3210, 25, 18, 28, 1, -18 },
  { 3267, 16, 18, 18, 1, -18 },
  { 3303, 15, 18, 19, 2, -18 },
  { 3337, 18, 26, 19, -1, -18 },
  { 3396, 16, 26, 19, 2, -18 },
  { 3448, 12, 18, 12, 1, -18 },
  { 3475, 13, 18, 14, 0, -18 },
  { 3505, 9, 22, 10, 2, -22 },
  { 3530, 15, 17, 18, 2, -17 },
  { 3562, 14, 17, 14, 2, -17 },
  { 3592, 21, 17, 22, 2, -17 },
  { 3637, 17, 17, 15, -1, -17 },
  { 3674, 20, 25, 14, -4, -17 },
  { 3737, 14, 17, 14, 0, -17 },
  { 3767, 12, 29, 11, 1, -24 },
  { 3811, 1, 33, 18, 9, -25 },
  { 3816, 12, 29, 11, -2, -24 },
  { 3860, 16, 3, 19, 2, -13 },
};

const GFXfont NotoSans_ExtraLightItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRALIGHTITALIC33PT7B_H_
