#ifndef _NOTOSANS_EXTRALIGHTITALIC12PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x76, 0xD0, 0x12, 0x12, 0x14, 0x7F, 0x24,
  0x24, 0xFA, 0x48, 0x48, 0x13, 0xE9, 0x46, 0x18, 0xAA, 0xE2, 0x00, 0x62,
  0x92, 0x94, 0x9A, 0xB5, 0x59, 0x29, 0x4A, 0xCE, 0x30, 0x91, 0x22, 0xC6,
  0x12, 0x63, 0x44, 0xF4, 0xF0, 0x12, 0x24, 0x48, 0x88, 0x88, 0x40, 0x21,
  0x11, 0x11, 0x12, 0x24, 0x80, 0x16, 0x8E, 0xA5, 0x00, 0x21, 0x3E, 0x42,
  0x10, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x80, 0x32,
  0x63, 0x18, 0xC6, 0x32, 0xF0, 0x2E, 0x94, 0x92, 0x40, 0x18, 0x90, 0x41,
  0x08, 0x42, 0x10, 0xF8, 0x39, 0x10, 0x41, 0x38, 0x10, 0x41, 0xF8, 0x04,
  0x31, 0x45, 0x25, 0x2F, 0xC2, 0x08, 0x1C, 0x82, 0x10, 0x78, 0x10, 0x41,
  0xF8, 0x1D, 0x84, 0x28, 0xDA, 0x28, 0xA2, 0xF0, 0xFC, 0x20, 0x84, 0x10,
  0x82, 0x10, 0x80, 0x32, 0x52, 0x97, 0x4E, 0x31, 0xF0, 0x32, 0x63, 0x18,
  0xBC, 0x22, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x94, 0x09, 0xB0, 0xC1, 0x80,
  0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0xE1, 0x11, 0x24, 0x80, 0x80, 0x3F,
  0x20, 0x67, 0xB4, 0x9A, 0x4D, 0x2A, 0x69, 0x00, 0x7C, 0x00, 0x04, 0x08,
  0x30, 0xA1, 0x27, 0xC8, 0xA1, 0x82, 0x79, 0x14, 0x61, 0x7A, 0x28, 0x62,
  0xF0, 0x1E, 0xC1, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78, 0x78, 0x89, 0x0C,
  0x18, 0x30, 0x61, 0x44, 0xF0, 0x7D, 0x04, 0x20, 0x7A, 0x08, 0x20, 0xF0,
  0x7D, 0x04, 0x20, 0xFA, 0x08, 0x20, 0x80, 0x1E, 0xC1, 0x04, 0x08, 0xD0,
  0x61, 0x42, 0x7C, 0x42, 0x85, 0x0C, 0x17, 0xD0, 0xA1, 0x42, 0x84, 0x32,
  0x22, 0x24, 0x44, 0xC0, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x38, 0x42,
  0x89, 0x65, 0x06, 0x14, 0x24, 0x48, 0x88, 0x44, 0x48, 0x88, 0x88, 0xF0,
  0x40, 0xA0, 0x90, 0xB4, 0x6A, 0x55, 0x2A, 0xA5, 0x24, 0x92, 0x00, 0x42,
  0x85, 0x8D, 0x19, 0x32, 0xA3, 0x46, 0x84, 0x3C, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC2, 0x78, 0x79, 0x14, 0x61, 0x8B, 0xC8, 0x20, 0x80, 0x3C, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC2, 0x68, 0x20, 0x20, 0x79, 0x14, 0x61, 0x8B,
  0xC9, 0x24, 0x88, 0x3D, 0x04, 0x10, 0x30, 0x20, 0x82, 0xF0, 0xFC, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x40, 0x42, 0x85, 0x0C, 0x18, 0x30, 0xA1, 0x42,
  0x78, 0x86, 0x18, 0x62, 0x91, 0x46, 0x18, 0x40, 0x84, 0x62, 0x18, 0xCA,
  0x52, 0x95, 0x29, 0x4A, 0x63, 0x18, 0x44, 0x00, 0x21, 0x12, 0x14, 0x14,
  0x08, 0x18, 0x24, 0x44, 0x84, 0x86, 0x28, 0x94, 0x61, 0x04, 0x10, 0x40,
  0x3E, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0xF8, 0x32, 0x44, 0x44, 0x48,
  0x88, 0xC0, 0xAA, 0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38,
  0x11, 0x94, 0x98, 0xC4, 0xF8, 0xC0, 0x7C, 0x63, 0x19, 0x78, 0x20, 0x85,
  0x89, 0x45, 0x14, 0x51, 0xF8, 0x7C, 0x21, 0x08, 0x78, 0x04, 0x13, 0x52,
  0x8A, 0x28, 0xA4, 0xF0, 0x7C, 0x7D, 0x08, 0x78, 0x0E, 0x10, 0x30, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x86, 0x00, 0x3D, 0x14, 0x61, 0x89, 0xE0,
  0x82, 0xF0, 0x20, 0x85, 0x89, 0x45, 0x14, 0x61, 0x88, 0x20, 0x24, 0x94,
  0x80, 0x08, 0x00, 0x21, 0x08, 0x44, 0x21, 0x09, 0x80, 0x20, 0x84, 0x52,
  0x51, 0x85, 0x24, 0x88, 0x25, 0x24, 0x94, 0x80, 0x3F, 0xA2, 0x51, 0x29,
  0x18, 0x8C, 0x44, 0x3D, 0x14, 0x51, 0x86, 0x20, 0x7C, 0x63, 0x18, 0xF8,
  0x3D, 0x14, 0x51, 0x47, 0xE8, 0x20, 0x80, 0x7C, 0x63, 0x19, 0x78, 0x42,
  0x10, 0x3A, 0x10, 0x88, 0x40, 0x7A, 0x08, 0x21, 0x78, 0x5E, 0x49, 0x26,
  0x8C, 0x63, 0x19, 0x78, 0x9C, 0xA9, 0x4C, 0x40, 0x93, 0x66, 0xD6, 0xA9,
  0x91, 0x00, 0x4C, 0xC2, 0x08, 0x52, 0x20, 0x46, 0x48, 0xA1, 0x43, 0x04,
  0x08, 0x20, 0x80, 0x78, 0x88, 0x84, 0x78, 0x19, 0x08, 0x42, 0x61, 0x08,
  0x42, 0x18, 0xFF, 0xF0, 0x20, 0x84, 0x21, 0x04, 0x44, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_ExtraLightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 4, 1, -9 },
  { 7, 8, 9, 7, 0, -9 },
  { 16, 5, 10, 7, 1, -9 },
  { 23, 8, 9, 9, 1, -9 },
  { 32, 7, 9, 8, 1, -9 },
  { 40, 1, 4, 2, 1, -9 },
  { 41, 4, 11, 3, 0, -9 },
  { 47, 4, 11, 3, -1, -9 },
  { 53, 5, 5, 6, 1, -9 },
  { 57, 5, 6, 7, 1, -7 },
  { 61, 2, 3, 2, -1, -1 },
  { 62, 3, 1, 4, 0, -4 },
  { 63, 1, 1, 3, 0, -1 },
  { 64, 6, 9, 4, -1, -9 },
  { 71, 5, 9, 7, 1, -9 },
  { 77, 3, 9, 7, 2, -9 },
  { 81, 6, 9, 7, 0, -9 },
  { 88, 6, 9, 7, 0, -9 },
  { 95, 6, 9, 7, 0, -9 },
  { 102, 6, 9, 7, 0, -9 },
  { 109, 6, 9, 7, 1, -9 },
  { 116, 6, 9, 7, 1, -9 },
  { 123, 5, 9, 7, 1, -9 },
  { 129, 5, 9, 7, 1, -9 },
  { 135, 2, 6, 3, 0, -6 },
  { 137, 3, 8, 3, -1, -6 },
  { 140, 5, 5, 7, 1, -7 },
  { 144, 5, 3, 7, 1, -6 },
  { 146, 5, 5, 7, 1, -7 },
  { 150, 4, 9, 5, 1, -9 },
  { 155, 9, 9, 10, 1, -8 },
  { 166, 7, 9, 7, -1, -9 },
  { 174, 6, 9, 7, 1, -9 },
  { 181, 7, 9, 7, 1, -9 },
  { 189, 7, 9, 8, 1, -9 },
  { 197, 6, 9, 6, 1, -9 },
  { 204, 6, 9, 6, 1, -9 },
  { 211, 7, 9, 8, 1, -9 },
  { 219, 7, 9, 8, 1, -9 },
  { 227, 4, 9, 3, 0, -9 },
  { 232, 5, 11, 3, -2, -9 },
  { 239, 7, 9, 7, 1, -9 },
  { 247, 4, 9, 6, 1, -9 },
  { 252, 9, 9, 10, 1, -9 },
  { 263, 7, 9, 8, 1, -9 },
  { 271, 7, 9, 9, 1, -9 },
  { 279, 6, 9, 7, 1, -9 },
  { 286, 7, 11, 9, 1, -9 },
  { 296, 6, 9, 7, 1, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 6, 9, 6, 1, -9 },
  { 317, 7, 9, 8, 1, -9 },
  { 325, 6, 9, 6, 1, -9 },
  { 332, 10, 9, 10, 1, -9 },
  { 344, 8, 9, 6, -1, -9 },
  { 353, 6, 9, 6, 1, -9 },
  { 360, 7, 9, 6, 0, -9 },
  { 368, 4, 11, 4, 0, -9 },
  { 374, 2, 9, 4, 1, -9 },
  { 377, 5, 11, 4, -1, -9 },
  { 384, 5, 6, 7, 1, -9 },
  { 388, 5, 1, 5, -1, 1 },
  { 389, 1, 2, 3, 2, -9 },
  { 390, 5, 6, 7, 1, -6 },
  { 394, 6, 9, 7, 0, -9 },
  { 401, 5, 6, 5, 1, -6 },
  { 405, 6, 9, 7, 1, -9 },
  { 412, 5, 6, 6, 1, -6 },
  { 416, 7, 12, 3, -2, -9 },
  { 427, 6, 9, 7, 0, -6 },
  { 434, 6, 9, 7, 0, -9 },
  { 441, 3, 9, 3, 0, -9 },
  { 445, 5, 12, 3, -2, -9 },
  { 453, 6, 9, 5, 0, -9 },
  { 460, 3, 9, 3, 0, -9 },
  { 464, 9, 6, 10, 0, -6 },
  { 471, 6, 6, 7, 0, -6 },
  { 476, 5, 6, 7, 1, -6 },
  { 480, 6, 9, 7, 0, -6 },
  { 487, 5, 9, 7, 1, -6 },
  { 493, 5, 6, 5, 0, -6 },
  { 497, 5, 6, 5, 0, -6 },
  { 501, 3, 8, 4, 1, -8 },
  { 504, 5, 6, 7, 1, -6 },
  { 508, 5, 6, 5, 1, -6 },
  { 512, 7, 6, 8, 1, -6 },
  { 518, 6, 6, 6, 0, -6 },
  { 523, 7, 9, 5, -1, -6 },
  { 531, 5, 6, 5, 0, -6 },
  { 535, 5, 11, 4, 0, -9 },
  { 542, 1, 12, 6, 3, -9 },
  { 544, 5, 11, 4, -1, -9 },
  { 551, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_ExtraLightItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRALIGHTITALIC12PT7B_H_
