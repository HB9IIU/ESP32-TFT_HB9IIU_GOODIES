#ifndef _NOTOSANS_EXTRALIGHTITALIC69PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x01, 0x80, 0x00, 0x1C, 0x07, 0x18, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x30, 0x80, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0x0C, 0x1F, 0x00, 0x3E, 0x06, 0x01, 0x80, 0x3C,
  0x03, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x00, 0x7C, 0x60, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x06, 0x7C, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x78, 0x00, 0x00, 0xC0, 0x78, 0x0C, 0x00, 0xE0, 0xF8, 0x07, 0xE0,
  0x61, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x38, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0x80,
  0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0xC0, 0x70, 0x00, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0xE0, 0x7E, 0x0C, 0x00, 0x18, 0x1C, 0x1F, 0xF8, 0xC0, 0x03, 0x81,
  0x83, 0xC3, 0xCC, 0x00, 0x38, 0x38, 0x70, 0x1E, 0xE0, 0x07, 0x07, 0x0E,
  0x00, 0xEE, 0x00, 0x60, 0xE0, 0xC0, 0x06, 0x60, 0x0E, 0x0C, 0x1C, 0x00,
  0x67, 0x01, 0xC1, 0xC1, 0x80, 0x06, 0x3C, 0xF8, 0x38, 0x38, 0x00, 0x71,
  0xFF, 0x07, 0x03, 0x00, 0x07, 0x0F, 0xC0, 0x60, 0x70, 0x00, 0x60, 0x00,
  0x0E, 0x07, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x00, 0x38,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x80,
  0x00, 0xC0, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x3F,
  0xF8, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x30, 0xF8, 0x00,
  0x00, 0x00, 0x1D, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x00,
  0x70, 0x78, 0x01, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x80, 0x0E, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x0E,
  0x1C, 0x00, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x07, 0x00,
  0x00, 0x01, 0xC7, 0x03, 0x80, 0x00, 0x00, 0xE7, 0x01, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x70, 0x07, 0x00,
  0x00, 0x0F, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x78,
  0x01, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC2,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF8, 0x01, 0x80, 0x01, 0xF0, 0x18,
  0x00, 0x03, 0xE0, 0xC0, 0x00, 0x07, 0x86, 0x00, 0x00, 0x0F, 0x30, 0x01,
  0x80, 0x1F, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0xC3,
  0x00, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C, 0x03, 0x80,
  0x03, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x33, 0xFF, 0xEF, 0x30, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x01, 0xEE, 0x00, 0xF3, 0x80, 0xF8, 0xC0, 0x78,
  0x70, 0x7C, 0x1C, 0x3C, 0x07, 0x3E, 0x01, 0xC6, 0x00, 0x61, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x03, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00,
  0x07, 0x80, 0x30, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC7,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xFF, 0xE0, 0x01, 0xC1, 0xFF, 0xF8, 0x00, 0xC3, 0xE0, 0x1F, 0x00, 0xE3,
  0x80, 0x03, 0x80, 0x73, 0x80, 0x00, 0xE0, 0x3B, 0x00, 0x00, 0x38, 0x1B,
  0x00, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x3F, 0x03, 0x80, 0x00, 0x3B, 0x80,
  0xE0, 0x00, 0x39, 0x80, 0x7C, 0x00, 0x79, 0xC0, 0x1F, 0x81, 0xF8, 0xE0,
  0x03, 0xFF, 0xF0, 0x70, 0x00, 0x7F, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x3F, 0xF7, 0xF0, 0x3C, 0x00, 0x78, 0x10, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x06, 0x0C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x71, 0xC0, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x73, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x07, 0x30, 0x00, 0x70, 0x00, 0x18, 0x00, 0x77, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x76, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x07, 0x60, 0x01, 0x80, 0x00, 0x30, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x6E, 0x00, 0x70, 0x00, 0x06, 0x00, 0x06, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0xEC, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0xC0, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0xCC, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x1C, 0xC0, 0x06, 0x00,
  0x01, 0xC0, 0x01, 0x8C, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x38, 0xC0, 0x07,
  0x00, 0x03, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x70, 0xE0,
  0x07, 0x00, 0x0C, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x01, 0xCE, 0x01, 0xC0,
  0xE0, 0x03, 0xC0, 0x78, 0xE0, 0x78, 0x06, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x70, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0E, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x01, 0xF8, 0x01, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00,
  0x18, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xC0, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x1C, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0x00,
  0x06, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x78, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x38, 0x00, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x05, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x07, 0x60, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x03, 0x18, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x71, 0x80, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0x30, 0xE0, 0x03, 0x06, 0x00, 0x00, 0x03, 0x87, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x38, 0x38, 0x01, 0xC1, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x0E,
  0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xE0,
  0x03, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x30, 0x01, 0xC0,
  0x18, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x60, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00,
  0x70, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x07, 0x70,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xF8, 0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60,
  0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x77, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x63, 0x80, 0x00, 0x01, 0xC0, 0x06, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x01, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x18, 0x01, 0x80, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x00,
  0x0C, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x03,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x01, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x60, 0x03, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0xFF, 0x00,
  0x03, 0x80, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x07, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x07, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x98, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x18,
  0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x01, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00,
  0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00,
  0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x70, 0x00, 0x30, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x00, 0x03, 0xFE, 0x01, 0x80, 0x07, 0xFF, 0xC1, 0xC0, 0x0F, 0xC1, 0xF0,
  0xC0, 0x0F, 0x00, 0x18, 0x60, 0x0F, 0x00, 0x06, 0x30, 0x0F, 0x00, 0x03,
  0xB8, 0x0F, 0x00, 0x00, 0xDC, 0x0F, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x18,
  0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3E, 0x03,
  0x80, 0x00, 0x37, 0x01, 0xC0, 0x00, 0x3B, 0x00, 0x70, 0x00, 0x39, 0x80,
  0x38, 0x00, 0x38, 0xC0, 0x0E, 0x00, 0x38, 0x60, 0x07, 0xC0, 0x78, 0x70,
  0x01, 0xFF, 0xF0, 0x30, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7F, 0x80, 0x00, 0xC0, 0xFF,
  0xF8, 0x00, 0x70, 0x7C, 0x1F, 0x00, 0x1C, 0x78, 0x01, 0xE0, 0x07, 0x38,
  0x00, 0x3C, 0x01, 0x9C, 0x00, 0x07, 0x00, 0x66, 0x00, 0x00, 0xE0, 0x3B,
  0x00, 0x00, 0x38, 0x0F, 0x80, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x01, 0x80,
  0xF0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38,
  0x0D, 0x80, 0x00, 0x1C, 0x07, 0x60, 0x00, 0x0F, 0x01, 0x8C, 0x00, 0x07,
  0x80, 0x63, 0x80, 0x07, 0xC0, 0x18, 0x78, 0x07, 0xE0, 0x0E, 0x0F, 0xFF,
  0xE0, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xE0, 0x0F, 0x80,
  0x02, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x40, 0x0F, 0x80,
  0x3C, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xC0, 0x38, 0x00, 0x0F, 0xFF, 0x81, 0xC0, 0x01, 0xF8, 0x1F, 0x0C, 0x00,
  0x1E, 0x00, 0x38, 0x60, 0x01, 0xE0, 0x00, 0x67, 0x00, 0x1E, 0x00, 0x03,
  0xB8, 0x01, 0xC0, 0x00, 0x0D, 0xC0, 0x1E, 0x00, 0x00, 0x2C, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00,
  0x07, 0x80, 0x18, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x03, 0x60, 0x07,
  0x00, 0x00, 0x37, 0x00, 0x38, 0x00, 0x03, 0xB8, 0x00, 0xE0, 0x00, 0x39,
  0x80, 0x07, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x00, 0x78, 0x60, 0x00, 0xF8,
  0x0F, 0x87, 0x00, 0x03, 0xFF, 0xF0, 0x30, 0x00, 0x07, 0xFE, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x00, 0xE0,
  0x3C, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xF0, 0x70, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x60, 0x0F, 0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x01, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x1E, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x60, 0x00, 0xFF, 0xF8,
  0x0C, 0x00, 0x7E, 0x07, 0xC3, 0x00, 0x1F, 0x00, 0x38, 0x60, 0x07, 0x80,
  0x01, 0x8C, 0x01, 0xE0, 0x00, 0x39, 0x80, 0x78, 0x00, 0x03, 0x70, 0x1E,
  0x00, 0x00, 0x6C, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00,
  0x01, 0xE0, 0x18, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0x03, 0x70, 0x0E, 0x00, 0x00, 0xEE, 0x00, 0xE0, 0x00, 0x39, 0x80,
  0x1C, 0x00, 0x0E, 0x30, 0x01, 0xC0, 0x07, 0x8E, 0x00, 0x3E, 0x03, 0xC1,
  0xC0, 0x03, 0xFF, 0xF0, 0x30, 0x00, 0x1F, 0xF8, 0x06, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x1F, 0xE0, 0x00, 0xC0, 0x7F, 0xF8, 0x01, 0xC1, 0xF0,
  0x7C, 0x01, 0xC3, 0x80, 0x1E, 0x01, 0xCF, 0x00, 0x0F, 0x01, 0x8C, 0x00,
  0x07, 0x01, 0x98, 0x00, 0x07, 0x03, 0xB0, 0x00, 0x03, 0x03, 0xE0, 0x00,
  0x03, 0x03, 0xE0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x02, 0x07, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06,
  0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x0E,
  0x77, 0x00, 0x00, 0x0C, 0xE3, 0x00, 0x00, 0x0D, 0xC3, 0x80, 0x00, 0x1F,
  0x81, 0x80, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x06, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x70, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x03, 0x8E, 0x00, 0xF0, 0x38, 0x01,
  0xC0, 0x18, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x00, 0xCE, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0x06, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xC0, 0x76, 0x00, 0x03,
  0xB8, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0x00, 0x60, 0x7F, 0xFC,
  0x00, 0x70, 0x7C, 0x3F, 0x00, 0x38, 0xF0, 0x03, 0xC0, 0x18, 0xF0, 0x00,
  0xF0, 0x0C, 0xE0, 0x00, 0x38, 0x06, 0x60, 0x00, 0x1C, 0x07, 0x60, 0x00,
  0x06, 0x03, 0xE0, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x01, 0x80, 0xF0, 0x00,
  0x00, 0xC0, 0xF0, 0x00, 0x00, 0x60, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x00, 0xC0,
  0xFF, 0xF8, 0x00, 0x0E, 0x0F, 0x83, 0xE0, 0x00, 0x70, 0xE0, 0x07, 0x80,
  0x03, 0x1C, 0x00, 0x1E, 0x00, 0x19, 0xC0, 0x00, 0x70, 0x00, 0xCC, 0x00,
  0x01, 0xC0, 0x0E, 0xC0, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x03,
  0xE0, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x1B, 0x00, 0x00, 0x38, 0x01, 0xD8, 0x00, 0x03, 0xC0, 0x0E, 0x60, 0x00,
  0x3C, 0x00, 0x73, 0x80, 0x07, 0xC0, 0x03, 0x0F, 0x00, 0xF8, 0x00, 0x38,
  0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0xC0, 0x03, 0xFF, 0xE0, 0x30, 0x03, 0xF0, 0x3E, 0x18,
  0x01, 0xF0, 0x03, 0x86, 0x00, 0xF0, 0x00, 0x31, 0x80, 0x78, 0x00, 0x0E,
  0x60, 0x3C, 0x00, 0x01, 0xB8, 0x1E, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x1E, 0x06, 0x00, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x01, 0xF0, 0x1C, 0x00, 0x00, 0xDC, 0x07, 0x00, 0x00, 0x77, 0x00, 0xE0,
  0x00, 0x39, 0x80, 0x38, 0x00, 0x1C, 0x60, 0x07, 0x00, 0x1E, 0x38, 0x01,
  0xF0, 0x1F, 0x0E, 0x00, 0x3F, 0xFF, 0x03, 0x00, 0x03, 0xFF, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x3F,
  0xC0, 0x30, 0x3F, 0xE0, 0x1C, 0x1F, 0x18, 0x07, 0x1E, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xE0, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x80, 0x00,
  0x3C, 0x18, 0x00, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x40, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0x06, 0xC0, 0xE0, 0x00, 0x0E, 0xC0, 0xE0, 0x00, 0x1D,
  0xC0, 0xE0, 0x00, 0x39, 0xC0, 0xE0, 0x00, 0x71, 0x80, 0x70, 0x00, 0xE1,
  0x80, 0x7C, 0x03, 0xC1, 0x80, 0x3F, 0xFF, 0x83, 0x80, 0x0F, 0xFE, 0x03,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x37, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x67, 0x00, 0x03, 0x0E, 0x00, 0x0E,
  0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x30,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x30, 0x01,
  0xC0, 0x60, 0x07, 0x03, 0x00, 0x18, 0x06, 0x00, 0x70, 0x38, 0x03, 0x80,
  0x60, 0x0E, 0x03, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x60, 0x38,
  0x01, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0x81, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x38, 0x00, 0x70, 0xE0, 0x01, 0x83,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x30, 0x00, 0x1C, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x04, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x3F, 0xFF,
  0x80, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x3E, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 14, 50, 15, 2, -49 },
  { 89, 16, 18, 23, 8, -49 },
  { 125, 41, 49, 43, 2, -49 },
  { 377, 33, 56, 38, 3, -52 },
  { 608, 44, 51, 53, 6, -50 },
  { 889, 41, 51, 47, 3, -50 },
  { 1151, 6, 18, 13, 8, -49 },
  { 1165, 20, 60, 17, 2, -49 },
  { 1315, 20, 60, 17, -5, -49 },
  { 1465, 29, 29, 37, 8, -52 },
  { 1571, 32, 32, 39, 5, -40 },
  { 1699, 10, 17, 14, -3, -8 },
  { 1721, 17, 3, 22, 2, -20 },
  { 1728, 5, 6, 15, 2, -5 },
  { 1732, 31, 49, 22, -3, -49 },
  { 1922, 33, 51, 38, 4, -50 },
  { 2133, 18, 49, 38, 11, -49 },
  { 2244, 34, 50, 38, 1, -50 },
  { 2457, 34, 51, 38, 2, -50 },
  { 2674, 36, 49, 38, 1, -49 },
  { 2895, 34, 50, 38, 3, -49 },
  { 3108, 33, 51, 38, 5, -50 },
  { 3319, 32, 49, 38, 7, -49 },
  { 3515, 34, 51, 38, 3, -50 },
  { 3732, 33, 51, 38, 3, -50 },
  { 3943, 11, 38, 15, 2, -37 },
  { 3996, 16, 46, 15, -3, -37 },
  { 4088, 32, 32, 39, 5, -41 },
  { 4216, 32, 17, 39, 5, -33 },
  { 4284, 32, 32, 39, 5, -41 },
  { 4412, 24, 51, 28, 6, -50 },
  { 4565, 52, 55, 58, 4, -49 },
  { 4923, 39, 49, 38, -4, -49 },
  { 5162, 37, 49, 41, 3, -49 },
  { 5389, 38, 51, 41, 6, -50 },
  { 5632, 41, 49, 47, 3, -49 },
  { 5884, 36, 49, 37, 3, -49 },
  { 6105, 36, 49, 33, 3, -49 },
  { 6326, 40, 51, 47, 6, -50 },
  { 6581, 44, 49, 47, 3, -49 },
  { 6851, 23, 49, 20, 0, -49 },
  { 6992, 29, 61, 17, -12, -49 },
  { 7214, 41, 49, 38, 3, -49 },
  { 7466, 26, 49, 34, 3, -49 },
  { 7626, 53, 49, 56, 3, -49 },
  { 7951, 44, 49, 47, 3, -49 },
  { 8221, 41, 51, 49, 6, -50 },
  { 8483, 36, 49, 39, 3, -49 },
  { 8704, 41, 62, 49, 6, -50 },
  { 9022, 36, 49, 39, 3, -49 },
  { 9243, 34, 51, 34, 1, -50 },
  { 9460, 34, 49, 34, 6, -49 },
  { 9669, 42, 50, 48, 6, -49 },
  { 9932, 36, 49, 37, 7, -49 },
  { 10153, 54, 49, 57, 8, -49 },
  { 10484, 44, 49, 34, -4, -49 },
  { 10754, 33, 49, 34, 7, -49 },
  { 10957, 40, 49, 37, -1, -49 },
  { 11202, 26, 60, 21, -1, -49 },
  { 11397, 11, 49, 22, 7, -49 },
  { 11465, 26, 60, 21, -5, -49 },
  { 11660, 32, 31, 38, 3, -50 },
  { 11784, 27, 3, 26, -6, 7 },
  { 11795, 9, 11, 16, 10, -53 },
  { 11808, 33, 38, 38, 3, -37 },
  { 11965, 34, 53, 39, 2, -52 },
  { 12191, 28, 38, 31, 4, -37 },
  { 12324, 37, 53, 39, 3, -52 },
  { 12570, 28, 38, 34, 4, -37 },
  { 12703, 38, 70, 19, -9, -53 },
  { 13036, 35, 54, 39, 2, -37 },
  { 13273, 32, 52, 39, 2, -52 },
  { 13481, 14, 50, 15, 2, -50 },
  { 13569, 26, 67, 15, -10, -50 },
  { 13787, 32, 52, 31, 2, -52 },
  { 13995, 14, 52, 15, 2, -52 },
  { 14086, 53, 37, 59, 2, -37 },
  { 14332, 33, 37, 39, 2, -37 },
  { 14485, 31, 38, 39, 4, -37 },
  { 14633, 37, 53, 39, -1, -37 },
  { 14879, 34, 53, 39, 3, -37 },
  { 15105, 26, 37, 26, 2, -37 },
  { 15226, 27, 38, 29, 1, -37 },
  { 15355, 19, 46, 22, 4, -45 },
  { 15465, 32, 38, 39, 4, -37 },
  { 15617, 29, 37, 29, 3, -37 },
  { 15752, 44, 37, 46, 4, -37 },
  { 15956, 35, 37, 32, -2, -37 },
  { 16118, 40, 54, 29, -8, -37 },
  { 16388, 31, 37, 30, -1, -37 },
  { 16532, 25, 60, 23, 2, -49 },
  { 16720, 3, 69, 37, 19, -52 },
  { 16746, 25, 60, 23, -3, -49 },
  { 16934, 32, 7, 39, 5, -28 },
};

const GFXfont NotoSans_ExtraLightItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRALIGHTITALIC69PT7B_H_
