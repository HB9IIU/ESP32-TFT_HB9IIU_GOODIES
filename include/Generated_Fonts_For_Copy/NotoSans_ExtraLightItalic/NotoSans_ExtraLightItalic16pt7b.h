#ifndef _NOTOSANS_EXTRALIGHTITALIC16PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x00, 0xC0, 0xBA, 0xAA, 0x19, 0x08, 0x84,
  0x8F, 0xF2, 0x21, 0x20, 0x91, 0xBE, 0x44, 0x24, 0x12, 0x00, 0x08, 0x3D,
  0xA2, 0x44, 0x86, 0x06, 0x0A, 0x14, 0x4B, 0xE1, 0x02, 0x00, 0x30, 0x52,
  0x24, 0x8A, 0x24, 0x8A, 0x22, 0xF9, 0x55, 0xA9, 0x12, 0x44, 0x92, 0x25,
  0x0E, 0x0C, 0x09, 0x08, 0x84, 0x42, 0x40, 0xC1, 0xA1, 0x11, 0x85, 0x41,
  0xA1, 0x8F, 0x20, 0xF0, 0x32, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88, 0x10,
  0x82, 0x10, 0x84, 0x22, 0x10, 0x88, 0x84, 0x40, 0x11, 0x21, 0x41, 0xF5,
  0x11, 0x02, 0x00, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x29, 0x40,
  0xE0, 0xC0, 0x02, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x82, 0x00,
  0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x13, 0xC0, 0x7A,
  0x22, 0x22, 0x44, 0x44, 0x80, 0x0E, 0x11, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x0C, 0x10, 0x20, 0x40, 0xFE, 0x0E, 0x31, 0x01, 0x01, 0x01, 0x02, 0x1E,
  0x02, 0x01, 0x01, 0x02, 0xFC, 0x01, 0x03, 0x05, 0x09, 0x12, 0x22, 0x42,
  0xFF, 0x04, 0x04, 0x04, 0x3F, 0x20, 0x40, 0x40, 0x78, 0x04, 0x02, 0x02,
  0x02, 0x04, 0xF8, 0x0F, 0x10, 0x20, 0x40, 0x40, 0xBC, 0xC2, 0x82, 0x82,
  0x82, 0x84, 0x78, 0xFE, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x02,
  0x00, 0x1C, 0x22, 0x41, 0x41, 0x22, 0x14, 0x28, 0xC4, 0x82, 0x82, 0x84,
  0x78, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x51, 0x9D, 0x04, 0x08, 0x27, 0x80,
  0x24, 0x00, 0x00, 0xC0, 0x11, 0x00, 0x00, 0x02, 0x44, 0x80, 0x07, 0x18,
  0x60, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x18, 0x04,
  0x03, 0x0C, 0x70, 0x80, 0x31, 0x30, 0x41, 0x04, 0x62, 0x10, 0x40, 0x00,
  0x20, 0x1F, 0xC2, 0x02, 0x40, 0x14, 0x79, 0x88, 0x99, 0x11, 0x91, 0x19,
  0x12, 0x97, 0x68, 0x88, 0x40, 0x03, 0xF8, 0x03, 0x02, 0x81, 0x41, 0x20,
  0x90, 0x88, 0x7C, 0x41, 0x40, 0xA0, 0x60, 0x20, 0x3F, 0x21, 0x41, 0x41,
  0x42, 0x7E, 0x41, 0x81, 0x81, 0x82, 0xFC, 0x07, 0x0C, 0x48, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x07, 0xC0, 0x3F, 0x10, 0x50,
  0x28, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x81, 0x41, 0x3F, 0x00, 0x3F, 0x20,
  0x40, 0x40, 0x7E, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFC, 0x3F, 0x20, 0x40,
  0x40, 0x40, 0x7C, 0x40, 0x80, 0x80, 0x80, 0x80, 0x07, 0x06, 0x32, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x7A, 0x02, 0x80, 0xA0, 0x44, 0x10, 0xFC, 0x20,
  0x48, 0x14, 0x09, 0x02, 0x40, 0x9F, 0xE4, 0x0A, 0x04, 0x81, 0x20, 0x48,
  0x10, 0x38, 0x84, 0x22, 0x10, 0x84, 0x42, 0x38, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x1C, 0x00, 0x21, 0x91, 0x11,
  0x09, 0x05, 0x03, 0x81, 0x21, 0x10, 0x84, 0x42, 0x20, 0x80, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x0F, 0xC0, 0x20, 0x32, 0x03, 0x50, 0x55,
  0x0A, 0x50, 0xA5, 0x12, 0x51, 0x28, 0xA4, 0x8A, 0x48, 0xC4, 0x88, 0x40,
  0x20, 0x4C, 0x15, 0x09, 0x22, 0x48, 0x92, 0x24, 0x4A, 0x14, 0x83, 0x20,
  0xC8, 0x10, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xA0, 0x24, 0x10, 0xF8, 0x3E, 0x21, 0x41, 0x41, 0x41, 0x7E, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xA0, 0x24, 0x10, 0xF8, 0x04, 0x01, 0x00, 0x20, 0x3E,
  0x21, 0x41, 0x41, 0x42, 0x7C, 0x48, 0x84, 0x84, 0x84, 0x82, 0x0E, 0x11,
  0x20, 0x20, 0x20, 0x10, 0x0C, 0x02, 0x02, 0x02, 0x02, 0xFC, 0xFF, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x50, 0x14,
  0x05, 0x02, 0x40, 0x90, 0x28, 0x0A, 0x02, 0x81, 0x10, 0x47, 0xE0, 0x81,
  0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0x60, 0x40, 0x40, 0x86, 0x18,
  0x61, 0x8A, 0x28, 0xA2, 0x92, 0x49, 0x24, 0xA2, 0x8A, 0x28, 0xC2, 0x8C,
  0x10, 0x81, 0x00, 0x10, 0x44, 0x20, 0x90, 0x28, 0x04, 0x01, 0x00, 0xC0,
  0x48, 0x22, 0x10, 0x48, 0x10, 0x83, 0x0A, 0x24, 0x45, 0x0C, 0x10, 0x20,
  0x40, 0x81, 0x00, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x20, 0x3F, 0x80, 0x3C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x83, 0x80, 0xAA, 0xA5, 0x54, 0x1C, 0x10, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x23, 0x80, 0x08, 0x10, 0x51, 0x22, 0x48, 0x60, 0xC1,
  0xFC, 0xD0, 0x18, 0xCD, 0x0C, 0x18, 0x30, 0xA1, 0x46, 0x74, 0x10, 0x10,
  0x20, 0x2E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0xBC, 0x1D, 0x84,
  0x20, 0x82, 0x08, 0x20, 0x78, 0x01, 0x01, 0x01, 0x19, 0x65, 0x42, 0x82,
  0x82, 0x82, 0x84, 0x8C, 0x74, 0x18, 0x94, 0x61, 0xFA, 0x08, 0x20, 0x78,
  0x07, 0x82, 0x01, 0x03, 0xC0, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x81, 0x80, 0x0C, 0x19, 0x48, 0x48, 0x24, 0x12,
  0x09, 0x08, 0x8C, 0x3A, 0x01, 0x00, 0x80, 0x8F, 0x80, 0x10, 0x10, 0x20,
  0x2E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x82, 0x11, 0x00, 0x22,
  0x44, 0x44, 0x48, 0x04, 0x10, 0x00, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x30, 0x10, 0x10, 0x20, 0x21, 0x22, 0x24, 0x48, 0x50, 0x68,
  0x48, 0x44, 0x84, 0x11, 0x22, 0x22, 0x44, 0x44, 0x48, 0x0C, 0x71, 0x94,
  0x48, 0x42, 0x42, 0x14, 0x21, 0x21, 0x09, 0x08, 0x48, 0x42, 0x82, 0x10,
  0x0E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x82, 0x1C, 0xC5, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x78, 0x0E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x41,
  0x42, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x18, 0x65, 0x42, 0x82, 0x82, 0x82,
  0x84, 0x8C, 0x74, 0x04, 0x04, 0x08, 0x08, 0x0C, 0xC2, 0x08, 0x41, 0x04,
  0x10, 0x80, 0x1D, 0x84, 0x10, 0x30, 0x20, 0x41, 0xF8, 0x24, 0xF4, 0x48,
  0x88, 0x88, 0xE0, 0x42, 0x86, 0x0C, 0x18, 0x50, 0xA3, 0x7A, 0x87, 0x0A,
  0x24, 0x89, 0x14, 0x18, 0x20, 0x88, 0x62, 0x29, 0x4A, 0x94, 0xA5, 0x31,
  0x4C, 0x62, 0x10, 0x31, 0x89, 0x03, 0x01, 0x01, 0x41, 0x20, 0x91, 0x84,
  0x10, 0xC4, 0x21, 0x10, 0x48, 0x12, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x04,
  0x02, 0x03, 0x00, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x10, 0x7C, 0x0C, 0x41,
  0x04, 0x20, 0x8C, 0x08, 0x21, 0x04, 0x10, 0x40, 0xC0, 0xFF, 0xFF, 0x18,
  0x20, 0x82, 0x08, 0x20, 0xC4, 0x10, 0x41, 0x08, 0x23, 0x00, 0xFF,
};

const GFXglyph NotoSans_ExtraLightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 2, -11 },
  { 9, 9, 11, 10, 1, -11 },
  { 22, 7, 13, 9, 1, -12 },
  { 34, 10, 12, 12, 1, -12 },
  { 49, 9, 12, 11, 1, -12 },
  { 63, 1, 4, 3, 2, -11 },
  { 64, 4, 14, 4, 1, -11 },
  { 71, 5, 14, 4, -1, -11 },
  { 80, 7, 7, 9, 2, -12 },
  { 87, 8, 7, 9, 1, -9 },
  { 94, 3, 4, 3, -1, -2 },
  { 96, 3, 1, 5, 1, -5 },
  { 97, 2, 1, 4, 0, -1 },
  { 98, 7, 11, 5, -1, -11 },
  { 108, 7, 12, 9, 1, -12 },
  { 119, 4, 11, 9, 3, -11 },
  { 125, 8, 12, 9, 0, -12 },
  { 137, 8, 12, 9, 0, -12 },
  { 149, 8, 11, 9, 0, -11 },
  { 160, 8, 11, 9, 1, -11 },
  { 171, 8, 12, 9, 1, -12 },
  { 183, 7, 11, 9, 2, -11 },
  { 193, 8, 12, 9, 1, -12 },
  { 205, 7, 12, 9, 1, -12 },
  { 216, 3, 9, 4, 0, -9 },
  { 220, 4, 11, 4, -1, -9 },
  { 226, 8, 7, 9, 1, -9 },
  { 233, 8, 4, 9, 1, -8 },
  { 237, 8, 7, 9, 1, -9 },
  { 244, 6, 12, 7, 1, -12 },
  { 253, 12, 12, 13, 1, -11 },
  { 271, 9, 11, 9, -1, -11 },
  { 284, 8, 11, 10, 1, -11 },
  { 295, 9, 12, 9, 1, -12 },
  { 309, 9, 11, 11, 1, -11 },
  { 322, 8, 11, 9, 1, -11 },
  { 333, 8, 11, 8, 1, -11 },
  { 344, 10, 12, 11, 1, -12 },
  { 359, 10, 11, 11, 1, -11 },
  { 373, 5, 11, 5, 0, -11 },
  { 380, 7, 14, 4, -3, -11 },
  { 393, 9, 11, 9, 1, -11 },
  { 406, 6, 11, 8, 1, -11 },
  { 415, 12, 11, 13, 1, -11 },
  { 432, 10, 11, 11, 1, -11 },
  { 446, 10, 12, 11, 1, -12 },
  { 461, 8, 11, 9, 1, -11 },
  { 472, 10, 15, 11, 1, -12 },
  { 491, 8, 11, 9, 1, -11 },
  { 502, 8, 12, 8, 0, -12 },
  { 514, 8, 11, 8, 1, -11 },
  { 525, 10, 11, 11, 1, -11 },
  { 539, 8, 11, 9, 2, -11 },
  { 550, 12, 11, 13, 2, -11 },
  { 567, 10, 11, 8, -1, -11 },
  { 581, 7, 11, 8, 2, -11 },
  { 591, 9, 11, 9, 0, -11 },
  { 604, 6, 14, 5, 0, -11 },
  { 615, 2, 11, 5, 2, -11 },
  { 618, 6, 14, 5, -1, -11 },
  { 629, 7, 8, 9, 1, -12 },
  { 636, 6, 1, 6, -1, 1 },
  { 637, 2, 2, 4, 2, -12 },
  { 638, 7, 9, 9, 1, -9 },
  { 646, 8, 12, 9, 0, -12 },
  { 658, 6, 9, 7, 1, -9 },
  { 665, 8, 12, 9, 1, -12 },
  { 677, 6, 9, 8, 1, -9 },
  { 684, 9, 16, 4, -2, -12 },
  { 702, 9, 13, 9, 0, -9 },
  { 717, 8, 12, 9, 0, -12 },
  { 729, 4, 12, 3, 0, -12 },
  { 735, 6, 16, 3, -2, -12 },
  { 747, 8, 12, 7, 0, -12 },
  { 759, 4, 12, 3, 0, -12 },
  { 765, 13, 9, 14, 0, -9 },
  { 780, 8, 9, 9, 0, -9 },
  { 789, 7, 9, 9, 1, -9 },
  { 797, 8, 13, 9, 0, -9 },
  { 810, 8, 13, 9, 1, -9 },
  { 823, 6, 9, 6, 0, -9 },
  { 830, 6, 9, 7, 0, -9 },
  { 837, 4, 11, 5, 1, -11 },
  { 843, 7, 8, 9, 1, -8 },
  { 850, 7, 8, 7, 1, -8 },
  { 857, 10, 8, 11, 1, -8 },
  { 867, 9, 8, 7, -1, -8 },
  { 876, 10, 12, 7, -2, -8 },
  { 891, 7, 8, 7, 0, -8 },
  { 898, 6, 14, 5, 0, -11 },
  { 909, 1, 16, 9, 4, -12 },
  { 911, 6, 14, 5, -1, -11 },
  { 922, 8, 1, 9, 1, -6 },
};

const GFXfont NotoSans_ExtraLightItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRALIGHTITALIC16PT7B_H_
