#ifndef _NOTOSANS_EXTRALIGHTITALIC43PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x80,
  0x30, 0xC8, 0x36, 0x09, 0x86, 0x61, 0x90, 0x64, 0x13, 0x04, 0xC3, 0x20,
  0xC8, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x40,
  0x00, 0x60, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x04, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x10, 0x08, 0x00,
  0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10,
  0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0x20, 0xC0,
  0x60, 0x00, 0x20, 0x18, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x06, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0x0C,
  0x30, 0x60, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x18, 0x00, 0x81,
  0x80, 0x08, 0x10, 0x00, 0xC1, 0x00, 0x06, 0x30, 0x00, 0x73, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x06, 0x70, 0x00, 0x61, 0x80,
  0x04, 0x18, 0x00, 0x40, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x08,
  0x00, 0x81, 0x80, 0x08, 0x30, 0xC0, 0x8E, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x07, 0xC0, 0x00, 0xC1, 0x8C, 0x00, 0x30, 0x60, 0xC0, 0x0C, 0x18,
  0x18, 0x03, 0x02, 0x03, 0x00, 0x40, 0xC0, 0x60, 0x18, 0x10, 0x0C, 0x06,
  0x06, 0x01, 0x81, 0x80, 0xC0, 0x30, 0x20, 0x18, 0x06, 0x0C, 0x02, 0x00,
  0x83, 0x00, 0x40, 0x10, 0xC0, 0x08, 0x06, 0x10, 0x71, 0x00, 0xC6, 0x3F,
  0xA0, 0x31, 0x8C, 0x34, 0x06, 0x23, 0x03, 0xC1, 0x8C, 0x40, 0x6C, 0x63,
  0x18, 0x0C, 0xF8, 0xC2, 0x01, 0x80, 0x10, 0xC0, 0x30, 0x06, 0x18, 0x06,
  0x01, 0x82, 0x00, 0xC0, 0x60, 0x40, 0x10, 0x08, 0x08, 0x02, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x0C, 0x06, 0x04, 0x00, 0x80, 0xC1,
  0x80, 0x18, 0x30, 0x60, 0x03, 0x0C, 0x18, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x10, 0x00, 0x40, 0x04, 0x00, 0x10, 0x01, 0x00,
  0x04, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x40, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x02, 0x0E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x47, 0x03, 0x00, 0x23,
  0x00, 0xC0, 0x19, 0x80, 0x18, 0x0C, 0x60, 0x03, 0x03, 0x30, 0x00, 0x61,
  0x8C, 0x00, 0x18, 0xC3, 0x00, 0x03, 0x30, 0xC0, 0x00, 0x78, 0x30, 0x00,
  0x1C, 0x0C, 0x00, 0x0F, 0x03, 0x00, 0x06, 0x60, 0x60, 0x03, 0x0C, 0x0E,
  0x07, 0x83, 0x01, 0xFF, 0x80, 0x60, 0x32, 0x66, 0x64, 0x4C, 0xC8, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x38, 0x10, 0x07, 0x04, 0x00, 0x71, 0x00, 0x07, 0x40,
  0xC0, 0x7F, 0xF0, 0x1C, 0x00, 0x0D, 0x00, 0x06, 0x60, 0x03, 0x08, 0x01,
  0x83, 0x01, 0xC0, 0x40, 0x20, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x0C, 0x30, 0xC6, 0x18, 0xC3, 0x08, 0x61, 0x08, 0x00, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1E, 0x38, 0x03, 0x80, 0xC0,
  0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x18, 0x00, 0x31, 0x00, 0x03,
  0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x34, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xC8, 0x00, 0x0C, 0x80,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x06,
  0x00, 0xE0, 0x60, 0x1C, 0x03, 0x83, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x60,
  0x3C, 0x0D, 0x07, 0x61, 0xCC, 0xE1, 0xB8, 0x34, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xF3, 0xC0, 0x1C,
  0x01, 0x80, 0x60, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xE7,
  0x80, 0x38, 0x03, 0x01, 0x80, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x80, 0x03, 0x83, 0xC0, 0x78, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0, 0x00,
  0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x61,
  0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x40, 0x06, 0x01, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x02, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x08, 0x00, 0x60, 0x78, 0x1E, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0xE3, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0xFC, 0x06, 0x3F, 0xF0, 0x6E, 0x03, 0x85, 0x80,
  0x18, 0x70, 0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0x40, 0x03, 0x06, 0x00, 0x70, 0x30, 0x0E, 0x03, 0x83, 0xC0,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x9F, 0x00, 0x60,
  0x1C, 0x06, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x80, 0x03, 0x04, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x01,
  0xC0, 0x18, 0x18, 0x00, 0x63, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0x8E, 0x00, 0xE0, 0x18, 0x0E, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x60, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00,
  0x06, 0x30, 0x00, 0x30, 0xC0, 0x03, 0x07, 0x00, 0x30, 0x1E, 0x0F, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1E, 0x3C, 0x03, 0x80, 0xE0, 0x60,
  0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x11, 0x80, 0x01, 0x10,
  0x00, 0x13, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x30, 0x00, 0x33,
  0x00, 0x03, 0x10, 0x00, 0x71, 0x80, 0x0F, 0x0C, 0x03, 0xA0, 0xF0, 0xE6,
  0x03, 0xFC, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x0C, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x0C, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x1C, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x7C, 0xF0,
  0x80, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x7C, 0x01, 0x0C, 0x01, 0xFF, 0x80,
  0xCC, 0x01, 0x80, 0x40, 0x66, 0x01, 0x80, 0x60, 0x32, 0x01, 0x80, 0x30,
  0x1B, 0x01, 0x80, 0x10, 0x0D, 0x80, 0x80, 0x18, 0x06, 0x80, 0xC0, 0x0C,
  0x03, 0x40, 0x60, 0x04, 0x01, 0x60, 0x20, 0x02, 0x01, 0xB0, 0x10, 0x03,
  0x00, 0xD8, 0x18, 0x01, 0x80, 0x4C, 0x0C, 0x01, 0xC0, 0x66, 0x02, 0x00,
  0xE0, 0x61, 0x01, 0x80, 0xB0, 0x30, 0x80, 0xE1, 0x8C, 0x70, 0x60, 0x3F,
  0x87, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x10, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x08, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x0C, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x06, 0x00,
  0x04, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0C, 0x00, 0xF0, 0x18, 0x00,
  0x60, 0x20, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x03, 0x81, 0x80, 0x1E, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x18,
  0x00, 0xE0, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00,
  0x10, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x07, 0x04, 0x00, 0x3C,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFC,
  0xFC, 0x07, 0x80, 0x08, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x1E, 0x00, 0x60,
  0x03, 0x80, 0x20, 0x00, 0x60, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x40, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x0C, 0x00, 0x3C, 0x04, 0x00, 0x78, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x3F,
  0xC0, 0x78, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x07, 0xFE, 0x40,
  0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x06, 0x00, 0x02, 0x01, 0x80, 0x03,
  0x00, 0x78, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0x20, 0x00, 0x04,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x10, 0x00, 0x02, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x08, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x04, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x03, 0x80, 0x20,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x02, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x87, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x47, 0x00, 0x00, 0x27, 0x80, 0x00, 0x36, 0x60, 0x00,
  0x1E, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x58, 0x00, 0x01, 0xA0, 0x2C, 0x00, 0x00, 0xB0, 0x36, 0x00,
  0x00, 0xD8, 0x1B, 0x00, 0x00, 0xCC, 0x0C, 0x80, 0x00, 0x64, 0x04, 0x40,
  0x00, 0x66, 0x02, 0x20, 0x00, 0x33, 0x03, 0x18, 0x00, 0x31, 0x81, 0x8C,
  0x00, 0x10, 0x80, 0xC6, 0x00, 0x18, 0x40, 0x41, 0x00, 0x18, 0x60, 0x20,
  0x80, 0x0C, 0x30, 0x30, 0x40, 0x0C, 0x18, 0x18, 0x30, 0x04, 0x08, 0x0C,
  0x18, 0x06, 0x04, 0x04, 0x0C, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03,
  0x01, 0x03, 0x01, 0x81, 0x80, 0x81, 0x00, 0x80, 0xC0, 0x61, 0x80, 0xC0,
  0x40, 0x30, 0x80, 0x60, 0x60, 0x18, 0xC0, 0x30, 0x30, 0x04, 0xC0, 0x18,
  0x18, 0x02, 0x60, 0x08, 0x08, 0x01, 0x60, 0x0C, 0x04, 0x00, 0xE0, 0x06,
  0x06, 0x00, 0x70, 0x03, 0x03, 0x00, 0x30, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0x40, 0x00, 0x20, 0x2C,
  0x00, 0x04, 0x0D, 0x80, 0x01, 0x81, 0x98, 0x00, 0x30, 0x33, 0x00, 0x06,
  0x04, 0x20, 0x00, 0x80, 0x86, 0x00, 0x10, 0x30, 0x40, 0x06, 0x06, 0x0C,
  0x00, 0xC0, 0xC1, 0x80, 0x18, 0x10, 0x18, 0x02, 0x02, 0x03, 0x00, 0xC0,
  0xC0, 0x20, 0x18, 0x18, 0x06, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x40, 0x0C,
  0x08, 0x18, 0x01, 0x83, 0x03, 0x00, 0x10, 0x60, 0x60, 0x03, 0x0C, 0x0C,
  0x00, 0x21, 0x01, 0x00, 0x06, 0x20, 0x60, 0x00, 0xCC, 0x0C, 0x00, 0x0D,
  0x81, 0x80, 0x01, 0xB0, 0x20, 0x00, 0x14, 0x04, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x18, 0x60, 0x00, 0x04, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x68, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x30, 0x07, 0x00, 0xC0, 0x06, 0x02, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x03,
  0x06, 0x00, 0x38, 0x18, 0x1F, 0x80, 0x7F, 0xF8, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x0E,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x30, 0x07, 0x00, 0xC0, 0x06, 0x02, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x80,
  0x06, 0x06, 0x00, 0xF0, 0x1F, 0xFF, 0x00, 0x60, 0x30, 0x01, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x08,
  0x00, 0xC0, 0x60, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x20, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xDF, 0xC0, 0xE0, 0x06, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x08,
  0x00, 0x70, 0x78, 0x1E, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x04, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x08, 0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0x70, 0x01, 0x80, 0x0F, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0x06, 0x80, 0x00, 0x19, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00,
  0xC0, 0x40, 0x01, 0x80, 0x80, 0x06, 0x01, 0x00, 0x08, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x20, 0x30, 0x00, 0x40, 0x60, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x13,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x58, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x6C, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x05, 0x00, 0x04, 0xC0, 0x03,
  0x40, 0x03, 0x30, 0x00, 0x90, 0x00, 0x8C, 0x00, 0x64, 0x00, 0x61, 0x00,
  0x11, 0x00, 0x18, 0x40, 0x0C, 0x40, 0x0C, 0x10, 0x02, 0x10, 0x03, 0x04,
  0x01, 0x86, 0x01, 0x81, 0x00, 0x61, 0x80, 0x60, 0x40, 0x30, 0x60, 0x30,
  0x10, 0x0C, 0x18, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x01, 0x81, 0x81, 0x81,
  0x80, 0x60, 0xC0, 0x60, 0x40, 0x18, 0x30, 0x18, 0x30, 0x06, 0x18, 0x06,
  0x08, 0x01, 0x86, 0x00, 0x86, 0x00, 0x61, 0x00, 0x21, 0x80, 0x18, 0xC0,
  0x08, 0xC0, 0x06, 0x20, 0x02, 0x30, 0x01, 0x98, 0x00, 0x88, 0x00, 0x64,
  0x00, 0x26, 0x00, 0x1B, 0x00, 0x09, 0x00, 0x06, 0x80, 0x02, 0xC0, 0x01,
  0xE0, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x00, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x80, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0x90,
  0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x60, 0x30, 0x06, 0x00, 0x80, 0x20, 0x06, 0x03, 0x00, 0x30,
  0x30, 0x00, 0x83, 0x00, 0x06, 0x18, 0x00, 0x31, 0x80, 0x00, 0x98, 0x00,
  0x06, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x81, 0x02,
  0x06, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x08, 0x18,
  0x30, 0x60, 0x40, 0x81, 0x83, 0x06, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0,
  0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x08,
  0x10, 0x01, 0x81, 0x80, 0x30, 0x18, 0x03, 0x00, 0x80, 0x60, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x04, 0x18, 0x00, 0x43, 0x00, 0x06, 0x30, 0x00, 0x26,
  0x00, 0x02, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0x80, 0xC1, 0x86, 0x0C, 0x10,
  0x60, 0xC0, 0x00, 0xFE, 0x10, 0x3C, 0x71, 0x07, 0x01, 0xB0, 0xC0, 0x0B,
  0x18, 0x00, 0xA1, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x04, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0,
  0x05, 0x06, 0x00, 0xD0, 0x60, 0x19, 0x03, 0x86, 0x30, 0x1F, 0xC3, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x87, 0xF0, 0x0C, 0xF3, 0xC0, 0x4C, 0x03, 0x06, 0xC0,
  0x18, 0x3C, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x46,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00,
  0x66, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x18, 0xE0,
  0x00, 0xC7, 0x00, 0x0C, 0x3C, 0x00, 0xC1, 0x30, 0x0E, 0x08, 0xC1, 0xC0,
  0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xF8, 0xF0, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x03, 0xF8, 0x60, 0x1E, 0x38, 0xC0, 0x70, 0x09, 0x01, 0x80, 0x1A, 0x06,
  0x00, 0x14, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x00, 0x41, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x10, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x07,
  0x06, 0x00, 0x1C, 0x0C, 0x00, 0x68, 0x0C, 0x01, 0xB0, 0x18, 0x06, 0x60,
  0x1C, 0x38, 0x80, 0x1F, 0xC1, 0x00, 0x00, 0xFC, 0x01, 0xE7, 0x83, 0x80,
  0xC3, 0x80, 0x31, 0x80, 0x19, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x40,
  0x07, 0x60, 0x0E, 0x30, 0x7E, 0x1F, 0xF8, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x41, 0xC0, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x8E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x04, 0x07, 0x8E, 0x30, 0x38, 0x04,
  0xC1, 0x80, 0x1A, 0x0C, 0x00, 0x28, 0x30, 0x00, 0xE1, 0x80, 0x03, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x21, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x38,
  0x60, 0x00, 0xE1, 0x80, 0x07, 0x06, 0x00, 0x34, 0x0C, 0x01, 0xB0, 0x30,
  0x0C, 0xC0, 0x70, 0xE2, 0x00, 0xFE, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x08, 0x00, 0xC0, 0x3C, 0x1E, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x1F, 0xC0, 0x63, 0x8E, 0x04, 0xC0, 0x30, 0xD8, 0x03, 0x0F, 0x00,
  0x10, 0xE0, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x23, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x46, 0x00, 0x04, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x08, 0xC0, 0x01, 0x80, 0x03, 0x81,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x8C, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x60,
  0x0E, 0x04, 0x01, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x08,
  0x18, 0x00, 0x83, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x19, 0xC0, 0x01,
  0x3C, 0x00, 0x16, 0x60, 0x03, 0xC6, 0x00, 0x38, 0x30, 0x03, 0x03, 0x00,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x06,
  0x04, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x00, 0x06, 0x1F, 0x80, 0xFE,
  0x02, 0x38, 0xE0, 0xE7, 0x81, 0x30, 0x30, 0xC0, 0xC1, 0xB0, 0x0C, 0x80,
  0x30, 0xF0, 0x06, 0x80, 0x18, 0x70, 0x03, 0xC0, 0x0C, 0x30, 0x01, 0xC0,
  0x06, 0x18, 0x00, 0xE0, 0x03, 0x18, 0x00, 0x60, 0x01, 0x8C, 0x00, 0x30,
  0x00, 0x86, 0x00, 0x10, 0x00, 0xC2, 0x00, 0x08, 0x00, 0x61, 0x00, 0x0C,
  0x00, 0x31, 0x80, 0x06, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x08, 0x60, 0x01,
  0x00, 0x0C, 0x20, 0x01, 0x80, 0x06, 0x30, 0x00, 0xC0, 0x03, 0x18, 0x00,
  0x60, 0x01, 0x0C, 0x00, 0x20, 0x00, 0x86, 0x00, 0x10, 0x00, 0xC2, 0x00,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x30, 0x06, 0x1F, 0xC0, 0x23, 0xC7,
  0x01, 0x30, 0x0C, 0x1B, 0x00, 0x60, 0xF0, 0x01, 0x07, 0x00, 0x0C, 0x30,
  0x00, 0x41, 0x80, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x20, 0x00, 0x43, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x20, 0x00, 0x43, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x3C,
  0x78, 0x07, 0x00, 0xC0, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x03, 0x30,
  0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x34,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x44, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x30, 0x30, 0x07,
  0x01, 0xC1, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0x87, 0xF0, 0x02, 0x3C, 0xF0,
  0x04, 0xC0, 0x30, 0x1B, 0x00, 0x60, 0x3C, 0x00, 0x60, 0x70, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0x83, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00,
  0xC0, 0xF0, 0x03, 0x01, 0xB0, 0x0E, 0x02, 0x30, 0x70, 0x0C, 0x3F, 0xC0,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x08, 0x1E, 0x38, 0xC1, 0xC0,
  0x26, 0x18, 0x01, 0xA1, 0x80, 0x05, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x10, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0,
  0x01, 0xC6, 0x00, 0x1C, 0x30, 0x01, 0xA0, 0xC0, 0x1B, 0x06, 0x01, 0x98,
  0x1C, 0x38, 0x80, 0x7F, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x06, 0x1F, 0x04, 0x79,
  0x04, 0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xC3, 0xC3, 0x80,
  0x21, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC8, 0x00, 0xC7, 0x81, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x07, 0xFF, 0xFF, 0xF0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x61, 0x07,
  0xF0, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x20, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C,
  0x40, 0x00, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x07,
  0x84, 0x00, 0xD0, 0x60, 0x19, 0x07, 0x07, 0x10, 0x3F, 0xC3, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03, 0x18, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x30, 0x60, 0x08, 0x08, 0x06, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x11,
  0x80, 0x04, 0x40, 0x01, 0x30, 0x00, 0x48, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x02, 0xC0, 0x0E,
  0x00, 0x64, 0x00, 0xA0, 0x04, 0x40, 0x1A, 0x00, 0xC4, 0x01, 0x20, 0x08,
  0x40, 0x32, 0x01, 0x84, 0x02, 0x30, 0x18, 0x40, 0x63, 0x03, 0x04, 0x04,
  0x30, 0x30, 0x60, 0xC3, 0x06, 0x06, 0x08, 0x30, 0x60, 0x61, 0x81, 0x0C,
  0x06, 0x10, 0x10, 0xC0, 0x63, 0x01, 0x08, 0x06, 0x20, 0x11, 0x80, 0x66,
  0x01, 0x10, 0x06, 0x40, 0x1B, 0x00, 0x6C, 0x01, 0xA0, 0x06, 0x80, 0x1E,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x31, 0x80, 0x00, 0xCC,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x60, 0x00, 0x19, 0x80, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x06,
  0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x20,
  0x00, 0xC0, 0x10, 0x00, 0x40, 0x08, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x40, 0x18, 0x00, 0x20, 0x18, 0x00,
  0x10, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x43, 0x00, 0x00, 0x23, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x3E, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x03, 0xE0,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x60, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x16, 0x0E,
  0x03, 0x80, 0x3F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraLightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 31, 9, 1, -31 },
  { 36, 10, 11, 14, 5, -31 },
  { 50, 26, 31, 27, 1, -31 },
  { 151, 20, 36, 24, 2, -33 },
  { 241, 27, 32, 33, 4, -31 },
  { 349, 26, 31, 29, 2, -31 },
  { 450, 4, 11, 8, 5, -31 },
  { 456, 13, 38, 11, 1, -31 },
  { 518, 13, 38, 11, -3, -31 },
  { 580, 18, 19, 23, 5, -33 },
  { 623, 20, 20, 25, 3, -25 },
  { 673, 6, 11, 9, -2, -5 },
  { 682, 10, 1, 13, 2, -12 },
  { 684, 3, 3, 9, 1, -3 },
  { 686, 19, 31, 14, -2, -31 },
  { 760, 20, 31, 24, 3, -31 },
  { 838, 11, 31, 24, 7, -31 },
  { 881, 22, 31, 24, 0, -31 },
  { 967, 22, 31, 24, 1, -31 },
  { 1053, 22, 31, 24, 1, -31 },
  { 1139, 21, 31, 24, 2, -31 },
  { 1221, 20, 31, 24, 3, -31 },
  { 1299, 19, 31, 24, 5, -31 },
  { 1373, 21, 31, 24, 2, -31 },
  { 1455, 20, 31, 24, 2, -31 },
  { 1533, 7, 23, 9, 1, -23 },
  { 1554, 10, 29, 9, -2, -23 },
  { 1591, 20, 19, 25, 3, -25 },
  { 1639, 20, 10, 25, 3, -20 },
  { 1664, 20, 19, 25, 3, -25 },
  { 1712, 15, 31, 18, 3, -31 },
  { 1771, 33, 34, 36, 2, -30 },
  { 1912, 24, 31, 24, -2, -31 },
  { 2005, 23, 31, 26, 2, -31 },
  { 2095, 23, 31, 26, 4, -31 },
  { 2185, 25, 31, 29, 2, -31 },
  { 2282, 22, 31, 23, 2, -31 },
  { 2368, 22, 31, 21, 2, -31 },
  { 2454, 25, 31, 30, 4, -31 },
  { 2551, 27, 31, 29, 2, -31 },
  { 2656, 14, 31, 12, 0, -31 },
  { 2711, 17, 39, 10, -7, -31 },
  { 2794, 25, 31, 24, 2, -31 },
  { 2891, 16, 31, 21, 2, -31 },
  { 2953, 33, 31, 35, 2, -31 },
  { 3081, 27, 31, 29, 2, -31 },
  { 3186, 25, 31, 31, 4, -31 },
  { 3283, 22, 31, 24, 2, -31 },
  { 3369, 25, 38, 31, 4, -31 },
  { 3488, 22, 31, 24, 2, -31 },
  { 3574, 21, 31, 21, 1, -31 },
  { 3656, 21, 31, 21, 4, -31 },
  { 3738, 26, 31, 30, 4, -31 },
  { 3839, 23, 31, 23, 4, -31 },
  { 3929, 34, 31, 36, 5, -31 },
  { 4061, 28, 31, 21, -3, -31 },
  { 4170, 21, 31, 21, 4, -31 },
  { 4252, 25, 31, 23, 0, -31 },
  { 4349, 16, 38, 13, 0, -31 },
  { 4425, 7, 31, 14, 4, -31 },
  { 4453, 16, 38, 13, -3, -31 },
  { 4529, 20, 19, 24, 2, -31 },
  { 4577, 17, 1, 16, -4, 5 },
  { 4580, 6, 7, 10, 6, -33 },
  { 4586, 20, 23, 24, 2, -23 },
  { 4644, 21, 33, 25, 1, -33 },
  { 4731, 18, 23, 19, 2, -23 },
  { 4783, 23, 33, 25, 2, -33 },
  { 4878, 17, 23, 21, 3, -23 },
  { 4927, 24, 43, 12, -6, -33 },
  { 5056, 22, 33, 25, 1, -23 },
  { 5147, 20, 33, 24, 1, -33 },
  { 5230, 9, 31, 9, 1, -31 },
  { 5265, 16, 41, 9, -6, -31 },
  { 5347, 20, 33, 19, 1, -33 },
  { 5430, 9, 33, 9, 1, -33 },
  { 5468, 33, 23, 37, 1, -23 },
  { 5563, 21, 23, 24, 1, -23 },
  { 5624, 20, 23, 24, 2, -23 },
  { 5682, 23, 33, 25, -1, -23 },
  { 5777, 21, 33, 25, 2, -23 },
  { 5864, 16, 23, 16, 1, -23 },
  { 5910, 17, 23, 18, 0, -23 },
  { 5959, 12, 28, 14, 2, -28 },
  { 6001, 20, 23, 24, 2, -23 },
  { 6059, 18, 23, 18, 2, -23 },
  { 6111, 28, 23, 29, 2, -23 },
  { 6192, 22, 23, 20, -1, -23 },
  { 6256, 25, 33, 18, -5, -23 },
  { 6360, 20, 23, 19, -1, -23 },
  { 6418, 16, 38, 14, 1, -31 },
  { 6494, 1, 43, 23, 12, -33 },
  { 6500, 15, 38, 14, -2, -31 },
  { 6572, 20, 4, 25, 3, -17 },
};

const GFXfont NotoSans_ExtraLightItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRALIGHTITALIC43PT7B_H_
