#ifndef _NOTOSANS_EXTRALIGHTITALIC25PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x20, 0x00, 0x84,
  0x00, 0x4D, 0x28, 0xA2, 0x8A, 0x49, 0x00, 0x01, 0x08, 0x04, 0x10, 0x08,
  0x40, 0x10, 0x80, 0x41, 0x00, 0x84, 0x1F, 0xFF, 0x82, 0x10, 0x08, 0x20,
  0x10, 0x80, 0x21, 0x00, 0x82, 0x0F, 0xFB, 0x82, 0x10, 0x04, 0x20, 0x10,
  0x40, 0x21, 0x00, 0x42, 0x00, 0x00, 0x80, 0x08, 0x07, 0xE0, 0x91, 0x11,
  0x02, 0x10, 0x21, 0x03, 0x20, 0x12, 0x00, 0xE0, 0x03, 0x80, 0x4C, 0x04,
  0x40, 0x44, 0x04, 0x40, 0x44, 0xC9, 0x83, 0xE0, 0x08, 0x00, 0x80, 0x1C,
  0x02, 0x22, 0x04, 0x42, 0x08, 0x42, 0x08, 0x82, 0x10, 0x82, 0x20, 0x82,
  0x40, 0x82, 0x4E, 0x84, 0x91, 0x8D, 0x21, 0x79, 0x41, 0x02, 0x41, 0x04,
  0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x42, 0x20, 0x44, 0x40, 0x78, 0x03,
  0xE0, 0x08, 0x60, 0x20, 0x40, 0x40, 0x80, 0x81, 0x01, 0x04, 0x01, 0x10,
  0x02, 0xC0, 0x06, 0x00, 0x32, 0x00, 0x84, 0x0A, 0x04, 0x28, 0x04, 0xD0,
  0x09, 0x20, 0x0C, 0x40, 0x18, 0x40, 0xC8, 0x7E, 0x18, 0x5A, 0xA8, 0x02,
  0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x00, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x30, 0x20, 0xC0, 0x02, 0x00, 0x82, 0x10, 0x62, 0x03, 0x42,
  0x1F, 0x85, 0x01, 0x20, 0x42, 0x08, 0x40, 0x04, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x32, 0x24, 0x48, 0xFC, 0xC0, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10, 0x00, 0x07, 0x83, 0x08, 0xC0,
  0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x28, 0x05, 0x00, 0xA0, 0x24, 0x0C, 0xC3, 0x0F, 0xC0, 0x04, 0x72, 0x71,
  0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x80, 0x03,
  0xE0, 0x60, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x07, 0xFF, 0x00, 0x07, 0xC3, 0x82, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x0F, 0x81, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x80, 0x8F, 0xF0, 0x00, 0x18, 0x01, 0x40,
  0x1C, 0x00, 0xA0, 0x09, 0x00, 0x88, 0x08, 0x80, 0x84, 0x08, 0x20, 0x81,
  0x08, 0x08, 0xC0, 0x8F, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x0F, 0xF0, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0xF0, 0x30, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x80, 0x8F, 0xF0, 0x03, 0xF0, 0xC0, 0x18, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x05, 0xF0, 0xA0, 0x8C, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x48, 0x08, 0x41, 0x03, 0xE0, 0xFF, 0xE0, 0x0C, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x00, 0x07, 0xC0, 0x83,
  0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x18, 0x20, 0xCC, 0x03, 0x01, 0xD8,
  0x20, 0x44, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x40, 0xC3, 0xF0,
  0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01,
  0x20, 0x32, 0x06, 0x1F, 0xA0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x0F, 0xC0, 0x32, 0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x0C, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x21, 0x04, 0x20, 0x00, 0x20,
  0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x80, 0x40, 0x00, 0x3E, 0x20, 0x80, 0x60, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x0C, 0x08, 0x08, 0x04, 0x04, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x60, 0x18, 0x02, 0x04, 0x00, 0x21,
  0x00, 0x02, 0x40, 0x70, 0x48, 0x31, 0x0A, 0x08, 0x21, 0x42, 0x04, 0x28,
  0x41, 0x06, 0x10, 0x20, 0xC2, 0x04, 0x18, 0x41, 0x85, 0x08, 0x51, 0x90,
  0xF3, 0xC2, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x28, 0x01, 0x90, 0x04,
  0x40, 0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x40, 0x81, 0x07, 0xFA, 0x10,
  0x08, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x0A, 0x00, 0x30, 0x0F, 0xE0,
  0x20, 0x61, 0x80, 0x84, 0x03, 0x10, 0x0C, 0x40, 0x21, 0x00, 0x88, 0x0C,
  0x3F, 0xC0, 0x81, 0x82, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01,
  0x10, 0x08, 0x40, 0x43, 0xFC, 0x00, 0x03, 0xF8, 0x10, 0x11, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x10, 0x60, 0x60, 0x30, 0x80, 0x21, 0x00, 0x62,
  0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00,
  0x24, 0x00, 0x48, 0x01, 0x10, 0x04, 0x20, 0x18, 0x40, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x3F, 0xE1, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0xFF, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x03, 0xF8, 0x08, 0x0C, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x01, 0xFA, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x10, 0x04, 0x20, 0x08, 0x20, 0x10, 0x3F, 0xC0, 0x08, 0x01,
  0x08, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x20, 0x04, 0x3F, 0xFC, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0x80, 0x10, 0x0F, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0xF8, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x3E, 0x00, 0x08, 0x06, 0x10, 0x10,
  0x40, 0x40, 0x81, 0x01, 0x04, 0x02, 0x10, 0x04, 0xC0, 0x13, 0x00, 0x2A,
  0x00, 0x64, 0x00, 0x84, 0x01, 0x08, 0x04, 0x08, 0x08, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x40, 0x61, 0x00, 0x40, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x7F, 0xC0, 0x08, 0x00, 0x61, 0x80, 0x0C, 0x50, 0x02, 0x8A, 0x00,
  0x51, 0x40, 0x14, 0x28, 0x02, 0x85, 0x00, 0x91, 0x10, 0x22, 0x22, 0x04,
  0x84, 0x41, 0x10, 0x88, 0x22, 0x11, 0x08, 0x44, 0x22, 0x08, 0x82, 0x42,
  0x10, 0x50, 0x42, 0x0A, 0x08, 0x81, 0x81, 0x10, 0x30, 0x60, 0x08, 0x01,
  0x08, 0x01, 0x14, 0x02, 0x14, 0x02, 0x12, 0x02, 0x12, 0x02, 0x12, 0x02,
  0x21, 0x04, 0x21, 0x04, 0x20, 0x84, 0x20, 0x84, 0x20, 0x44, 0x40, 0x48,
  0x40, 0x48, 0x40, 0x28, 0x40, 0x28, 0x40, 0x18, 0x80, 0x10, 0x03, 0xF0,
  0x18, 0x10, 0x40, 0x11, 0x00, 0x22, 0x00, 0x28, 0x00, 0x50, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x50, 0x01,
  0x90, 0x02, 0x20, 0x08, 0x20, 0x20, 0x3F, 0x80, 0x0F, 0xC0, 0x41, 0x86,
  0x06, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x02, 0x20, 0x31, 0x0E,
  0x0F, 0x80, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x00, 0x03, 0xF0, 0x18, 0x10, 0x40, 0x11, 0x00, 0x22, 0x00, 0x28,
  0x00, 0x50, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x28, 0x00, 0x50, 0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x20, 0x3F, 0x80,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x41, 0x86,
  0x06, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x02, 0x20, 0x21, 0xFE,
  0x08, 0x40, 0x41, 0x04, 0x08, 0x20, 0x41, 0x01, 0x08, 0x08, 0x40, 0x44,
  0x01, 0x00, 0x03, 0xF0, 0x60, 0x46, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x80, 0xC3, 0xF8, 0x00, 0xFF, 0xF0, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x10,
  0x02, 0x60, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90,
  0x02, 0x20, 0x04, 0x20, 0x10, 0x60, 0x40, 0x7F, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x10, 0x41, 0x04, 0x20,
  0x42, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x05, 0x00, 0x30, 0x02, 0x00,
  0x80, 0x40, 0x38, 0x04, 0x02, 0x80, 0xA0, 0x48, 0x0A, 0x04, 0x81, 0x20,
  0x48, 0x12, 0x08, 0x82, 0x20, 0x88, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x20, 0x88, 0x22, 0x04, 0x82, 0x40, 0x50, 0x24, 0x05, 0x02, 0x80, 0x60,
  0x28, 0x06, 0x02, 0x80, 0x60, 0x30, 0x04, 0x03, 0x00, 0x08, 0x02, 0x10,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x21, 0x00, 0x44, 0x00, 0x90, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x84, 0x02, 0x08, 0x0C,
  0x08, 0x10, 0x10, 0x40, 0x21, 0x00, 0x20, 0x80, 0x1A, 0x01, 0x90, 0x08,
  0x80, 0x82, 0x08, 0x10, 0x40, 0x84, 0x02, 0x40, 0x16, 0x00, 0xA0, 0x06,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x0F, 0x84, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x07, 0xC0, 0x82, 0x10,
  0x84, 0x20, 0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0xC0, 0x07, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x3E, 0x00, 0x01, 0x00, 0x38, 0x02, 0x80, 0x48, 0x04, 0x40, 0x84, 0x10,
  0x41, 0x02, 0x20, 0x24, 0x02, 0xC0, 0x10, 0xFF, 0x80, 0x91, 0x10, 0x03,
  0x00, 0xC9, 0x10, 0x52, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80,
  0x48, 0x04, 0x80, 0xCC, 0x14, 0x43, 0x43, 0xC8, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x10, 0x26, 0xE2, 0x82, 0x30, 0x12, 0x01, 0x20,
  0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x4A, 0x08, 0x9F,
  0x00, 0x01, 0x03, 0xB1, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x60, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x04, 0x40, 0xED, 0x04, 0x0C, 0x20, 0x31, 0x00,
  0xC4, 0x02, 0x10, 0x08, 0x80, 0x22, 0x00, 0x88, 0x06, 0x20, 0x10, 0xC0,
  0xC1, 0x05, 0x03, 0xE4, 0x00, 0x01, 0x01, 0xD8, 0x41, 0x10, 0x16, 0x04,
  0x81, 0x90, 0xE3, 0xE0, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x7F,
  0x00, 0x00, 0x78, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F,
  0x80, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xED, 0x10, 0x32, 0x03,
  0x40, 0x34, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x4C, 0x0C,
  0x41, 0x43, 0xE4, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x83, 0x0F, 0xC0,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x23, 0x09, 0x99, 0x41, 0x30,
  0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x80, 0x50,
  0x0A, 0x03, 0x00, 0x18, 0x80, 0x01, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21,
  0x10, 0x84, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0xC1, 0xC0, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x19, 0x04, 0x21, 0x04, 0x40, 0x90, 0x24, 0x05, 0x40,
  0xC8, 0x10, 0x84, 0x10, 0x81, 0x10, 0x22, 0x02, 0x00, 0x08, 0x84, 0x21,
  0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x20, 0x01, 0x01, 0x04,
  0xD8, 0xD8, 0xA1, 0x21, 0x98, 0x18, 0x12, 0x02, 0x02, 0x40, 0x40, 0x50,
  0x10, 0x12, 0x02, 0x02, 0x40, 0x40, 0x48, 0x08, 0x09, 0x02, 0x01, 0x40,
  0x40, 0x48, 0x08, 0x09, 0x01, 0x01, 0x00, 0x01, 0x82, 0x66, 0x28, 0x23,
  0x03, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0xC0, 0x48,
  0x04, 0x80, 0x48, 0x0C, 0x0F, 0xC1, 0x02, 0x20, 0x24, 0x01, 0x40, 0x14,
  0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x40, 0x46, 0x08, 0x3F, 0x00,
  0x13, 0xF0, 0xA0, 0x86, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x24,
  0x02, 0x20, 0x11, 0x00, 0x98, 0x08, 0xA0, 0x84, 0xF8, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x01, 0x00, 0xED, 0x10, 0x32,
  0x03, 0x40, 0x34, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x4C,
  0x0C, 0x41, 0x43, 0xE4, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x27, 0x94, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x02, 0x07, 0x72, 0x00, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x60, 0x08, 0x02, 0x81, 0x1F, 0x80, 0x10, 0x20,
  0x47, 0xF2, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x3C,
  0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04,
  0x40, 0x48, 0x0C, 0x80, 0xC4, 0x34, 0x7C, 0x80, 0x80, 0x70, 0x09, 0x02,
  0x20, 0x44, 0x10, 0x84, 0x10, 0x82, 0x20, 0x44, 0x05, 0x00, 0xA0, 0x18,
  0x03, 0x00, 0x80, 0x81, 0x81, 0x81, 0x82, 0x82, 0x42, 0x82, 0x44, 0x84,
  0x44, 0x84, 0x48, 0x48, 0x48, 0x48, 0x50, 0x50, 0x50, 0x50, 0x60, 0x60,
  0x60, 0x60, 0x40, 0x40, 0x10, 0x18, 0x41, 0x02, 0x18, 0x09, 0x80, 0x48,
  0x01, 0x80, 0x08, 0x00, 0xA0, 0x09, 0x00, 0x84, 0x08, 0x20, 0xC0, 0x8C,
  0x04, 0x00, 0x08, 0x06, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x41, 0x00,
  0x82, 0x01, 0x08, 0x02, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x03,
  0xC0, 0x00, 0x1F, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x0F, 0xF8, 0x03, 0x82, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x38, 0x18, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xC0, 0x70, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x03,
  0x06, 0x00, 0x78, 0x30, 0xFC,
};

const GFXglyph NotoSans_ExtraLightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 18, 6, 1, -18 },
  { 13, 6, 7, 8, 3, -18 },
  { 19, 15, 18, 16, 1, -18 },
  { 53, 12, 20, 14, 1, -19 },
  { 83, 16, 18, 19, 2, -18 },
  { 119, 15, 18, 17, 1, -18 },
  { 153, 2, 7, 5, 3, -18 },
  { 155, 7, 22, 6, 1, -18 },
  { 175, 8, 22, 6, -2, -18 },
  { 197, 11, 11, 13, 3, -19 },
  { 213, 11, 12, 14, 2, -15 },
  { 230, 4, 6, 5, -1, -3 },
  { 233, 6, 1, 8, 1, -7 },
  { 234, 1, 2, 5, 1, -2 },
  { 235, 11, 18, 8, -1, -18 },
  { 260, 11, 18, 14, 2, -18 },
  { 285, 6, 18, 14, 4, -18 },
  { 299, 13, 18, 14, 0, -18 },
  { 329, 12, 18, 14, 1, -18 },
  { 356, 13, 18, 14, 0, -18 },
  { 386, 12, 18, 14, 1, -18 },
  { 413, 12, 18, 14, 2, -18 },
  { 440, 11, 18, 14, 3, -18 },
  { 465, 12, 18, 14, 1, -18 },
  { 492, 12, 18, 14, 1, -18 },
  { 519, 4, 13, 5, 1, -13 },
  { 526, 6, 16, 5, -1, -13 },
  { 538, 11, 12, 14, 2, -15 },
  { 555, 11, 6, 14, 2, -12 },
  { 564, 11, 12, 14, 2, -15 },
  { 581, 9, 18, 10, 2, -18 },
  { 602, 19, 20, 21, 1, -18 },
  { 650, 14, 18, 14, -1, -18 },
  { 682, 14, 18, 15, 1, -18 },
  { 714, 14, 18, 15, 2, -18 },
  { 746, 15, 18, 17, 1, -18 },
  { 780, 13, 18, 13, 1, -18 },
  { 810, 13, 18, 12, 1, -18 },
  { 840, 15, 18, 17, 2, -18 },
  { 874, 16, 18, 17, 1, -18 },
  { 910, 8, 18, 7, 0, -18 },
  { 928, 10, 22, 6, -4, -18 },
  { 956, 15, 18, 14, 1, -18 },
  { 990, 9, 18, 12, 1, -18 },
  { 1011, 19, 18, 20, 1, -18 },
  { 1054, 16, 18, 17, 1, -18 },
  { 1090, 15, 18, 18, 2, -18 },
  { 1124, 13, 18, 14, 1, -18 },
  { 1154, 15, 22, 18, 2, -18 },
  { 1196, 13, 18, 14, 1, -18 },
  { 1226, 13, 18, 12, 0, -18 },
  { 1256, 12, 18, 12, 2, -18 },
  { 1283, 15, 18, 17, 2, -18 },
  { 1317, 12, 18, 13, 3, -18 },
  { 1344, 20, 18, 21, 3, -18 },
  { 1389, 15, 18, 12, -1, -18 },
  { 1423, 13, 18, 12, 2, -18 },
  { 1453, 14, 18, 13, 0, -18 },
  { 1485, 9, 22, 8, 0, -18 },
  { 1510, 5, 18, 8, 2, -18 },
  { 1522, 10, 22, 8, -2, -18 },
  { 1550, 12, 11, 14, 1, -18 },
  { 1567, 9, 1, 9, -2, 3 },
  { 1569, 3, 4, 6, 4, -19 },
  { 1571, 12, 14, 14, 1, -14 },
  { 1592, 12, 19, 14, 1, -19 },
  { 1621, 10, 14, 11, 1, -14 },
  { 1639, 14, 19, 14, 1, -19 },
  { 1673, 11, 14, 12, 1, -14 },
  { 1693, 13, 25, 7, -3, -19 },
  { 1734, 12, 20, 14, 1, -14 },
  { 1764, 11, 19, 14, 1, -19 },
  { 1791, 5, 18, 5, 1, -18 },
  { 1803, 9, 24, 5, -3, -18 },
  { 1830, 11, 19, 11, 1, -19 },
  { 1857, 5, 19, 5, 1, -19 },
  { 1869, 19, 14, 21, 1, -14 },
  { 1903, 12, 14, 14, 1, -14 },
  { 1924, 12, 13, 14, 1, -13 },
  { 1944, 13, 19, 14, 0, -13 },
  { 1975, 12, 20, 14, 1, -14 },
  { 2005, 9, 13, 9, 1, -13 },
  { 2020, 10, 14, 11, 0, -14 },
  { 2038, 7, 16, 8, 1, -16 },
  { 2052, 12, 13, 14, 1, -13 },
  { 2072, 11, 13, 11, 1, -13 },
  { 2090, 16, 13, 17, 1, -13 },
  { 2116, 13, 13, 12, -1, -13 },
  { 2138, 15, 19, 11, -3, -13 },
  { 2174, 11, 13, 11, 0, -13 },
  { 2192, 9, 22, 8, 1, -18 },
  { 2217, 1, 25, 13, 7, -19 },
  { 2221, 9, 22, 8, -1, -18 },
  { 2246, 11, 2, 14, 2, -10 },
};

const GFXfont NotoSans_ExtraLightItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRALIGHTITALIC25PT7B_H_
