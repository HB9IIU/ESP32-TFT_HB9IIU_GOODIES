#ifndef _NOTOSANS_EXTRALIGHTITALIC20PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x44, 0x44, 0x00, 0x08, 0x4A, 0x65, 0x29, 0x00,
  0x04, 0x40, 0x44, 0x08, 0x80, 0x88, 0x7F, 0xF1, 0x08, 0x11, 0x01, 0x10,
  0x11, 0x0F, 0xFC, 0x22, 0x02, 0x20, 0x42, 0x04, 0x40, 0x02, 0x01, 0x07,
  0x64, 0x82, 0x41, 0x20, 0x90, 0x30, 0x0E, 0x04, 0x82, 0x41, 0x21, 0x27,
  0xE0, 0x40, 0x20, 0x78, 0x34, 0x44, 0x84, 0x48, 0x88, 0x89, 0x08, 0x96,
  0x8A, 0x99, 0x51, 0x69, 0x10, 0x91, 0x11, 0x12, 0x21, 0x41, 0x2C, 0x1C,
  0x06, 0x00, 0x98, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10, 0x0E, 0x01, 0x80,
  0x24, 0x14, 0x22, 0x81, 0x28, 0x14, 0x80, 0x88, 0x14, 0x7E, 0x60, 0x5A,
  0x80, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x40,
  0x18, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x10, 0x88, 0x80, 0x04,
  0x02, 0x32, 0x07, 0x30, 0xE0, 0xA1, 0x90, 0x8C, 0x04, 0x01, 0x00, 0x40,
  0x10, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x29, 0x48, 0xF8,
  0x80, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x04, 0x04, 0x00, 0x06, 0x06, 0x61, 0x08, 0x81, 0x40, 0x50,
  0x14, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x10, 0x83, 0xC0,
  0x19, 0x72, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x20, 0x0F, 0x84, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x3F, 0xE0, 0x0F, 0xC2, 0x08, 0x00, 0x80, 0x20, 0x04, 0x01, 0x03,
  0xC0, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x11, 0xFC, 0x00, 0x00,
  0x40, 0x18, 0x05, 0x01, 0x20, 0x48, 0x11, 0x04, 0x21, 0x04, 0x41, 0x1F,
  0xFC, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x1F, 0xC4, 0x02, 0x00, 0x80,
  0x20, 0x17, 0x06, 0x30, 0x04, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x3F,
  0x00, 0x01, 0x83, 0x91, 0x00, 0x80, 0x20, 0x10, 0x05, 0xE1, 0x84, 0x40,
  0xA0, 0x28, 0x0A, 0x02, 0x81, 0x10, 0xC3, 0xC0, 0xFF, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x00,
  0x1F, 0x88, 0x12, 0x04, 0x81, 0x20, 0x84, 0xC0, 0xC0, 0xC8, 0x41, 0x20,
  0x28, 0x0A, 0x04, 0x81, 0x1F, 0x80, 0x1F, 0x10, 0x50, 0x28, 0x14, 0x0A,
  0x05, 0x02, 0x47, 0x1C, 0x80, 0x80, 0x40, 0x40, 0x47, 0xC0, 0x24, 0x00,
  0x00, 0x02, 0x00, 0x08, 0x40, 0x00, 0x00, 0x00, 0x01, 0x10, 0x88, 0x40,
  0x00, 0x40, 0x60, 0x60, 0xE0, 0xC0, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x60, 0x60, 0x60, 0xE0, 0x00, 0xFC, 0x08, 0x08, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF0, 0x10, 0x18, 0x40, 0x11,
  0x00, 0x14, 0x3E, 0x28, 0x84, 0x62, 0x08, 0xC4, 0x11, 0x88, 0x43, 0x10,
  0x8A, 0x23, 0x14, 0x39, 0xC4, 0x00, 0x08, 0x00, 0x0C, 0x08, 0x07, 0xE0,
  0x00, 0x80, 0x30, 0x0A, 0x01, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x1F,
  0xC4, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x40, 0x1F, 0xC2, 0x08, 0x80,
  0x90, 0x12, 0x04, 0x41, 0x0F, 0xC2, 0x04, 0x40, 0x48, 0x09, 0x01, 0x40,
  0x48, 0x11, 0xFC, 0x00, 0x0F, 0xE6, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x7E, 0x00,
  0x1F, 0x81, 0x06, 0x20, 0x22, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x24, 0x02, 0x40, 0x48, 0x0C, 0x81, 0x0F, 0xE0, 0x1F, 0xC8, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x3F, 0x80, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0xFC, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xE6, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1E, 0x80, 0x50, 0x0A, 0x01,
  0x40, 0x24, 0x08, 0x7F, 0x00, 0x10, 0x19, 0x00, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x10, 0xFF, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x11, 0x00,
  0x88, 0x04, 0x40, 0x20, 0x1E, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x1E, 0x00, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x30, 0xC0, 0x10,
  0x32, 0x04, 0x21, 0x82, 0x20, 0x24, 0x02, 0x80, 0x58, 0x06, 0x40, 0x44,
  0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x08, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x1F, 0xC0, 0x10, 0x06, 0x50,
  0x0C, 0xA0, 0x29, 0x40, 0x52, 0x81, 0x45, 0x04, 0x92, 0x09, 0x22, 0x22,
  0x44, 0x48, 0x89, 0x11, 0x12, 0x24, 0x28, 0x48, 0x60, 0x90, 0x42, 0x00,
  0x10, 0x09, 0x80, 0x8A, 0x04, 0x50, 0x22, 0x41, 0x12, 0x11, 0x08, 0x88,
  0x44, 0x42, 0x22, 0x09, 0x10, 0x51, 0x01, 0x88, 0x0C, 0x40, 0x20, 0x07,
  0x01, 0x8C, 0x20, 0x24, 0x02, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x1F, 0x84,
  0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x09, 0xFC, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x07, 0x01, 0x8C, 0x20, 0x24, 0x02, 0x40, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44,
  0x08, 0x3F, 0x00, 0x40, 0x02, 0x00, 0x30, 0x1F, 0x84, 0x12, 0x04, 0x81,
  0x20, 0x48, 0x14, 0x19, 0xF8, 0x42, 0x10, 0x84, 0x22, 0x04, 0x81, 0x20,
  0x20, 0x0F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x01, 0x3F, 0x80, 0xFF, 0xC2, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x00, 0x20, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x48,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x81, 0x07, 0xE0, 0x80, 0x60,
  0x28, 0x0A, 0x04, 0x41, 0x10, 0x84, 0x21, 0x10, 0x44, 0x12, 0x04, 0x81,
  0x40, 0x60, 0x08, 0x00, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84,
  0x44, 0x84, 0x44, 0x88, 0x44, 0x88, 0x48, 0x88, 0x48, 0x90, 0x50, 0x90,
  0x50, 0xA0, 0x60, 0xA0, 0x60, 0x40, 0x40, 0x40, 0x10, 0x10, 0x82, 0x08,
  0x40, 0x48, 0x04, 0x80, 0x50, 0x02, 0x00, 0x60, 0x09, 0x01, 0x10, 0x11,
  0x02, 0x08, 0x40, 0x88, 0x04, 0x80, 0xE0, 0x44, 0x11, 0x08, 0x44, 0x11,
  0x02, 0x80, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x00, 0x1F,
  0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x01, 0xFF, 0x00, 0x1E, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xF0, 0x92, 0x24,
  0x92, 0x44, 0x92, 0x40, 0x1E, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0xF0, 0x06, 0x05, 0x02, 0x82, 0x22,
  0x11, 0x09, 0x03, 0x81, 0xFF, 0x94, 0x0E, 0x98, 0xD0, 0x28, 0x18, 0x0C,
  0x0A, 0x05, 0x02, 0x83, 0x42, 0x9E, 0x80, 0x10, 0x10, 0x08, 0x04, 0x02,
  0xF1, 0x85, 0x82, 0x81, 0x40, 0xA0, 0x60, 0x30, 0x18, 0x16, 0x12, 0xF0,
  0x0F, 0x30, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x3E, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0xE4, 0x62, 0x90, 0x22, 0x04, 0x80, 0x90,
  0x12, 0x04, 0x40, 0x88, 0x31, 0x0A, 0x1E, 0x40, 0x0E, 0x31, 0x41, 0x41,
  0x82, 0xFC, 0x80, 0x80, 0x80, 0x40, 0x3E, 0x00, 0xE0, 0x20, 0x08, 0x01,
  0x00, 0xF8, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x70, 0x00, 0x0E,
  0x4C, 0x54, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x83, 0x21, 0x47,
  0x90, 0x08, 0x02, 0x00, 0x88, 0x43, 0xE0, 0x10, 0x10, 0x08, 0x04, 0x02,
  0xF1, 0x85, 0x82, 0x81, 0x40, 0xA0, 0x60, 0x50, 0x28, 0x14, 0x0A, 0x04,
  0x30, 0x02, 0x24, 0x44, 0x48, 0x88, 0x88, 0x03, 0x00, 0x00, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0xE0, 0x10, 0x10, 0x08, 0x04, 0x02, 0x09, 0x09, 0x08, 0x98, 0x50,
  0x38, 0x12, 0x11, 0x08, 0x44, 0x22, 0x08, 0x12, 0x22, 0x22, 0x44, 0x44,
  0x88, 0x88, 0x80, 0x2E, 0x1C, 0xA2, 0xC5, 0x85, 0x0A, 0x04, 0x14, 0x10,
  0x28, 0x20, 0xA0, 0x41, 0x40, 0x82, 0x82, 0x05, 0x04, 0x0A, 0x08, 0x20,
  0x2F, 0x28, 0x58, 0x28, 0x14, 0x0A, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0,
  0x40, 0x0E, 0x18, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x21,
  0x1F, 0x00, 0x17, 0x8A, 0x13, 0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x01,
  0x40, 0x98, 0x45, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0E, 0x4C,
  0x54, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x83, 0x21, 0x47, 0x90,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x2E, 0xA1, 0x82, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x00, 0x1E, 0x21, 0x40, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x02, 0x02, 0xFC, 0x20, 0x8F, 0xD0, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20,
  0xF0, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x0A, 0x05, 0x02, 0x83, 0x42,
  0x9E, 0x80, 0x81, 0x81, 0x82, 0x82, 0x84, 0x44, 0x48, 0x50, 0x50, 0x60,
  0x60, 0x82, 0x0C, 0x10, 0x61, 0x85, 0x14, 0x28, 0xA2, 0x49, 0x12, 0x45,
  0x14, 0x28, 0xA1, 0x86, 0x0C, 0x10, 0x40, 0x10, 0x62, 0x08, 0x22, 0x04,
  0x80, 0xA0, 0x08, 0x02, 0x80, 0x90, 0x22, 0x04, 0x23, 0x06, 0x00, 0x10,
  0x22, 0x04, 0x41, 0x08, 0x20, 0x88, 0x11, 0x02, 0x40, 0x48, 0x0A, 0x01,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x3F, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x3F, 0x80, 0x07, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x30, 0xFF, 0xFF, 0xF0, 0x1C, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x06, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0xE0, 0x78, 0x61, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 4, 1, -14 },
  { 8, 5, 5, 7, 2, -14 },
  { 12, 12, 14, 12, 1, -14 },
  { 33, 9, 16, 11, 1, -15 },
  { 51, 12, 14, 15, 2, -14 },
  { 72, 12, 15, 14, 1, -15 },
  { 95, 2, 5, 4, 2, -14 },
  { 97, 5, 17, 5, 1, -14 },
  { 108, 5, 17, 5, -1, -14 },
  { 119, 9, 8, 11, 2, -15 },
  { 128, 10, 10, 11, 1, -12 },
  { 141, 3, 5, 4, -1, -2 },
  { 143, 5, 1, 6, 1, -6 },
  { 144, 1, 1, 4, 1, -1 },
  { 145, 9, 14, 6, -1, -14 },
  { 161, 10, 15, 11, 1, -15 },
  { 180, 5, 14, 11, 3, -14 },
  { 189, 10, 14, 11, 0, -14 },
  { 207, 11, 14, 11, 0, -14 },
  { 227, 11, 14, 11, 0, -14 },
  { 247, 10, 14, 11, 1, -14 },
  { 265, 10, 15, 11, 1, -15 },
  { 284, 9, 14, 11, 2, -14 },
  { 300, 10, 14, 11, 1, -14 },
  { 318, 9, 14, 11, 1, -14 },
  { 334, 3, 11, 4, 1, -11 },
  { 339, 5, 14, 4, -1, -11 },
  { 348, 10, 9, 11, 1, -12 },
  { 360, 10, 4, 11, 1, -9 },
  { 365, 10, 9, 11, 1, -12 },
  { 377, 7, 14, 8, 2, -14 },
  { 390, 15, 16, 17, 1, -14 },
  { 420, 11, 14, 11, -1, -14 },
  { 440, 11, 14, 12, 1, -14 },
  { 460, 11, 14, 12, 2, -14 },
  { 480, 12, 14, 14, 1, -14 },
  { 501, 10, 14, 11, 1, -14 },
  { 519, 10, 14, 10, 1, -14 },
  { 537, 11, 14, 14, 2, -14 },
  { 557, 13, 14, 14, 1, -14 },
  { 580, 7, 14, 6, 0, -14 },
  { 593, 8, 18, 5, -3, -14 },
  { 611, 12, 14, 11, 1, -14 },
  { 632, 7, 14, 10, 1, -14 },
  { 645, 15, 14, 16, 1, -14 },
  { 672, 13, 14, 14, 1, -14 },
  { 695, 12, 15, 14, 2, -15 },
  { 718, 10, 14, 11, 1, -14 },
  { 736, 12, 18, 14, 2, -15 },
  { 763, 10, 14, 11, 1, -14 },
  { 781, 10, 14, 10, 0, -14 },
  { 799, 10, 14, 10, 2, -14 },
  { 817, 12, 14, 14, 2, -14 },
  { 838, 10, 14, 11, 2, -14 },
  { 856, 16, 14, 17, 2, -14 },
  { 884, 12, 14, 10, -1, -14 },
  { 905, 10, 14, 10, 2, -14 },
  { 923, 11, 14, 11, 0, -14 },
  { 943, 7, 17, 6, 0, -14 },
  { 958, 3, 14, 6, 2, -14 },
  { 964, 7, 17, 6, -1, -14 },
  { 979, 9, 8, 11, 1, -14 },
  { 988, 8, 1, 8, -2, 2 },
  { 989, 2, 3, 5, 3, -15 },
  { 990, 9, 11, 11, 1, -11 },
  { 1003, 9, 15, 11, 1, -15 },
  { 1020, 8, 11, 9, 1, -11 },
  { 1031, 11, 15, 11, 1, -15 },
  { 1052, 8, 11, 10, 1, -11 },
  { 1063, 11, 20, 6, -3, -15 },
  { 1091, 10, 16, 11, 1, -11 },
  { 1111, 9, 15, 11, 1, -15 },
  { 1128, 4, 14, 4, 1, -14 },
  { 1135, 8, 19, 4, -3, -14 },
  { 1154, 9, 15, 9, 1, -15 },
  { 1171, 4, 15, 4, 1, -15 },
  { 1179, 15, 11, 17, 1, -11 },
  { 1200, 9, 11, 11, 1, -11 },
  { 1213, 9, 11, 11, 1, -11 },
  { 1226, 10, 16, 11, 0, -11 },
  { 1246, 10, 16, 11, 1, -11 },
  { 1266, 7, 11, 8, 1, -11 },
  { 1276, 8, 11, 9, 0, -11 },
  { 1287, 6, 13, 6, 1, -13 },
  { 1297, 9, 11, 11, 1, -11 },
  { 1310, 8, 11, 8, 1, -11 },
  { 1321, 13, 11, 13, 1, -11 },
  { 1339, 11, 11, 9, -1, -11 },
  { 1355, 11, 16, 8, -2, -11 },
  { 1377, 9, 11, 9, 0, -11 },
  { 1390, 8, 17, 7, 0, -14 },
  { 1407, 1, 20, 11, 5, -15 },
  { 1410, 7, 17, 7, -1, -14 },
  { 1425, 10, 2, 11, 1, -8 },
};

const GFXfont NotoSans_ExtraLightItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRALIGHTITALIC20PT7B_H_
