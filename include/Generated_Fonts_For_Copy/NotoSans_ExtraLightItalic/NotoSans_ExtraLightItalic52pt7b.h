#ifndef _NOTOSANS_EXTRALIGHTITALIC52PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0E, 0x03, 0x80, 0xE0, 0x00,
  0x30, 0x33, 0x07, 0x30, 0x62, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC6, 0x0C,
  0x40, 0xCC, 0x0C, 0xC0, 0x8C, 0x08, 0x81, 0x80, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x80, 0x10, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x03, 0xC6, 0x1C, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80,
  0x01, 0x80, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x10, 0x00, 0x18, 0x08, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x10, 0x70, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80,
  0x01, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x70,
  0x00, 0x20, 0x70, 0x60, 0x10, 0xF0, 0x3F, 0xDB, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x01, 0xFC, 0x00, 0x03, 0x01, 0xC3, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x01,
  0x81, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x08, 0x01,
  0xC0, 0x60, 0x04, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x60,
  0x60, 0x03, 0x00, 0x30, 0x60, 0x01, 0x00, 0x30, 0x30, 0x01, 0x80, 0x18,
  0x30, 0x30, 0xC0, 0x0C, 0x30, 0xFE, 0x60, 0x0C, 0x30, 0xE1, 0x90, 0x06,
  0x18, 0xC0, 0x6C, 0x06, 0x18, 0xC0, 0x36, 0x07, 0x18, 0x60, 0x19, 0x87,
  0x18, 0x60, 0x0C, 0xFF, 0x0C, 0x30, 0x06, 0x0C, 0x0C, 0x18, 0x03, 0x00,
  0x0C, 0x18, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x60,
  0x06, 0x03, 0x00, 0x30, 0x06, 0x01, 0x00, 0x18, 0x07, 0x01, 0x80, 0x18,
  0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x30, 0x06,
  0x03, 0x80, 0x18, 0x03, 0x01, 0x80, 0x06, 0x03, 0x01, 0x80, 0x03, 0x03,
  0x01, 0x80, 0x01, 0xC3, 0x81, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0xC7, 0x00, 0x60, 0x03, 0x9C, 0x00, 0x60, 0x06, 0x30, 0x00,
  0x60, 0x18, 0xC0, 0x00, 0xE0, 0x31, 0x80, 0x00, 0xC0, 0xC3, 0x00, 0x00,
  0xC3, 0x8C, 0x00, 0x00, 0xC6, 0x18, 0x00, 0x01, 0xD8, 0x30, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x3B,
  0x01, 0xC0, 0x00, 0xE3, 0x01, 0xC0, 0x07, 0x03, 0x01, 0xF0, 0xFC, 0x07,
  0x00, 0xFF, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x33, 0x32, 0x66,
  0x66, 0x4C, 0xCC, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x60, 0x0F, 0x01,
  0x80, 0x0F, 0x04, 0x00, 0x0F, 0x10, 0x00, 0x06, 0xC0, 0xF0, 0x07, 0xFF,
  0xC0, 0x1C, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x60, 0x00, 0x30, 0x80, 0x03,
  0x83, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x1C, 0x38, 0x61, 0xC3,
  0x06, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x5F, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x73, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x8C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x70,
  0x03, 0x00, 0x70, 0x00, 0xF1, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x80, 0xE6, 0x07, 0x18, 0x70, 0xC3,
  0x83, 0x38, 0x0C, 0x40, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xC0,
  0xF0, 0x07, 0x80, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x40, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC0,
  0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07,
  0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF7, 0xE0, 0x01, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xE0, 0x20, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x3F, 0x00, 0x30, 0xFF, 0xE0,
  0x19, 0xE0, 0x38, 0x0D, 0xC0, 0x0E, 0x0D, 0x80, 0x03, 0x87, 0x80, 0x00,
  0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xEE,
  0x00, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x60,
  0x00, 0x70, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x87, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0x0F,
  0x00, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x18, 0x1C, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x03, 0xC3,
  0x00, 0x03, 0xC1, 0xC0, 0x03, 0x60, 0x60, 0x03, 0x30, 0x1C, 0x07, 0x18,
  0x07, 0xFF, 0x18, 0x00, 0xFC, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xE0, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x83, 0xE0, 0xF0, 0x40, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x01,
  0xFF, 0x80, 0x31, 0x80, 0x0F, 0x07, 0x80, 0x66, 0x00, 0x38, 0x03, 0x00,
  0xCC, 0x00, 0xC0, 0x0C, 0x01, 0xB0, 0x03, 0x00, 0x18, 0x03, 0x60, 0x0C,
  0x00, 0x30, 0x06, 0xC0, 0x38, 0x00, 0x40, 0x0F, 0x00, 0x60, 0x01, 0x80,
  0x1E, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x06, 0x00, 0x78, 0x06,
  0x00, 0x18, 0x01, 0xB0, 0x0C, 0x00, 0x30, 0x03, 0x60, 0x18, 0x00, 0x60,
  0x06, 0xC0, 0x30, 0x01, 0xC0, 0x19, 0x80, 0x60, 0x03, 0x80, 0x33, 0x00,
  0xC0, 0x0F, 0x00, 0xC6, 0x01, 0x80, 0x36, 0x03, 0x8C, 0x03, 0x80, 0xCC,
  0x0E, 0x18, 0x03, 0xC7, 0x0C, 0x78, 0x18, 0x03, 0xFC, 0x1F, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x01, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x78, 0x06, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0E,
  0x01, 0xFC, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x38, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x78, 0x00, 0x20, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x08, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x00,
  0xC0, 0x00, 0xF8, 0x01, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0x07, 0xF8, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x18,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x1E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0xE8, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06,
  0x3C, 0x00, 0x00, 0x0C, 0xD8, 0x00, 0x00, 0x37, 0x38, 0x00, 0x00, 0x7C,
  0x30, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x1B, 0x00, 0xB0, 0x00, 0x00, 0x1E, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x01, 0xB0, 0x00, 0x00, 0x66,
  0x01, 0x98, 0x00, 0x00, 0xEE, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x03, 0x18, 0x00, 0x03,
  0x0C, 0x03, 0x18, 0x00, 0x07, 0x18, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x06,
  0x0C, 0x00, 0x0C, 0x18, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x06, 0x0C, 0x00,
  0x18, 0x18, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x80, 0x60, 0x18, 0x03, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x06, 0x00, 0xE0, 0x38, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x1C, 0x00, 0xC0, 0x30, 0x03, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0xB0, 0x01, 0x80, 0x60, 0x01, 0xB0, 0x01, 0x80, 0x60, 0x01,
  0xE0, 0x01, 0x80, 0x60, 0x01, 0xE0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x01,
  0x80, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x16, 0x00, 0x00, 0x70, 0x1B,
  0x00, 0x00, 0x30, 0x0D, 0x80, 0x00, 0x18, 0x06, 0x60, 0x00, 0x0C, 0x03,
  0x30, 0x00, 0x06, 0x01, 0x0C, 0x00, 0x06, 0x01, 0x86, 0x00, 0x03, 0x00,
  0xC1, 0x80, 0x01, 0x80, 0x60, 0xC0, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x60,
  0x38, 0x18, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x18,
  0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x06,
  0x01, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x60, 0x03, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x30, 0x00, 0x60, 0x60, 0x18, 0x00, 0x30,
  0x30, 0x0C, 0x00, 0x0C, 0x18, 0x06, 0x00, 0x06, 0x0C, 0x07, 0x00, 0x01,
  0x8C, 0x03, 0x00, 0x00, 0xC6, 0x01, 0x80, 0x00, 0x73, 0x00, 0xC0, 0x00,
  0x19, 0x80, 0x60, 0x00, 0x0C, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x30, 0x00,
  0x01, 0xE0, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x60, 0x00,
  0xE0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x78, 0x06, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0x00, 0x1E, 0x00, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x01, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x03, 0x80,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x80, 0xFE, 0x3F, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00,
  0x18, 0x01, 0x80, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00,
  0xC4, 0x00, 0x06, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x60, 0x00, 0x61, 0x80,
  0x03, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x30, 0x60, 0x01, 0xCC,
  0x00, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x1C, 0x18, 0x00, 0x63, 0x00, 0x0C,
  0x0C, 0x00, 0x60, 0x80, 0x0E, 0x06, 0x00, 0x30, 0x40, 0x06, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00,
  0x10, 0xC0, 0x03, 0x0C, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x06, 0x70,
  0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x01, 0xB8, 0x00, 0x13,
  0x00, 0x00, 0xD8, 0x00, 0x09, 0x80, 0x00, 0x6C, 0x00, 0x04, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60,
  0x38, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x08, 0x00, 0x38, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC3, 0x06, 0x18, 0x30, 0x61, 0x83, 0x00,
  0x3F, 0x83, 0x00, 0xFF, 0xC3, 0x03, 0xC0, 0x63, 0x07, 0x00, 0x32, 0x0E,
  0x00, 0x16, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0xB0, 0xC0, 0x01, 0xA0, 0xE0, 0x03, 0x60, 0x60,
  0x06, 0x60, 0x70, 0x0C, 0x60, 0x3C, 0x78, 0x40, 0x1F, 0xE0, 0x40, 0x03,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x3F, 0x00, 0x30, 0xFF, 0xE0, 0x18, 0xE0,
  0x78, 0x0C, 0xC0, 0x0C, 0x06, 0xC0, 0x03, 0x06, 0xC0, 0x01, 0x83, 0xC0,
  0x00, 0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38,
  0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x0B, 0x00, 0x07, 0x0C, 0x80, 0x07, 0x06, 0x70, 0x0F,
  0x03, 0x1F, 0x1E, 0x01, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0xF0, 0x04, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x04, 0x07, 0xC3, 0xE0, 0x0F, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x18,
  0x01, 0xFF, 0xC3, 0x00, 0xF0, 0x1C, 0xC0, 0x38, 0x00, 0x98, 0x0E, 0x00,
  0x1B, 0x01, 0x80, 0x01, 0x60, 0x60, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x78, 0x18, 0x00, 0x1E, 0x03, 0x00,
  0x02, 0xC0, 0x70, 0x00, 0xD8, 0x06, 0x00, 0x33, 0x00, 0xE0, 0x1C, 0x40,
  0x0F, 0x1E, 0x08, 0x00, 0xFF, 0x83, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x60, 0x60, 0x01,
  0x86, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x39, 0x80,
  0x01, 0x98, 0x00, 0x18, 0xC0, 0x03, 0x86, 0x00, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x04, 0x03, 0xC3, 0xE0, 0x0F, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0x04, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x60, 0x07, 0xFF, 0x0C, 0x03, 0xC0, 0x71, 0x00,
  0xE0, 0x02, 0x60, 0x38, 0x00, 0x6C, 0x06, 0x00, 0x05, 0x81, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x00, 0x01, 0xE0,
  0x60, 0x00, 0x78, 0x0C, 0x00, 0x0B, 0x01, 0xC0, 0x03, 0x60, 0x18, 0x00,
  0xCC, 0x03, 0x80, 0x71, 0x00, 0x3C, 0x38, 0x60, 0x03, 0xFE, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x0F, 0x00, 0x3F, 0x0F, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x03, 0xF0, 0x06, 0x0F, 0xFC, 0x06, 0x38,
  0x0E, 0x06, 0x60, 0x06, 0x06, 0xC0, 0x07, 0x0D, 0x80, 0x03, 0x0F, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x8E, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x60, 0x38,
  0x00, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x0C, 0x38, 0x00,
  0x18, 0xE0, 0x00, 0x33, 0xC0, 0x00, 0xCC, 0xC0, 0x01, 0xB1, 0x80, 0x03,
  0xC1, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x70, 0x00, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x06, 0x07, 0xE0, 0x07, 0xF0, 0x0C, 0x3F, 0xE0, 0x3F, 0xF0, 0x18, 0xC0,
  0xE0, 0xE0, 0x70, 0x33, 0x00, 0xE3, 0x00, 0x70, 0x4C, 0x00, 0xCC, 0x00,
  0x61, 0xB0, 0x01, 0xB0, 0x00, 0xC3, 0xC0, 0x03, 0x40, 0x01, 0x87, 0x00,
  0x07, 0x80, 0x03, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x70, 0x00, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x61, 0x80,
  0x00, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x80, 0x01, 0x86,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x07, 0xF0, 0x06, 0x1F, 0xFC, 0x06,
  0x38, 0x0E, 0x06, 0x60, 0x06, 0x04, 0xC0, 0x07, 0x0D, 0x80, 0x03, 0x0F,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C,
  0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xE0,
  0x00, 0x30, 0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x1F,
  0x0F, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x7E, 0x00,
  0x0C, 0x3F, 0xF8, 0x00, 0xC7, 0x03, 0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0x98,
  0x00, 0x60, 0x1B, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x18, 0x0E, 0x00, 0x03, 0x00, 0xB0, 0x00, 0x70, 0x19, 0x00, 0x0E, 0x01,
  0x9C, 0x03, 0xC0, 0x18, 0xF8, 0xF0, 0x01, 0x83, 0xFE, 0x00, 0x18, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0x80, 0x7F, 0xF0, 0xC0, 0xF0,
  0x1C, 0x40, 0xE0, 0x02, 0x60, 0xE0, 0x01, 0xB0, 0x60, 0x00, 0x58, 0x60,
  0x00, 0x3C, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x86, 0x00, 0x07,
  0x83, 0x00, 0x03, 0xC1, 0xC0, 0x03, 0x60, 0x60, 0x03, 0x30, 0x38, 0x07,
  0x18, 0x0F, 0x0F, 0x18, 0x03, 0xFE, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x06, 0x07, 0xE0,
  0xC3, 0xFC, 0x18, 0xE0, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0x00, 0x70,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x70, 0xF8, 0x3E, 0x03,
  0xFF, 0x80, 0x01, 0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xF1, 0x80, 0xFF, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0xF0, 0xC0, 0x01, 0xB0, 0xC0, 0x03, 0x60, 0xE0,
  0x06, 0x60, 0x60, 0x0C, 0x60, 0x7C, 0x78, 0x60, 0x1F, 0xE0, 0x40, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xE0,
  0x10, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x01, 0x0C, 0x00, 0x0C, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x6C, 0x00,
  0x66, 0x00, 0x36, 0x00, 0x33, 0x00, 0x33, 0x00, 0x31, 0x80, 0x19, 0x80,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x10,
  0x0E, 0x18, 0x06, 0x08, 0x06, 0x04, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0x61, 0x80,
  0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x06, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01, 0x30, 0x01, 0xB0,
  0x00, 0x98, 0x00, 0xD8, 0x00, 0x58, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0x30,
  0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x70, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x7C,
  0x07, 0x80, 0x0F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraLightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 37, 11, 2, -37 },
  { 48, 12, 13, 17, 6, -37 },
  { 68, 31, 37, 32, 2, -37 },
  { 212, 25, 42, 29, 2, -39 },
  { 344, 33, 39, 40, 4, -38 },
  { 505, 31, 39, 35, 2, -38 },
  { 657, 4, 13, 9, 6, -37 },
  { 664, 15, 45, 13, 2, -37 },
  { 749, 15, 45, 13, -3, -37 },
  { 834, 22, 22, 28, 6, -39 },
  { 895, 24, 24, 30, 4, -30 },
  { 967, 7, 13, 10, -2, -6 },
  { 979, 12, 2, 16, 2, -15 },
  { 982, 3, 4, 11, 2, -4 },
  { 984, 23, 37, 16, -2, -37 },
  { 1091, 25, 39, 29, 3, -38 },
  { 1213, 14, 37, 29, 8, -37 },
  { 1278, 27, 38, 29, 0, -38 },
  { 1407, 26, 39, 29, 1, -38 },
  { 1534, 27, 37, 29, 1, -37 },
  { 1659, 26, 38, 29, 2, -37 },
  { 1783, 25, 39, 29, 3, -38 },
  { 1905, 23, 37, 29, 6, -37 },
  { 2012, 26, 39, 29, 2, -38 },
  { 2139, 25, 39, 29, 2, -38 },
  { 2261, 8, 28, 11, 2, -28 },
  { 2289, 12, 35, 11, -2, -28 },
  { 2342, 24, 24, 30, 4, -31 },
  { 2414, 24, 12, 30, 4, -24 },
  { 2450, 24, 24, 30, 4, -31 },
  { 2522, 18, 38, 21, 4, -38 },
  { 2608, 39, 42, 44, 3, -37 },
  { 2813, 29, 37, 29, -3, -37 },
  { 2948, 28, 37, 31, 2, -37 },
  { 3078, 29, 39, 31, 4, -38 },
  { 3220, 31, 37, 35, 2, -37 },
  { 3364, 27, 37, 28, 2, -37 },
  { 3489, 27, 37, 25, 2, -37 },
  { 3614, 31, 39, 36, 4, -38 },
  { 3766, 33, 37, 35, 2, -37 },
  { 3919, 17, 37, 15, 0, -37 },
  { 3998, 22, 46, 12, -9, -37 },
  { 4125, 31, 37, 28, 2, -37 },
  { 4269, 19, 37, 25, 2, -37 },
  { 4357, 40, 37, 42, 2, -37 },
  { 4542, 33, 37, 35, 2, -37 },
  { 4695, 31, 39, 37, 4, -38 },
  { 4847, 27, 37, 29, 2, -37 },
  { 4972, 31, 47, 37, 4, -38 },
  { 5155, 27, 37, 29, 2, -37 },
  { 5280, 26, 39, 26, 1, -38 },
  { 5407, 25, 37, 25, 5, -37 },
  { 5523, 32, 38, 36, 4, -37 },
  { 5675, 27, 37, 28, 5, -37 },
  { 5800, 41, 37, 43, 6, -37 },
  { 5990, 33, 37, 26, -3, -37 },
  { 6143, 25, 37, 25, 5, -37 },
  { 6259, 30, 37, 28, 0, -37 },
  { 6398, 19, 45, 16, 0, -37 },
  { 6505, 9, 37, 16, 5, -37 },
  { 6547, 20, 45, 16, -4, -37 },
  { 6660, 25, 23, 29, 2, -37 },
  { 6732, 20, 2, 20, -4, 5 },
  { 6737, 6, 8, 12, 8, -40 },
  { 6743, 24, 29, 29, 3, -28 },
  { 6830, 25, 41, 30, 2, -40 },
  { 6959, 21, 29, 24, 3, -28 },
  { 7036, 27, 41, 30, 3, -40 },
  { 7175, 21, 29, 26, 3, -28 },
  { 7252, 29, 52, 14, -7, -40 },
  { 7441, 27, 40, 30, 1, -28 },
  { 7576, 24, 40, 29, 2, -40 },
  { 7696, 10, 38, 11, 2, -38 },
  { 7744, 19, 50, 11, -7, -38 },
  { 7863, 23, 40, 23, 2, -40 },
  { 7978, 10, 40, 11, 2, -40 },
  { 8028, 39, 28, 44, 2, -28 },
  { 8165, 24, 28, 29, 2, -28 },
  { 8249, 24, 29, 29, 3, -28 },
  { 8336, 28, 40, 30, -1, -28 },
  { 8476, 25, 40, 30, 3, -28 },
  { 8601, 19, 28, 20, 2, -28 },
  { 8668, 20, 29, 22, 1, -28 },
  { 8741, 15, 35, 16, 3, -34 },
  { 8807, 24, 29, 29, 3, -28 },
  { 8894, 21, 28, 22, 3, -28 },
  { 8968, 33, 28, 35, 3, -28 },
  { 9084, 27, 28, 24, -2, -28 },
  { 9179, 30, 41, 22, -6, -28 },
  { 9333, 24, 28, 23, -1, -28 },
  { 9417, 19, 45, 17, 1, -37 },
  { 9524, 2, 53, 28, 14, -40 },
  { 9538, 18, 45, 17, -2, -37 },
  { 9640, 24, 5, 30, 4, -21 },
};

const GFXfont NotoSans_ExtraLightItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRALIGHTITALIC52PT7B_H_
