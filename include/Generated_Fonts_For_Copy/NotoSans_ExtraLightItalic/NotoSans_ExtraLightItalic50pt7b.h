#ifndef _NOTOSANS_EXTRALIGHTITALIC50PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x70, 0x00, 0x18, 0x31, 0x83, 0x30, 0x33, 0x06, 0x30, 0x63, 0x06,
  0x20, 0x62, 0x04, 0x60, 0x46, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0x80, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x81, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xF1, 0x1F, 0x01,
  0xC3, 0x02, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00, 0x06,
  0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0xCC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x18, 0x70, 0x00, 0x10, 0x30, 0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x20, 0x30, 0x00, 0x20, 0x30, 0x00,
  0x60, 0x60, 0xC0, 0x61, 0xC0, 0xFC, 0x6F, 0x80, 0x3F, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0x07, 0xB8, 0x00,
  0x18, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x06, 0x00,
  0x60, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x20, 0x06, 0x01,
  0x80, 0x60, 0x06, 0x03, 0x00, 0x60, 0x04, 0x07, 0x00, 0x60, 0x0C, 0x06,
  0x00, 0x40, 0x0C, 0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x0C, 0x18,
  0x00, 0xC0, 0x18, 0x30, 0x70, 0xC0, 0x18, 0x61, 0xFC, 0xC0, 0x18, 0xC3,
  0x06, 0xC0, 0x30, 0xC6, 0x06, 0x60, 0x61, 0x8C, 0x03, 0x60, 0xE3, 0x0C,
  0x03, 0x3B, 0xC6, 0x18, 0x03, 0x1F, 0x06, 0x18, 0x03, 0x00, 0x0C, 0x10,
  0x03, 0x00, 0x18, 0x30, 0x03, 0x00, 0x30, 0x30, 0x03, 0x00, 0x30, 0x30,
  0x02, 0x00, 0x60, 0x30, 0x06, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x20,
  0x18, 0x06, 0x00, 0x30, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x18, 0x00, 0x18,
  0x60, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x03,
  0x0E, 0x03, 0x00, 0x0C, 0x60, 0x06, 0x00, 0x63, 0x00, 0x0C, 0x01, 0x9C,
  0x00, 0x30, 0x0C, 0x60, 0x00, 0x60, 0x61, 0x80, 0x00, 0xC1, 0x8C, 0x00,
  0x03, 0x8C, 0x30, 0x00, 0x06, 0x60, 0xC0, 0x00, 0x0F, 0x03, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x06, 0xC0, 0x70, 0x00, 0x71,
  0x80, 0xE0, 0x07, 0x87, 0x01, 0xE0, 0xF8, 0x0C, 0x03, 0xFF, 0x80, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0xCC, 0x63, 0x18, 0x84, 0x63, 0x18, 0x8C,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x20, 0x18, 0x03, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x0E, 0x20, 0x00, 0x1D,
  0x00, 0xC0, 0x3F, 0xFE, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00,
  0x18, 0x40, 0x01, 0x83, 0x00, 0x18, 0x08, 0x03, 0x80, 0x60, 0x08, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x30,
  0xC1, 0x86, 0x00, 0xFF, 0xF0, 0x77, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x78, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x03,
  0xC0, 0x3C, 0x07, 0x60, 0x73, 0x0E, 0x19, 0xE1, 0x9C, 0x0C, 0x40, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0x80, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x7C, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x10, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x20, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0xE0, 0x60, 0x01, 0xE0, 0x3F, 0x07, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x3F, 0x80, 0x31, 0xFF, 0xC0, 0x33, 0x80, 0x70, 0x66, 0x00, 0x30,
  0x6C, 0x00, 0x18, 0x78, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x70, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x0E, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x1C, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x07, 0xC1, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x18, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x36, 0x06, 0x00,
  0x66, 0x03, 0xE7, 0xC6, 0x01, 0xFF, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x01, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x38, 0x38, 0x00, 0x00,
  0x60, 0x07, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x61, 0x80, 0x07, 0xFE, 0x01, 0x8C,
  0x00, 0x78, 0x3C, 0x06, 0x30, 0x03, 0x80, 0x60, 0x08, 0xC0, 0x18, 0x01,
  0x80, 0x26, 0x00, 0xC0, 0x06, 0x00, 0xD8, 0x06, 0x00, 0x18, 0x02, 0x40,
  0x18, 0x00, 0xC0, 0x0B, 0x00, 0xC0, 0x03, 0x00, 0x6C, 0x03, 0x00, 0x0C,
  0x01, 0xB0, 0x08, 0x00, 0x20, 0x06, 0xC0, 0x60, 0x01, 0x80, 0x1B, 0x01,
  0x80, 0x06, 0x00, 0xCC, 0x06, 0x00, 0x38, 0x03, 0x30, 0x18, 0x00, 0xE0,
  0x1C, 0xC0, 0x60, 0x07, 0x00, 0x63, 0x01, 0x80, 0x16, 0x03, 0x0C, 0x03,
  0x01, 0xD8, 0x1C, 0x30, 0x0E, 0x0E, 0x70, 0xE0, 0xC0, 0x1F, 0xE0, 0xFE,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x40, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x70, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x30, 0x01, 0xE0, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x38, 0x0C, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x60,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80,
  0x07, 0xC1, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x60,
  0x00, 0xF0, 0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x78, 0x01, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x10, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x3F, 0xF9, 0x80, 0x03, 0xFF, 0xCC, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04,
  0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0x78, 0x00, 0x38, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x83, 0xC0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x70,
  0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0xC0, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x06, 0x78, 0x00,
  0x00, 0x33, 0x30, 0x00, 0x00, 0xD8, 0xC0, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1A, 0x00,
  0x00, 0x06, 0xC0, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x01, 0x98, 0x06, 0x60,
  0x00, 0x06, 0x30, 0x0C, 0x40, 0x00, 0x18, 0xC0, 0x10, 0xC0, 0x00, 0x31,
  0x80, 0x61, 0x80, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x01, 0x86,
  0x00, 0x06, 0x0C, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x04, 0x08, 0x00, 0x30,
  0x60, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x01, 0x81, 0x80, 0x60,
  0x60, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0x30,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x30,
  0x06, 0x01, 0x80, 0x30, 0xC0, 0x0C, 0x03, 0x00, 0x21, 0x80, 0x18, 0x06,
  0x00, 0x66, 0x00, 0x60, 0x0C, 0x00, 0xCC, 0x00, 0xC0, 0x30, 0x01, 0xB0,
  0x01, 0x80, 0x60, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x80, 0x04, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x02, 0x01, 0xE0,
  0x00, 0x06, 0x01, 0xE0, 0x00, 0x06, 0x01, 0xB0, 0x00, 0x06, 0x01, 0x30,
  0x00, 0x06, 0x03, 0x18, 0x00, 0x0C, 0x03, 0x18, 0x00, 0x0C, 0x03, 0x08,
  0x00, 0x0C, 0x03, 0x0C, 0x00, 0x0C, 0x03, 0x0C, 0x00, 0x0C, 0x06, 0x06,
  0x00, 0x18, 0x06, 0x06, 0x00, 0x18, 0x06, 0x03, 0x00, 0x18, 0x06, 0x03,
  0x00, 0x18, 0x04, 0x03, 0x00, 0x10, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x18, 0x00,
  0x60, 0x60, 0x18, 0x00, 0x60, 0x60, 0x18, 0x00, 0x60, 0x60, 0x18, 0x00,
  0x30, 0x60, 0x18, 0x00, 0x30, 0x60, 0x30, 0x00, 0x18, 0xC0, 0x30, 0x00,
  0x18, 0xC0, 0x30, 0x00, 0x18, 0xC0, 0x30, 0x00, 0x0C, 0xC0, 0x30, 0x00,
  0x0C, 0xC0, 0x60, 0x00, 0x07, 0x80, 0x60, 0x00, 0x07, 0x80, 0x60, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x1C, 0x01, 0xE0, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07,
  0x03, 0x00, 0x03, 0x80, 0xC0, 0x03, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1C, 0x01,
  0xE0, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x70, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0C, 0x03, 0x00, 0x07,
  0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x01, 0xE0, 0x3F, 0x0F,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x39, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x07,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x40, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x08, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00,
  0x6C, 0x00, 0x05, 0x80, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00,
  0x36, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00,
  0x61, 0x80, 0x06, 0x30, 0x00, 0xC1, 0x00, 0x0C, 0x60, 0x03, 0x02, 0x00,
  0x30, 0xC0, 0x06, 0x04, 0x00, 0x60, 0x80, 0x1C, 0x0C, 0x01, 0x81, 0x00,
  0x30, 0x18, 0x03, 0x02, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00,
  0x4C, 0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00,
  0x16, 0x00, 0x02, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x04, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02,
  0x03, 0x03, 0x03, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x08,
  0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1,
  0x83, 0x0C, 0x18, 0x20, 0xC1, 0x00, 0x1F, 0x83, 0x00, 0xFF, 0xC3, 0x01,
  0xC0, 0x63, 0x03, 0x80, 0x32, 0x07, 0x00, 0x16, 0x0E, 0x00, 0x1E, 0x0C,
  0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x60, 0x00, 0xB0, 0x60,
  0x01, 0x20, 0x70, 0x03, 0x60, 0x38, 0x0E, 0x60, 0x1E, 0x38, 0x60, 0x0F,
  0xF0, 0x40, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x07, 0xE0, 0x06, 0x1F, 0xF8, 0x06, 0x30, 0x1C, 0x04,
  0xE0, 0x0C, 0x0C, 0x80, 0x06, 0x0D, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x18, 0x50, 0x00, 0x30, 0xD0, 0x00, 0x70, 0xD8,
  0x00, 0xE0, 0xCC, 0x01, 0xC0, 0xC7, 0x8F, 0x80, 0x83, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xC0, 0x30, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x01, 0x01, 0xE1, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xC0, 0xC0, 0x0F, 0xFE, 0x18, 0x03, 0x80, 0xE6, 0x00,
  0xE0, 0x06, 0xC0, 0x30, 0x00, 0x58, 0x0E, 0x00, 0x0B, 0x01, 0x80, 0x01,
  0xC0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80,
  0x60, 0x00, 0xD0, 0x0C, 0x00, 0x36, 0x01, 0xC0, 0x0C, 0xC0, 0x1C, 0x03,
  0x18, 0x01, 0xE3, 0xC2, 0x00, 0x1F, 0xE0, 0x40, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xC0, 0xE0, 0x70, 0x07, 0x0E, 0x00,
  0x30, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x76, 0x00,
  0x06, 0x60, 0x01, 0xC6, 0x00, 0x78, 0xC0, 0x7E, 0x0F, 0xFF, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x01, 0x81, 0xF0, 0xF8, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0xC0, 0x1F, 0xFC, 0x30, 0x0E, 0x03, 0x88, 0x07, 0x00, 0x36,
  0x03, 0x80, 0x05, 0x81, 0xC0, 0x01, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00,
  0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x3C, 0x0C, 0x00, 0x1E, 0x03, 0x00,
  0x0D, 0x80, 0xE0, 0x06, 0x60, 0x1C, 0x03, 0x18, 0x03, 0xC7, 0x84, 0x00,
  0x7F, 0x83, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x02, 0x00, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x3F, 0x00, 0x61, 0xFF, 0x80, 0xC6, 0x03, 0x81, 0x38,
  0x03, 0x06, 0x40, 0x03, 0x0D, 0x00, 0x06, 0x1E, 0x00, 0x0C, 0x38, 0x00,
  0x18, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x00, 0x00, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x03, 0x06, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0x40, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x61,
  0xC0, 0x01, 0x8E, 0x00, 0x04, 0x78, 0x00, 0x33, 0xE0, 0x00, 0xD9, 0xC0,
  0x03, 0xC3, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0x18, 0x01, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x06, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x0F,
  0xC0, 0x0F, 0xC0, 0x18, 0xFF, 0xC0, 0xFF, 0xC0, 0x47, 0x03, 0x07, 0x03,
  0x81, 0x30, 0x06, 0x30, 0x06, 0x0D, 0x80, 0x19, 0x80, 0x18, 0x34, 0x00,
  0x6C, 0x00, 0x60, 0xE0, 0x01, 0xA0, 0x00, 0xC3, 0x80, 0x07, 0x80, 0x06,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x70, 0x00, 0x61, 0x80, 0x01,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x80, 0x00, 0xC6,
  0x00, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60,
  0x00, 0x61, 0x80, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x00,
  0x03, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x03, 0xF0, 0x03, 0x0F,
  0xFC, 0x02, 0x3C, 0x0E, 0x02, 0x70, 0x06, 0x06, 0xE0, 0x03, 0x06, 0x80,
  0x03, 0x07, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x30, 0xE0, 0x00, 0x30, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x01, 0x8E, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00,
  0x01, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0x3C, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0xFC, 0x00, 0x18, 0x7F, 0xE0, 0x02, 0x18, 0x0E, 0x00,
  0x4E, 0x00, 0xC0, 0x1B, 0x00, 0x0C, 0x03, 0x40, 0x01, 0x80, 0x78, 0x00,
  0x18, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30,
  0x14, 0x00, 0x0C, 0x02, 0x80, 0x03, 0x80, 0xD8, 0x00, 0xE0, 0x19, 0x80,
  0x38, 0x03, 0x1E, 0x3E, 0x00, 0x61, 0xFF, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x81, 0x80, 0x7F, 0xF0, 0xC0, 0x70, 0x1C, 0x40, 0x70,
  0x03, 0x60, 0x70, 0x00, 0xB0, 0x70, 0x00, 0x58, 0x30, 0x00, 0x38, 0x30,
  0x00, 0x0C, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E,
  0x0C, 0x00, 0x07, 0x06, 0x00, 0x07, 0x83, 0x00, 0x07, 0x81, 0x80, 0x06,
  0xC0, 0xE0, 0x06, 0x60, 0x38, 0x06, 0x30, 0x0F, 0x1E, 0x10, 0x03, 0xFC,
  0x18, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x06, 0x07, 0xC1, 0x87, 0xF0, 0x47, 0x00, 0x13, 0x80,
  0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1C, 0x03, 0x86,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x80, 0x0E, 0x1F, 0x07, 0x81, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x7F, 0x80, 0x20, 0x00, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x1E, 0x18,
  0x00, 0x2C, 0x30, 0x00, 0xD8, 0x60, 0x03, 0x20, 0xE0, 0x1C, 0xC0, 0xF0,
  0xF1, 0x80, 0xFF, 0x83, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x1D, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x0C, 0x08, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03,
  0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x01, 0x01,
  0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x27, 0x00, 0x00, 0x98, 0x00, 0x03,
  0x40, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x06, 0xC0,
  0x07, 0x80, 0x0C, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x0D, 0x80, 0x1C, 0xC0,
  0x0D, 0x80, 0x18, 0xC0, 0x19, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x30, 0xC0,
  0x30, 0x80, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0,
  0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0xC0, 0xC1, 0x80, 0x41,
  0x80, 0xC1, 0x80, 0x61, 0x80, 0xC3, 0x00, 0x63, 0x00, 0xC3, 0x00, 0x63,
  0x00, 0x46, 0x00, 0x66, 0x00, 0x46, 0x00, 0x66, 0x00, 0x6C, 0x00, 0x6C,
  0x00, 0x6C, 0x00, 0x6C, 0x00, 0x68, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC1,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x02, 0xFF, 0xE0,
  0x0F, 0x00, 0xF0, 0x34, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 36, 11, 1, -36 },
  { 51, 12, 13, 16, 5, -36 },
  { 71, 30, 36, 31, 2, -36 },
  { 206, 24, 41, 28, 2, -38 },
  { 329, 32, 37, 39, 4, -36 },
  { 477, 30, 37, 34, 2, -36 },
  { 616, 5, 13, 9, 5, -36 },
  { 625, 14, 44, 13, 2, -36 },
  { 702, 14, 44, 13, -3, -36 },
  { 779, 21, 22, 27, 6, -38 },
  { 837, 23, 23, 29, 4, -29 },
  { 904, 7, 12, 10, -2, -6 },
  { 915, 12, 1, 16, 2, -14 },
  { 917, 4, 3, 11, 1, -3 },
  { 919, 22, 36, 16, -2, -36 },
  { 1018, 23, 37, 28, 3, -36 },
  { 1125, 13, 36, 28, 8, -36 },
  { 1184, 26, 36, 28, 0, -36 },
  { 1301, 25, 37, 28, 1, -36 },
  { 1417, 26, 36, 28, 1, -36 },
  { 1534, 25, 37, 28, 2, -36 },
  { 1650, 24, 37, 28, 3, -36 },
  { 1761, 23, 36, 28, 5, -36 },
  { 1865, 25, 37, 28, 2, -36 },
  { 1981, 24, 37, 28, 2, -36 },
  { 2092, 9, 27, 11, 1, -27 },
  { 2123, 12, 33, 11, -2, -27 },
  { 2173, 23, 23, 29, 4, -30 },
  { 2240, 23, 12, 29, 4, -24 },
  { 2275, 23, 23, 29, 4, -30 },
  { 2342, 17, 36, 20, 4, -36 },
  { 2419, 38, 40, 42, 3, -35 },
  { 2609, 28, 36, 28, -3, -36 },
  { 2735, 27, 36, 30, 2, -36 },
  { 2857, 28, 37, 30, 4, -36 },
  { 2987, 30, 36, 34, 2, -36 },
  { 3122, 26, 36, 27, 2, -36 },
  { 3239, 26, 36, 24, 2, -36 },
  { 3356, 29, 37, 34, 4, -36 },
  { 3491, 32, 36, 34, 2, -36 },
  { 3635, 17, 36, 14, 0, -36 },
  { 3712, 20, 45, 12, -8, -36 },
  { 3825, 30, 36, 27, 2, -36 },
  { 3960, 19, 36, 24, 2, -36 },
  { 4046, 39, 36, 41, 2, -36 },
  { 4222, 32, 36, 34, 2, -36 },
  { 4366, 30, 37, 36, 4, -36 },
  { 4505, 26, 36, 28, 2, -36 },
  { 4622, 30, 45, 36, 4, -36 },
  { 4791, 26, 36, 28, 2, -36 },
  { 4908, 25, 37, 25, 1, -36 },
  { 5024, 24, 36, 24, 5, -36 },
  { 5132, 31, 37, 34, 4, -36 },
  { 5276, 26, 36, 27, 5, -36 },
  { 5393, 39, 36, 42, 6, -36 },
  { 5569, 32, 36, 25, -3, -36 },
  { 5713, 24, 36, 25, 5, -36 },
  { 5821, 29, 36, 27, 0, -36 },
  { 5952, 18, 44, 15, 0, -36 },
  { 6051, 8, 36, 16, 5, -36 },
  { 6087, 19, 44, 15, -4, -36 },
  { 6192, 24, 22, 28, 2, -36 },
  { 6258, 19, 2, 19, -4, 5 },
  { 6263, 6, 8, 12, 7, -38 },
  { 6269, 24, 28, 28, 2, -27 },
  { 6353, 24, 39, 29, 2, -38 },
  { 6470, 20, 28, 23, 3, -27 },
  { 6540, 27, 39, 29, 2, -38 },
  { 6672, 20, 28, 25, 3, -27 },
  { 6742, 27, 50, 14, -6, -38 },
  { 6911, 26, 39, 29, 1, -27 },
  { 7038, 23, 38, 28, 2, -38 },
  { 7148, 9, 36, 11, 2, -36 },
  { 7189, 18, 48, 11, -7, -36 },
  { 7297, 22, 38, 23, 2, -38 },
  { 7402, 10, 38, 11, 2, -38 },
  { 7450, 38, 27, 42, 2, -27 },
  { 7579, 24, 27, 28, 1, -27 },
  { 7660, 23, 28, 28, 3, -27 },
  { 7741, 27, 39, 29, -1, -27 },
  { 7873, 25, 39, 29, 2, -27 },
  { 7995, 18, 27, 19, 2, -27 },
  { 8056, 19, 28, 21, 1, -27 },
  { 8123, 14, 34, 16, 3, -33 },
  { 8183, 23, 28, 28, 3, -27 },
  { 8264, 22, 27, 21, 2, -27 },
  { 8339, 32, 27, 33, 3, -27 },
  { 8447, 26, 27, 23, -2, -27 },
  { 8535, 30, 39, 21, -6, -27 },
  { 8682, 23, 27, 22, -1, -27 },
  { 8760, 18, 44, 17, 1, -36 },
  { 8859, 2, 50, 27, 14, -38 },
  { 8872, 18, 44, 17, -2, -36 },
  { 8971, 23, 5, 29, 4, -20 },
};

const GFXfont NotoSans_ExtraLightItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRALIGHTITALIC50PT7B_H_
