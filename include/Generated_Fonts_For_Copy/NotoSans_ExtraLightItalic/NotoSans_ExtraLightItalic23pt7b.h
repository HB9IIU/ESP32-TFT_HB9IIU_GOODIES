#ifndef _NOTOSANS_EXTRALIGHTITALIC23PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x00, 0x88, 0xCC, 0x65, 0x29,
  0x48, 0x02, 0x10, 0x21, 0x01, 0x08, 0x08, 0x40, 0x42, 0x3D, 0xEC, 0x21,
  0x01, 0x08, 0x10, 0x80, 0x84, 0x3F, 0xFC, 0x21, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x08, 0x40, 0x01, 0x00, 0x60, 0x37, 0x89, 0x02, 0x20, 0x44, 0x08,
  0x80, 0xA0, 0x0C, 0x00, 0xE0, 0x12, 0x02, 0x20, 0x88, 0x11, 0x22, 0x43,
  0xF0, 0x08, 0x02, 0x00, 0x18, 0x04, 0x48, 0x11, 0x08, 0x42, 0x10, 0x88,
  0x22, 0x10, 0x88, 0x21, 0x20, 0x42, 0x5E, 0x89, 0x45, 0x14, 0x85, 0xD2,
  0x08, 0x24, 0x20, 0x88, 0x42, 0x10, 0x84, 0x21, 0x10, 0x44, 0x40, 0x70,
  0x03, 0x80, 0x11, 0x00, 0x82, 0x02, 0x08, 0x10, 0x20, 0x21, 0x00, 0x88,
  0x01, 0xC0, 0x0C, 0x00, 0xC8, 0x14, 0x10, 0xA0, 0x22, 0x80, 0x92, 0x01,
  0x88, 0x06, 0x10, 0x28, 0x7F, 0x18, 0xEA, 0xA0, 0x04, 0x21, 0x08, 0x21,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x04,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82,
  0x04, 0x10, 0x40, 0x86, 0x00, 0x04, 0x02, 0x22, 0x0D, 0x01, 0xF8, 0xC0,
  0x91, 0x88, 0x02, 0x00, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC1, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x24, 0xA5, 0x00, 0xF8, 0xC0, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x03, 0x81, 0x88, 0x40, 0x88, 0x12,
  0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x28, 0x04,
  0x81, 0x10, 0x22, 0x08, 0x3E, 0x00, 0x1C, 0xAC, 0xA2, 0x08, 0x41, 0x04,
  0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x03, 0x80, 0xC6, 0x08, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0xFF, 0xC0, 0x03, 0xC0, 0xC2, 0x10,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x0C, 0x0F, 0x00, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x48, 0x0C, 0x7F, 0x00, 0x00, 0x30,
  0x06, 0x00, 0xA0, 0x12, 0x02, 0x20, 0x42, 0x08, 0x40, 0x84, 0x10, 0x42,
  0x04, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x0F, 0xE2,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x0F, 0xC0, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x20, 0x47, 0xF0, 0x03, 0xE1, 0x80, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0xF8, 0xE0, 0x90, 0x12, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x20, 0x44, 0x18, 0x7C, 0x00, 0x7F, 0xE0, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0x03, 0x81, 0x88, 0x40, 0x88, 0x11,
  0x02, 0x20, 0x44, 0x10, 0x4C, 0x0E, 0x06, 0x31, 0x02, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x12, 0x04, 0x3F, 0x00, 0x07, 0x01, 0x18, 0x41, 0x10, 0x12,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x20, 0x66, 0x38, 0x39, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x02, 0x40, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x08, 0x44, 0x22, 0x00, 0x00, 0x40, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x18, 0x18, 0x18, 0x18, 0x08, 0x00, 0x3C, 0x42, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x30, 0x20, 0x40, 0x40, 0x00, 0x00,
  0x80, 0x80, 0x03, 0xFC, 0x01, 0x00, 0xC0, 0x80, 0x08, 0x40, 0x02, 0x20,
  0x70, 0x90, 0x62, 0x14, 0x20, 0x85, 0x10, 0x21, 0x84, 0x10, 0x61, 0x04,
  0x28, 0x41, 0x0A, 0x10, 0xC4, 0x84, 0xD2, 0x10, 0xC3, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x05, 0x00, 0x28,
  0x02, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0x7F, 0x84,
  0x04, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x50, 0x01, 0x1F, 0xE1, 0x01,
  0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x63, 0xF8, 0x20, 0x44, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x06, 0x80, 0xCF, 0xF0, 0x01, 0xE0, 0x30,
  0xC6, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x40, 0x41, 0x00, 0x84, 0x02, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x31,
  0x01, 0x88, 0x18, 0x3F, 0x80, 0x1F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x03, 0xFC, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x3F, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x01, 0xE0, 0x30, 0xC6, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x0F, 0xA0, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x11, 0x00, 0x8C, 0x04, 0x1F, 0xC0, 0x18, 0x06, 0x20,
  0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x1F, 0xFC,
  0x20, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x20,
  0x08, 0x40, 0x10, 0x1F, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xF0, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x83, 0xC0, 0x18, 0x1C, 0x40, 0x81,
  0x04, 0x04, 0x20, 0x21, 0x00, 0x88, 0x02, 0x40, 0x0F, 0x00, 0x22, 0x01,
  0x08, 0x04, 0x10, 0x10, 0x40, 0x40, 0x81, 0x02, 0x08, 0x04, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0xFF, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80,
  0x28, 0x50, 0x0A, 0x24, 0x04, 0x89, 0x01, 0x42, 0x40, 0x90, 0x90, 0x24,
  0x24, 0x11, 0x10, 0x88, 0x44, 0x22, 0x21, 0x09, 0x08, 0x42, 0x42, 0x10,
  0xA0, 0x88, 0x10, 0x22, 0x04, 0x10, 0x18, 0x06, 0x30, 0x08, 0x50, 0x10,
  0xA0, 0x22, 0x40, 0x44, 0x41, 0x08, 0x82, 0x10, 0x84, 0x21, 0x08, 0x81,
  0x11, 0x02, 0x42, 0x04, 0x84, 0x05, 0x08, 0x0A, 0x20, 0x08, 0x40, 0x10,
  0x03, 0xC0, 0x30, 0xC1, 0x01, 0x88, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00,
  0x44, 0x02, 0x18, 0x10, 0x1F, 0x80, 0x1F, 0xE1, 0x02, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x22, 0x04, 0x3F, 0x84, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x03, 0xC0, 0x30, 0xC1, 0x01, 0x88,
  0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x44, 0x02, 0x18, 0x10, 0x1F, 0x80,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x1F, 0xE1, 0x02, 0x10, 0x11,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x0C, 0x3F, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x40, 0x84, 0x08, 0x80, 0x48, 0x04, 0x03, 0xC0, 0xC3, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x08, 0x7F, 0x00, 0xFF, 0xE0, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x88, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01, 0x04, 0x0C, 0x0F, 0xC0, 0x80,
  0x14, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x02, 0x20, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x30, 0x03, 0x00, 0x80,
  0x80, 0xE0, 0x60, 0x28, 0x14, 0x12, 0x09, 0x04, 0x82, 0x41, 0x21, 0x10,
  0x88, 0x44, 0x22, 0x21, 0x10, 0x88, 0x44, 0x22, 0x12, 0x09, 0x04, 0x82,
  0x41, 0x40, 0xA0, 0x50, 0x28, 0x18, 0x0C, 0x06, 0x01, 0x01, 0x00, 0x08,
  0x0C, 0x20, 0x20, 0x41, 0x01, 0x08, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x00,
  0x40, 0x03, 0x00, 0x12, 0x00, 0x88, 0x04, 0x20, 0x10, 0x40, 0x81, 0x04,
  0x02, 0x20, 0x08, 0x80, 0x28, 0x09, 0x02, 0x20, 0x42, 0x10, 0x44, 0x09,
  0x01, 0x20, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x1F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x1F, 0xF8, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xF0, 0x84,
  0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x11, 0x0F, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x1F, 0x00, 0x01, 0x00, 0x60, 0x14, 0x02, 0x40,
  0x88, 0x21, 0x04, 0x11, 0x02, 0x40, 0x48, 0x0A, 0x00, 0x80, 0xFF, 0x80,
  0x89, 0x10, 0x1F, 0xA6, 0x14, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x14,
  0x04, 0x80, 0x90, 0x31, 0x0A, 0x3E, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x5F, 0x8C, 0x11, 0x01, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x05, 0x80, 0xB0, 0x26, 0x0C, 0xBE, 0x00, 0x0F, 0xCC, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0xFC, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x21, 0xFA, 0x30, 0x62, 0x06, 0x40, 0x64,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x81, 0x84, 0x28, 0x7C, 0x80,
  0x0F, 0x84, 0x22, 0x05, 0x02, 0x41, 0x9F, 0x88, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0xFC, 0x00, 0x30, 0x06, 0x40, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x3F, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x02, 0xC0, 0x08, 0x00, 0x1F, 0xA6, 0x0C, 0x81, 0xA0, 0x34,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x31, 0x0A, 0x3E, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0xCC, 0x06, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x09, 0xF3, 0x84, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60,
  0x28, 0x0A, 0x02, 0x80, 0x80, 0x11, 0x00, 0x02, 0x22, 0x44, 0x44, 0x48,
  0x88, 0x80, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0xA0,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x32, 0x10, 0x88, 0x44,
  0x12, 0x05, 0x81, 0xA0, 0x44, 0x21, 0x08, 0x22, 0x08, 0x81, 0x00, 0x11,
  0x11, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x80, 0x2F, 0x8F, 0x98, 0x28,
  0x48, 0x18, 0x24, 0x08, 0x14, 0x04, 0x0A, 0x04, 0x05, 0x02, 0x02, 0x81,
  0x02, 0x80, 0x81, 0x40, 0x40, 0xA0, 0x40, 0x50, 0x20, 0x40, 0x27, 0xC7,
  0x08, 0x80, 0xB0, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x40, 0x1F, 0x86, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x60,
  0x0C, 0x02, 0x80, 0x50, 0x11, 0x06, 0x1F, 0x00, 0x13, 0xE1, 0xC2, 0x10,
  0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x60, 0x26, 0x04, 0x60,
  0xC5, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x1F, 0xA6,
  0x0C, 0x81, 0xA0, 0x34, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x31,
  0x0A, 0x3E, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x2F, 0x30,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x90,
  0x08, 0x04, 0x03, 0x00, 0x40, 0x18, 0x02, 0x01, 0x00, 0xA0, 0x5F, 0xC0,
  0x10, 0x20, 0x87, 0xF2, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x1C, 0x00, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x80, 0x90, 0x14,
  0x04, 0x80, 0x90, 0x32, 0x0A, 0x3E, 0x40, 0x80, 0xE0, 0x28, 0x11, 0x04,
  0x42, 0x10, 0x84, 0x41, 0x20, 0x48, 0x14, 0x03, 0x00, 0x80, 0x81, 0x03,
  0x06, 0x0A, 0x0C, 0x14, 0x28, 0x48, 0x48, 0x89, 0x12, 0x12, 0x24, 0x28,
  0x50, 0x50, 0xA0, 0xC1, 0x41, 0x83, 0x02, 0x06, 0x00, 0x10, 0x30, 0x84,
  0x08, 0x40, 0x48, 0x05, 0x00, 0x20, 0x06, 0x00, 0x90, 0x11, 0x02, 0x08,
  0x20, 0x8C, 0x0C, 0x08, 0x0C, 0x20, 0x20, 0x41, 0x01, 0x04, 0x04, 0x20,
  0x10, 0x80, 0x44, 0x01, 0x10, 0x04, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x90, 0x01, 0x00, 0x00, 0x3F,
  0xC0, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04,
  0x03, 0xFC, 0x07, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0,
  0x40, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x30, 0xFF, 0xFF,
  0xFE, 0x0E, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x03, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x80, 0xF8, 0x61, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 5, 6, 8, 3, -16 },
  { 13, 13, 16, 14, 1, -16 },
  { 39, 11, 18, 13, 1, -17 },
  { 64, 15, 17, 18, 2, -17 },
  { 96, 14, 17, 16, 1, -17 },
  { 126, 2, 6, 4, 3, -16 },
  { 128, 6, 20, 6, 1, -16 },
  { 143, 7, 20, 6, -2, -16 },
  { 161, 9, 9, 12, 3, -17 },
  { 172, 10, 10, 13, 2, -13 },
  { 185, 3, 6, 5, -1, -3 },
  { 188, 5, 1, 7, 1, -7 },
  { 189, 1, 2, 5, 1, -2 },
  { 190, 10, 16, 7, -1, -16 },
  { 210, 11, 17, 13, 1, -17 },
  { 234, 6, 16, 13, 4, -16 },
  { 246, 12, 17, 13, 0, -17 },
  { 272, 12, 17, 13, 0, -17 },
  { 298, 12, 16, 13, 0, -16 },
  { 322, 11, 16, 13, 1, -16 },
  { 344, 11, 17, 13, 2, -17 },
  { 368, 11, 16, 13, 2, -16 },
  { 390, 11, 17, 13, 1, -17 },
  { 414, 11, 17, 13, 1, -17 },
  { 438, 3, 12, 5, 1, -12 },
  { 443, 5, 15, 5, -1, -12 },
  { 453, 10, 11, 13, 2, -14 },
  { 467, 10, 6, 13, 2, -11 },
  { 475, 10, 11, 13, 2, -14 },
  { 489, 8, 17, 9, 2, -17 },
  { 506, 18, 18, 19, 1, -16 },
  { 547, 13, 16, 13, -1, -16 },
  { 573, 12, 16, 14, 1, -16 },
  { 597, 13, 17, 14, 2, -17 },
  { 625, 14, 16, 16, 1, -16 },
  { 653, 12, 16, 12, 1, -16 },
  { 677, 12, 16, 11, 1, -16 },
  { 701, 13, 17, 16, 2, -17 },
  { 729, 15, 16, 16, 1, -16 },
  { 759, 8, 16, 7, 0, -16 },
  { 775, 10, 20, 6, -4, -16 },
  { 800, 14, 16, 13, 1, -16 },
  { 828, 9, 16, 11, 1, -16 },
  { 846, 18, 16, 19, 1, -16 },
  { 882, 15, 16, 16, 1, -16 },
  { 912, 14, 17, 16, 2, -17 },
  { 942, 12, 16, 13, 1, -16 },
  { 966, 14, 21, 16, 2, -17 },
  { 1003, 12, 16, 13, 1, -16 },
  { 1027, 12, 17, 11, 0, -17 },
  { 1053, 11, 16, 11, 2, -16 },
  { 1075, 14, 16, 16, 2, -16 },
  { 1103, 12, 16, 12, 2, -16 },
  { 1127, 18, 16, 19, 3, -16 },
  { 1163, 14, 16, 11, -1, -16 },
  { 1191, 11, 16, 11, 2, -16 },
  { 1213, 13, 16, 12, 0, -16 },
  { 1239, 8, 20, 7, 0, -16 },
  { 1259, 4, 16, 7, 2, -16 },
  { 1267, 9, 20, 7, -2, -16 },
  { 1290, 11, 11, 13, 1, -17 },
  { 1306, 9, 1, 9, -2, 2 },
  { 1308, 3, 4, 5, 3, -18 },
  { 1310, 11, 12, 13, 1, -12 },
  { 1327, 11, 17, 13, 1, -17 },
  { 1351, 10, 12, 10, 1, -12 },
  { 1366, 12, 17, 13, 1, -17 },
  { 1392, 10, 12, 11, 1, -12 },
  { 1407, 13, 24, 6, -3, -18 },
  { 1446, 11, 18, 13, 1, -12 },
  { 1471, 10, 17, 13, 1, -17 },
  { 1493, 4, 17, 5, 1, -17 },
  { 1502, 8, 23, 5, -3, -17 },
  { 1525, 10, 17, 10, 1, -17 },
  { 1547, 4, 17, 5, 1, -17 },
  { 1556, 17, 12, 20, 1, -12 },
  { 1582, 11, 12, 13, 1, -12 },
  { 1599, 11, 12, 13, 1, -12 },
  { 1616, 12, 17, 13, 0, -12 },
  { 1642, 11, 17, 13, 1, -12 },
  { 1666, 8, 12, 9, 1, -12 },
  { 1678, 9, 12, 10, 0, -12 },
  { 1692, 7, 15, 7, 1, -15 },
  { 1706, 11, 12, 13, 1, -12 },
  { 1723, 10, 12, 10, 1, -12 },
  { 1738, 15, 12, 15, 1, -12 },
  { 1761, 12, 12, 11, -1, -12 },
  { 1779, 14, 18, 10, -3, -12 },
  { 1811, 10, 12, 10, 0, -12 },
  { 1826, 8, 20, 8, 1, -16 },
  { 1846, 1, 23, 12, 6, -17 },
  { 1849, 8, 20, 8, -1, -16 },
  { 1869, 10, 2, 13, 2, -9 },
};

const GFXfont NotoSans_ExtraLightItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRALIGHTITALIC23PT7B_H_
