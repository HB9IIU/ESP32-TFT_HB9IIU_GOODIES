#ifndef _NOTOSANS_EXTRALIGHTITALIC58PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x08, 0x00, 0x1C,
  0x1C, 0x60, 0x71, 0x81, 0x8E, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x03, 0x0C,
  0x0C, 0x60, 0x31, 0x80, 0xC6, 0x02, 0x18, 0x18, 0x40, 0x61, 0x01, 0x8C,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x02, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xC6, 0x1F, 0x01, 0xE0, 0xC0, 0x40, 0x70, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1E, 0x20,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x8F, 0x00, 0x00, 0x30, 0x70, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x38,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x81, 0x00, 0x60, 0xE0, 0x3C, 0x0C,
  0x78, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x20, 0x1F, 0xF0,
  0x00, 0x06, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x07, 0x01,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x0E, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x03, 0x80, 0x30, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x1C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x0C,
  0x0E, 0x00, 0x18, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x60, 0xFE, 0x30, 0x03, 0x87, 0x0F, 0xF9, 0x80, 0x18, 0x30,
  0xE0, 0xEC, 0x01, 0xC3, 0x0C, 0x03, 0x70, 0x0C, 0x30, 0xE0, 0x19, 0x80,
  0xC3, 0x86, 0x00, 0xEE, 0x1C, 0x18, 0x60, 0x07, 0x3F, 0xC1, 0x83, 0x00,
  0x38, 0xFC, 0x18, 0x38, 0x01, 0xC0, 0x01, 0xC1, 0x80, 0x0E, 0x00, 0x0C,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x30, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x70, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x38, 0x00, 0x38, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x18, 0x00,
  0x07, 0x9E, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x1C, 0x00, 0xE0, 0x01, 0x8E, 0x00,
  0x18, 0x00, 0x67, 0x00, 0x07, 0x00, 0x31, 0x80, 0x00, 0xE0, 0x1C, 0xE0,
  0x00, 0x18, 0x06, 0x30, 0x00, 0x03, 0x03, 0x8C, 0x00, 0x00, 0xE1, 0xC3,
  0x00, 0x00, 0x1C, 0xE0, 0xC0, 0x00, 0x03, 0x30, 0x30, 0x00, 0x00, 0x78,
  0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x07,
  0x60, 0x38, 0x00, 0x03, 0x9C, 0x07, 0x00, 0x03, 0xC3, 0x80, 0xF0, 0x03,
  0xC0, 0x60, 0x1F, 0xDF, 0xE0, 0x1C, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18,
  0x41, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0xF0, 0x0C,
  0x00, 0x3C, 0x08, 0x00, 0x0F, 0x08, 0x00, 0x03, 0x98, 0x00, 0x00, 0xF8,
  0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x38, 0x00, 0x00, 0xE8, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0x8C, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x03,
  0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E,
  0x06, 0x06, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFE, 0x40, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x78,
  0x00, 0xE0, 0x1E, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x60, 0x78,
  0xC1, 0xE1, 0x8F, 0x07, 0x7C, 0x0C, 0x60, 0x18, 0x80, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x20, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xC0, 0x78, 0x01, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x21, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x80, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x1C,
  0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xC0, 0x20, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x07, 0xFF, 0x00, 0x31, 0xF8, 0xF8, 0x07, 0x38,
  0x01, 0xC0, 0x66, 0x00, 0x0E, 0x06, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x70,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x07, 0x8C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C,
  0x1C, 0x00, 0x0D, 0x81, 0xC0, 0x07, 0x30, 0x3C, 0x03, 0xCE, 0x01, 0xFF,
  0xE1, 0x80, 0x1F, 0xF0, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x04, 0x00, 0x78, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0x07,
  0x83, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x3E, 0x07, 0x83, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x0F, 0xFF,
  0x00, 0x71, 0xC0, 0x03, 0xF3, 0xF8, 0x03, 0x18, 0x00, 0x78, 0x03, 0x00,
  0x33, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x33,
  0x00, 0x38, 0x00, 0x60, 0x03, 0x70, 0x03, 0x00, 0x06, 0x00, 0x36, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x60, 0x0E, 0x00, 0x06, 0x00, 0x36, 0x00, 0xC0,
  0x00, 0xC0, 0x07, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0x6E, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x6C, 0x01, 0x80, 0x01, 0x80,
  0x0E, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xCC, 0x01, 0x80, 0x03, 0x80, 0x1C,
  0xC0, 0x18, 0x00, 0x78, 0x01, 0x8C, 0x01, 0xC0, 0x07, 0x80, 0x38, 0xE0,
  0x0C, 0x00, 0xD8, 0x07, 0x06, 0x00, 0xE0, 0x19, 0x80, 0xE0, 0x60, 0x07,
  0x07, 0x0E, 0x3C, 0x06, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x70, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x03, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x0F,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xC0, 0x03, 0xF0,
  0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1E, 0x06, 0x00,
  0x00, 0x78, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x3F, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x06, 0x00,
  0x00, 0x1E, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x0F, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFC, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0x8C, 0x00, 0x03, 0xFF, 0xE3, 0x00, 0x01, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x80, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x00, 0x3B, 0x98, 0x00, 0x00, 0x0D,
  0xC7, 0x00, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x36, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x60, 0x19, 0x80, 0x00,
  0x00, 0x6E, 0x01, 0x98, 0x00, 0x00, 0x0E, 0xE0, 0x19, 0x80, 0x00, 0x00,
  0xCC, 0x01, 0x98, 0x00, 0x00, 0x1C, 0xC0, 0x39, 0x80, 0x00, 0x01, 0x8C,
  0x03, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x30, 0xC0, 0x00, 0x07, 0x18, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x00, 0x0E, 0x18, 0x07, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x00, 0x18, 0x38, 0x06, 0x0E, 0x00,
  0x03, 0x83, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x06, 0x06, 0x00, 0x07,
  0x03, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x0C, 0x07,
  0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x0C, 0x07, 0x00, 0x18, 0x06, 0x01,
  0xC0, 0x30, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x30, 0x0E, 0x01, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0xC0, 0x38, 0x03, 0x81, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x18,
  0x01, 0xC0, 0x30, 0x01, 0x83, 0x80, 0x18, 0x03, 0x00, 0x18, 0x30, 0x01,
  0x80, 0x30, 0x01, 0x86, 0x00, 0x18, 0x07, 0x00, 0x18, 0xE0, 0x01, 0x80,
  0x60, 0x01, 0xCC, 0x00, 0x38, 0x06, 0x00, 0x0D, 0xC0, 0x03, 0x00, 0x60,
  0x00, 0xD8, 0x00, 0x30, 0x06, 0x00, 0x0F, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xF8, 0x00,
  0x00, 0x60, 0x19, 0x80, 0x00, 0x06, 0x01, 0x98, 0x00, 0x00, 0x60, 0x18,
  0xC0, 0x00, 0x0E, 0x01, 0x8C, 0x00, 0x00, 0xC0, 0x38, 0xE0, 0x00, 0x0C,
  0x03, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x0C, 0x03, 0x03, 0x00,
  0x01, 0xC0, 0x30, 0x30, 0x00, 0x18, 0x07, 0x03, 0x80, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x18, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x38,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x06, 0x01, 0xC0,
  0x03, 0x80, 0x60, 0x1C, 0x00, 0x18, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x1C, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x38, 0x00, 0x0E,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x30, 0x00, 0x06, 0x0C, 0x03, 0x00,
  0x00, 0x31, 0xC0, 0x30, 0x00, 0x03, 0x18, 0x07, 0x00, 0x00, 0x39, 0x80,
  0x60, 0x00, 0x01, 0x98, 0x06, 0x00, 0x00, 0x1D, 0x80, 0x60, 0x00, 0x00,
  0xF8, 0x06, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0xF8, 0x01, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x80,
  0xC0, 0x00, 0xF8, 0x06, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x78, 0x01, 0x80, 0x01, 0xE0,
  0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x00, 0xC0, 0x07,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0xF0, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x73, 0x00, 0x00, 0xEC, 0x00, 0x03,
  0x1C, 0x00, 0x06, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x00, 0x01, 0x87,
  0x00, 0x03, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x38, 0xE0, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x18,
  0x18, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x63, 0x80, 0x01, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0xB8, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x07, 0x06, 0x06,
  0x00, 0x1F, 0xE0, 0x60, 0x0F, 0xFF, 0x0C, 0x07, 0x80, 0x71, 0x81, 0xE0,
  0x06, 0x60, 0x70, 0x00, 0x6C, 0x0C, 0x00, 0x0D, 0x83, 0x80, 0x00, 0xB0,
  0xE0, 0x00, 0x1E, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x3C, 0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x6C,
  0x0C, 0x00, 0x0D, 0x81, 0x80, 0x03, 0x30, 0x38, 0x01, 0xCC, 0x03, 0x80,
  0x71, 0x80, 0x3E, 0xF8, 0x30, 0x03, 0xFE, 0x06, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x1F,
  0xE0, 0x03, 0x07, 0xFF, 0x00, 0x31, 0xE0, 0x38, 0x03, 0x38, 0x01, 0xC0,
  0x77, 0x00, 0x0E, 0x06, 0x60, 0x00, 0x60, 0x6C, 0x00, 0x06, 0x07, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x70, 0x68, 0x00, 0x06, 0x06, 0xC0, 0x00, 0xE0, 0x66, 0x00, 0x1C, 0x0C,
  0x70, 0x07, 0x80, 0xC3, 0xF7, 0xE0, 0x0C, 0x0F, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xF0, 0x06, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x60, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFE, 0x06, 0x00, 0x1F, 0xFE, 0x0C,
  0x00, 0x78, 0x0E, 0x38, 0x03, 0xC0, 0x06, 0x60, 0x0E, 0x00, 0x06, 0xC0,
  0x18, 0x00, 0x0D, 0x80, 0x70, 0x00, 0x0B, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x06, 0xC0, 0x18, 0x00, 0x19, 0x80, 0x30, 0x00, 0x76,
  0x00, 0x70, 0x01, 0xCC, 0x00, 0x70, 0x0E, 0x18, 0x00, 0x7F, 0xF8, 0x30,
  0x00, 0x7F, 0xC0, 0x60, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x06,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x78,
  0x70, 0x03, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x70,
  0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x43, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x18, 0x01, 0xFF,
  0xE0, 0xC0, 0x1E, 0x03, 0x86, 0x03, 0xC0, 0x06, 0x60, 0x38, 0x00, 0x1B,
  0x01, 0x80, 0x00, 0xD8, 0x1C, 0x00, 0x02, 0xC1, 0xC0, 0x00, 0x1E, 0x0C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x03, 0xC1, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1B,
  0x01, 0x80, 0x01, 0x98, 0x0C, 0x00, 0x19, 0x80, 0x70, 0x01, 0xCC, 0x01,
  0xC0, 0x38, 0x60, 0x07, 0xEF, 0x83, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x04, 0x00,
  0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x03,
  0xFC, 0x00, 0xC1, 0xFF, 0xE0, 0x18, 0x70, 0x1E, 0x03, 0x38, 0x01, 0xC0,
  0xEE, 0x00, 0x1C, 0x19, 0x80, 0x03, 0x83, 0x60, 0x00, 0x30, 0x78, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x0C, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x43, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x1C,
  0x03, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x61, 0xE0, 0x00, 0x19, 0xD8, 0x00, 0x06, 0xE7, 0x00, 0x01, 0xF0, 0xC0,
  0x00, 0xF8, 0x38, 0x00, 0x3C, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x70, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x1C,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x03, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x30, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0x1C, 0x07, 0x07, 0x81,
  0xE0, 0x33, 0x00, 0x30, 0xE0, 0x0E, 0x06, 0x60, 0x03, 0x9C, 0x00, 0x60,
  0x6C, 0x00, 0x19, 0x80, 0x07, 0x06, 0x80, 0x01, 0xB0, 0x00, 0x70, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x30, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x87, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x86, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03,
  0x01, 0xFE, 0x00, 0x60, 0xFF, 0xF0, 0x0C, 0x78, 0x0F, 0x01, 0x9C, 0x00,
  0xE0, 0x67, 0x00, 0x0E, 0x0D, 0xC0, 0x01, 0xC1, 0xB0, 0x00, 0x18, 0x3C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x61, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x60, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x3F, 0xC0,
  0x00, 0xC1, 0xFF, 0xC0, 0x01, 0x8F, 0x01, 0xC0, 0x03, 0x38, 0x01, 0xC0,
  0x0C, 0xE0, 0x01, 0xC0, 0x1B, 0x80, 0x01, 0x80, 0x36, 0x00, 0x03, 0x00,
  0x78, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x1A, 0x00, 0x01,
  0x80, 0x36, 0x00, 0x07, 0x00, 0x66, 0x00, 0x1C, 0x01, 0xCE, 0x00, 0xF0,
  0x03, 0x0F, 0xDF, 0x80, 0x06, 0x07, 0xFE, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x30, 0x07, 0xFF, 0x83, 0x00, 0xF0,
  0x1C, 0x30, 0x3C, 0x00, 0x66, 0x07, 0x00, 0x03, 0x60, 0x60, 0x00, 0x36,
  0x0E, 0x00, 0x01, 0x61, 0xC0, 0x00, 0x1E, 0x18, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x36, 0x06, 0x00, 0x06, 0x60, 0x60, 0x00,
  0xCC, 0x07, 0x00, 0x1C, 0xC0, 0x38, 0x07, 0x0C, 0x01, 0xFB, 0xE0, 0xC0,
  0x0F, 0xF8, 0x1C, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x03, 0xF8, 0x18, 0x3F, 0xC0, 0xC7,
  0x80, 0x06, 0x70, 0x00, 0x67, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x38, 0x01, 0xC1,
  0xC0, 0x01, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x70, 0xE0, 0x03, 0x83, 0xFD,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0xDE, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x70, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x86,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x0D, 0x83, 0x80, 0x03,
  0x30, 0x30, 0x01, 0xC6, 0x07, 0x80, 0x71, 0x80, 0x7E, 0xFC, 0x30, 0x07,
  0xFE, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60,
  0x70, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x30, 0x06, 0x00, 0x38, 0x0C, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x1C, 0x00, 0x0D, 0xC0, 0x01, 0xE0, 0x00, 0x6E, 0x00, 0x0F,
  0x00, 0x06, 0x70, 0x00, 0xD8, 0x00, 0x31, 0x80, 0x06, 0xC0, 0x03, 0x0C,
  0x00, 0x66, 0x00, 0x18, 0x60, 0x03, 0x38, 0x01, 0xC3, 0x00, 0x30, 0xC0,
  0x0C, 0x18, 0x03, 0x86, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x06, 0x06, 0x01,
  0xC1, 0x80, 0x70, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x60, 0x38,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x70, 0x18, 0x1C, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x18, 0x38, 0x07, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x06,
  0x1C, 0x00, 0xC3, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xCE, 0x00, 0x31,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x37, 0x00, 0x0C, 0xC0, 0x01, 0xB0,
  0x00, 0x6E, 0x00, 0x0F, 0x80, 0x03, 0x60, 0x00, 0x78, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x21, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x27, 0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x03, 0xFF, 0xE8, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_ExtraLightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 42, 13, 2, -41 },
  { 59, 14, 15, 19, 6, -41 },
  { 86, 35, 41, 36, 2, -41 },
  { 266, 27, 47, 32, 3, -44 },
  { 425, 37, 43, 45, 5, -42 },
  { 624, 34, 43, 39, 3, -42 },
  { 807, 6, 15, 11, 6, -41 },
  { 819, 17, 50, 15, 2, -41 },
  { 926, 17, 50, 15, -4, -41 },
  { 1033, 24, 25, 31, 7, -44 },
  { 1108, 27, 27, 33, 4, -34 },
  { 1200, 9, 14, 11, -3, -7 },
  { 1216, 14, 2, 18, 2, -17 },
  { 1220, 4, 5, 13, 2, -4 },
  { 1223, 26, 41, 18, -3, -41 },
  { 1357, 27, 43, 32, 4, -42 },
  { 1503, 15, 41, 32, 9, -41 },
  { 1580, 29, 42, 32, 1, -42 },
  { 1733, 29, 43, 32, 1, -42 },
  { 1889, 30, 42, 32, 1, -42 },
  { 2047, 29, 42, 32, 2, -41 },
  { 2200, 28, 43, 32, 4, -42 },
  { 2351, 27, 41, 32, 6, -41 },
  { 2490, 28, 43, 32, 3, -42 },
  { 2641, 27, 43, 32, 3, -42 },
  { 2787, 9, 32, 13, 2, -31 },
  { 2823, 14, 38, 13, -3, -31 },
  { 2890, 27, 26, 33, 4, -34 },
  { 2978, 27, 13, 33, 4, -27 },
  { 3022, 27, 26, 33, 4, -34 },
  { 3110, 20, 43, 24, 5, -42 },
  { 3218, 44, 46, 49, 3, -41 },
  { 3471, 32, 42, 32, -3, -42 },
  { 3639, 31, 41, 35, 3, -41 },
  { 3798, 32, 43, 34, 5, -42 },
  { 3970, 34, 41, 39, 3, -41 },
  { 4145, 29, 41, 31, 3, -41 },
  { 4294, 29, 41, 28, 3, -41 },
  { 4443, 34, 43, 40, 5, -42 },
  { 4626, 36, 41, 40, 3, -41 },
  { 4811, 19, 41, 17, 0, -41 },
  { 4909, 24, 51, 14, -10, -41 },
  { 5062, 34, 41, 32, 3, -41 },
  { 5237, 21, 41, 28, 3, -41 },
  { 5345, 44, 41, 47, 3, -41 },
  { 5571, 36, 41, 40, 3, -41 },
  { 5756, 34, 43, 42, 5, -42 },
  { 5939, 29, 41, 32, 3, -41 },
  { 6088, 34, 52, 42, 5, -42 },
  { 6309, 29, 41, 33, 3, -41 },
  { 6458, 29, 43, 29, 1, -42 },
  { 6614, 29, 41, 28, 5, -41 },
  { 6763, 35, 42, 40, 5, -41 },
  { 6947, 30, 41, 31, 6, -41 },
  { 7101, 45, 41, 48, 7, -41 },
  { 7332, 36, 41, 29, -3, -41 },
  { 7517, 28, 41, 28, 6, -41 },
  { 7661, 33, 41, 31, 0, -41 },
  { 7831, 22, 50, 17, -1, -41 },
  { 7969, 9, 41, 18, 6, -41 },
  { 8016, 22, 50, 17, -4, -41 },
  { 8154, 27, 26, 32, 3, -42 },
  { 8242, 22, 2, 22, -5, 6 },
  { 8248, 7, 9, 14, 9, -44 },
  { 8256, 27, 32, 32, 3, -31 },
  { 8364, 28, 45, 33, 2, -44 },
  { 8522, 24, 32, 26, 3, -31 },
  { 8618, 31, 45, 33, 3, -44 },
  { 8793, 24, 32, 29, 3, -31 },
  { 8889, 31, 58, 16, -7, -44 },
  { 9114, 29, 45, 33, 2, -31 },
  { 9278, 27, 44, 32, 2, -44 },
  { 9427, 11, 42, 13, 2, -42 },
  { 9485, 21, 56, 13, -8, -42 },
  { 9632, 26, 44, 26, 2, -44 },
  { 9775, 11, 44, 13, 2, -44 },
  { 9836, 44, 31, 49, 2, -31 },
  { 10007, 27, 31, 32, 2, -31 },
  { 10112, 27, 32, 33, 3, -31 },
  { 10220, 31, 45, 33, -1, -31 },
  { 10395, 28, 45, 33, 3, -31 },
  { 10553, 21, 31, 22, 2, -31 },
  { 10635, 22, 32, 25, 1, -31 },
  { 10723, 17, 39, 18, 3, -38 },
  { 10806, 27, 32, 32, 3, -31 },
  { 10914, 24, 31, 24, 3, -31 },
  { 11007, 37, 31, 39, 3, -31 },
  { 11151, 30, 31, 27, -2, -31 },
  { 11268, 33, 45, 24, -6, -31 },
  { 11454, 26, 31, 25, -1, -31 },
  { 11555, 21, 50, 19, 1, -41 },
  { 11687, 2, 58, 31, 16, -44 },
  { 11702, 21, 50, 19, -3, -41 },
  { 11834, 27, 5, 33, 4, -23 },
};

const GFXfont NotoSans_ExtraLightItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRALIGHTITALIC58PT7B_H_
