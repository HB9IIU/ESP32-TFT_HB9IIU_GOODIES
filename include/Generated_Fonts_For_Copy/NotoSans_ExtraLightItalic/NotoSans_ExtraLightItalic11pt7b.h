#ifndef _NOTOSANS_EXTRALIGHTITALIC11PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x84, 0xB6, 0x80, 0x14, 0x29, 0xD9, 0x42, 0x9F, 0x92,
  0x28, 0x33, 0x68, 0xC3, 0x29, 0x5C, 0x40, 0x63, 0x4A, 0xA5, 0xBD, 0xA5,
  0x54, 0xC6, 0x18, 0x48, 0x90, 0xC7, 0x31, 0x61, 0x3E, 0xE0, 0x32, 0x44,
  0x88, 0x88, 0x84, 0x24, 0x92, 0x49, 0x50, 0xA3, 0xC9, 0xA0, 0x21, 0x3E,
  0x42, 0x00, 0x70, 0xE0, 0x80, 0x11, 0x22, 0x44, 0x88, 0x74, 0x63, 0x18,
  0xC6, 0x5C, 0x75, 0x24, 0xA4, 0x38, 0x10, 0x42, 0x10, 0x84, 0x3E, 0x38,
  0x10, 0x4E, 0x08, 0x20, 0xBC, 0x04, 0x21, 0x8A, 0x4B, 0xF0, 0x84, 0x3C,
  0x84, 0x1C, 0x08, 0x10, 0xBC, 0x3A, 0x21, 0xE8, 0xC6, 0x5E, 0xF8, 0x44,
  0x22, 0x21, 0x10, 0x72, 0x52, 0xE9, 0x4A, 0x5E, 0x74, 0x63, 0x1F, 0x08,
  0x5C, 0x40, 0x20, 0x20, 0x00, 0xB0, 0x3A, 0x30, 0x60, 0x80, 0xFF, 0xC0,
  0xE0, 0x86, 0xC8, 0x00, 0xE1, 0x12, 0x48, 0x08, 0x3E, 0x41, 0x99, 0xA5,
  0xA5, 0xC9, 0xB6, 0x80, 0x78, 0x04, 0x18, 0x50, 0xA3, 0xC4, 0x90, 0xC1,
  0x7A, 0x63, 0xF8, 0xC6, 0x3E, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x1E, 0x79,
  0x18, 0x61, 0x86, 0x18, 0xBC, 0x7A, 0x21, 0xE8, 0x42, 0x1E, 0x7A, 0x21,
  0x0F, 0x42, 0x10, 0x3D, 0x08, 0x20, 0x9E, 0x18, 0x5E, 0x45, 0x18, 0x7F,
  0x86, 0x18, 0xA2, 0x32, 0x24, 0x44, 0x4C, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x26, 0x00, 0x45, 0x29, 0x38, 0xA2, 0x89, 0x24, 0x44, 0x88, 0x88, 0x8F,
  0x41, 0x43, 0xC2, 0xA6, 0xAA, 0xAA, 0xB2, 0xA2, 0x45, 0x1A, 0x69, 0x96,
  0x59, 0xA2, 0x39, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x72, 0x63, 0x1F, 0x42,
  0x10, 0x39, 0x18, 0x61, 0x86, 0x18, 0x5A, 0x10, 0x40, 0x72, 0x63, 0x1F,
  0x4A, 0x52, 0x3D, 0x04, 0x08, 0x10, 0x20, 0xBC, 0xF9, 0x08, 0x44, 0x21,
  0x08, 0x42, 0x86, 0x14, 0x28, 0x50, 0xA2, 0x78, 0x86, 0x28, 0xA4, 0x92,
  0x84, 0x10, 0x88, 0xCC, 0x66, 0x53, 0x2A, 0xA5, 0x51, 0x10, 0x88, 0x22,
  0x28, 0x50, 0x41, 0x05, 0x11, 0x62, 0x8C, 0x64, 0xC4, 0x21, 0x08, 0x3C,
  0x10, 0x84, 0x21, 0x04, 0x3E, 0x34, 0x44, 0x44, 0x88, 0x8C, 0xAA, 0x55,
  0x31, 0x11, 0x11, 0x22, 0x2C, 0x21, 0x95, 0x28, 0x80, 0xF0, 0x80, 0x7C,
  0x65, 0x29, 0x78, 0x21, 0x07, 0x91, 0x45, 0x18, 0xBC, 0x78, 0x88, 0x8E,
  0x08, 0x5F, 0x18, 0xCA, 0x5E, 0x79, 0xBC, 0x8F, 0x1C, 0x43, 0x08, 0x20,
  0x84, 0x10, 0x41, 0x08, 0x00, 0x3D, 0x14, 0x62, 0x89, 0xE0, 0x84, 0xE0,
  0x22, 0x1E, 0x94, 0xA6, 0x31, 0x21, 0x24, 0xA4, 0x08, 0x04, 0x21, 0x08,
  0x84, 0x21, 0x30, 0x22, 0x12, 0xA6, 0x32, 0x52, 0x29, 0x24, 0xA4, 0x7B,
  0x22, 0x52, 0x29, 0x18, 0x94, 0x48, 0x79, 0x14, 0x52, 0x8A, 0x20, 0x74,
  0x63, 0x19, 0x70, 0x79, 0x14, 0x51, 0x8B, 0xC8, 0x20, 0x80, 0x7C, 0x63,
  0x29, 0x78, 0x42, 0x20, 0x74, 0x44, 0x88, 0x74, 0x43, 0x1F, 0x9E, 0x49,
  0x30, 0x8C, 0x63, 0x29, 0x78, 0x99, 0xAA, 0xC8, 0x93, 0x4B, 0x56, 0xC9,
  0x92, 0x00, 0x4A, 0x88, 0x45, 0x48, 0x45, 0x12, 0x8A, 0x30, 0x82, 0x10,
  0x80, 0x78, 0x88, 0x84, 0x78, 0x12, 0x22, 0xC4, 0x44, 0x84, 0xFF, 0xE0,
  0x31, 0x11, 0x11, 0x22, 0x2C, 0xF8,
};

const GFXglyph NotoSans_ExtraLightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 2, 0, -8 },
  { 4, 3, 3, 4, 1, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 5, 9, 6, 1, -8 },
  { 19, 7, 8, 8, 1, -8 },
  { 26, 7, 8, 7, 0, -8 },
  { 33, 1, 3, 2, 1, -8 },
  { 34, 4, 10, 3, 0, -8 },
  { 39, 3, 10, 3, -1, -8 },
  { 43, 5, 4, 6, 1, -8 },
  { 46, 5, 5, 6, 1, -6 },
  { 50, 2, 2, 2, -1, -1 },
  { 51, 3, 1, 3, 0, -3 },
  { 52, 1, 1, 2, 0, -1 },
  { 53, 4, 8, 3, 0, -8 },
  { 57, 5, 8, 6, 1, -8 },
  { 62, 3, 8, 6, 2, -8 },
  { 65, 6, 8, 6, 0, -8 },
  { 71, 6, 8, 6, 0, -8 },
  { 77, 6, 8, 6, 0, -8 },
  { 83, 6, 8, 6, 0, -8 },
  { 89, 5, 8, 6, 1, -8 },
  { 94, 5, 8, 6, 1, -8 },
  { 99, 5, 8, 6, 1, -8 },
  { 104, 5, 8, 6, 1, -8 },
  { 109, 2, 6, 2, 0, -6 },
  { 111, 3, 7, 2, -1, -6 },
  { 114, 5, 5, 6, 1, -6 },
  { 118, 5, 2, 6, 1, -5 },
  { 120, 5, 5, 6, 1, -6 },
  { 124, 4, 8, 4, 1, -8 },
  { 128, 8, 9, 9, 1, -8 },
  { 137, 7, 8, 6, -1, -8 },
  { 144, 5, 8, 7, 1, -8 },
  { 149, 6, 8, 7, 1, -8 },
  { 155, 6, 8, 7, 1, -8 },
  { 161, 5, 8, 6, 1, -8 },
  { 166, 5, 8, 5, 1, -8 },
  { 171, 6, 8, 8, 1, -8 },
  { 177, 6, 8, 7, 1, -8 },
  { 183, 4, 8, 3, 0, -8 },
  { 187, 5, 10, 3, -2, -8 },
  { 194, 6, 8, 6, 1, -8 },
  { 200, 4, 8, 5, 1, -8 },
  { 204, 8, 8, 9, 1, -8 },
  { 212, 6, 8, 7, 1, -8 },
  { 218, 6, 8, 8, 1, -8 },
  { 224, 5, 8, 6, 1, -8 },
  { 229, 6, 10, 8, 1, -8 },
  { 237, 5, 8, 6, 1, -8 },
  { 242, 6, 8, 5, 0, -8 },
  { 248, 5, 8, 5, 1, -8 },
  { 253, 7, 8, 8, 1, -8 },
  { 260, 6, 8, 6, 1, -8 },
  { 266, 9, 8, 9, 1, -8 },
  { 275, 7, 8, 5, -1, -8 },
  { 282, 5, 8, 5, 1, -8 },
  { 287, 6, 8, 6, 0, -8 },
  { 293, 4, 10, 3, 0, -8 },
  { 298, 2, 8, 3, 1, -8 },
  { 300, 4, 10, 3, -1, -8 },
  { 305, 5, 5, 6, 1, -8 },
  { 309, 4, 1, 4, -1, 1 },
  { 310, 1, 1, 3, 2, -8 },
  { 311, 5, 6, 6, 1, -6 },
  { 315, 6, 8, 6, 0, -8 },
  { 321, 4, 6, 5, 1, -6 },
  { 324, 5, 8, 6, 1, -8 },
  { 329, 4, 6, 5, 1, -6 },
  { 332, 6, 11, 3, -1, -8 },
  { 341, 6, 9, 6, 0, -6 },
  { 348, 5, 8, 6, 0, -8 },
  { 353, 3, 8, 2, 0, -8 },
  { 356, 5, 11, 2, -2, -8 },
  { 363, 5, 8, 5, 0, -8 },
  { 368, 3, 8, 2, 0, -8 },
  { 371, 9, 6, 9, 0, -6 },
  { 378, 6, 6, 6, 0, -6 },
  { 383, 5, 6, 6, 1, -6 },
  { 387, 6, 9, 6, 0, -6 },
  { 394, 5, 9, 6, 1, -6 },
  { 400, 4, 6, 4, 0, -6 },
  { 403, 4, 6, 5, 0, -6 },
  { 406, 3, 7, 3, 1, -7 },
  { 409, 5, 6, 6, 1, -6 },
  { 413, 4, 6, 5, 1, -6 },
  { 416, 7, 6, 7, 1, -6 },
  { 422, 5, 6, 5, 0, -6 },
  { 426, 6, 9, 5, -1, -6 },
  { 433, 5, 6, 5, 0, -6 },
  { 437, 4, 10, 4, 0, -8 },
  { 442, 1, 11, 6, 3, -8 },
  { 444, 4, 10, 4, -1, -8 },
  { 449, 5, 1, 6, 1, -4 },
};

const GFXfont NotoSans_ExtraLightItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRALIGHTITALIC11PT7B_H_
