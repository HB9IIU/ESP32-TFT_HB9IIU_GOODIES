#ifndef _NOTOSANS_EXTRALIGHTITALIC47PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x00, 0x30, 0x66, 0x0C, 0xC1,
  0x98, 0x22, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x40, 0x88, 0x11, 0x06, 0x60,
  0xC8, 0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x20, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0,
  0x04, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x02, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x40, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x1E, 0x21, 0xC0, 0xE1, 0x81, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00, 0x03, 0x98, 0x00,
  0x07, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x17, 0x80, 0x00,
  0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x00, 0x80,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x03, 0x08,
  0x04, 0x18, 0x3C, 0x33, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x30, 0x1F, 0xC0, 0x00, 0x80, 0xC1, 0x80, 0x06,
  0x06, 0x06, 0x00, 0x30, 0x30, 0x08, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06,
  0x00, 0xC0, 0x30, 0x18, 0x02, 0x01, 0x80, 0x60, 0x08, 0x0C, 0x01, 0x00,
  0x20, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x06, 0x0C, 0x00, 0xC0, 0x18,
  0x60, 0x03, 0x00, 0x41, 0x80, 0x0C, 0x03, 0x0C, 0x7F, 0x30, 0x0C, 0x63,
  0x8E, 0xC0, 0x63, 0x1C, 0x1B, 0x01, 0x8C, 0x60, 0x36, 0x0C, 0x63, 0x00,
  0xDF, 0xE3, 0x0C, 0x03, 0x1E, 0x08, 0x60, 0x0C, 0x00, 0x61, 0x80, 0x30,
  0x03, 0x06, 0x00, 0xC0, 0x18, 0x10, 0x02, 0x00, 0x40, 0xC0, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x06, 0x00, 0x18,
  0x30, 0x18, 0x00, 0x71, 0xC0, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x80,
  0x04, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x80, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x31, 0xC0, 0x60, 0x03, 0x38,
  0x03, 0x00, 0x63, 0x00, 0x18, 0x06, 0x60, 0x01, 0x80, 0xC4, 0x00, 0x0C,
  0x18, 0xC0, 0x00, 0x61, 0x8C, 0x00, 0x03, 0x30, 0xC0, 0x00, 0x36, 0x0C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0xE6, 0x07, 0x00, 0x1C, 0x30, 0x3C, 0x0F, 0x03, 0x80, 0xFF, 0xC0, 0x1C,
  0x33, 0x33, 0x26, 0x66, 0x44, 0x4C, 0x80, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x01, 0x00, 0x40, 0x38,
  0x18, 0x01, 0xC3, 0x00, 0x0E, 0x40, 0x00, 0x68, 0x3C, 0x03, 0xFF, 0x80,
  0xE0, 0x00, 0x36, 0x00, 0x0C, 0x40, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x70,
  0x18, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x18,
  0x30, 0xC1, 0x86, 0x0C, 0x10, 0x60, 0x83, 0x00, 0xFF, 0xFF, 0xFC, 0x6F,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x1C, 0x07, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x60, 0x00, 0x19, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0x40, 0x01, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x80, 0x1C,
  0x3C, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x01, 0xE0, 0x76, 0x0E,
  0x63, 0x84, 0x70, 0xCC, 0x0C, 0x80, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x0E, 0x02, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0xC0,
  0x01, 0xC0, 0xFC, 0x0F, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x10, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xE7, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x40, 0x01, 0xC0, 0xF8, 0x1E,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x07, 0xC0, 0x0C, 0x7F, 0xE0, 0x11,
  0x80, 0xE0, 0x6C, 0x00, 0x60, 0xF0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x1C, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0x38, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x3B, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xCE, 0x00, 0x1E, 0x0E, 0x00, 0x60, 0x06, 0x01, 0x80, 0x06,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x1E, 0x0F, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E,
  0x18, 0x00, 0x3C, 0x18, 0x00, 0xD8, 0x38, 0x07, 0x60, 0x3E, 0xFC, 0xC0,
  0x1F, 0xE1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0xF0, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x04, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0xF8, 0x30, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x43, 0x00, 0x0F, 0xC0, 0x0C, 0xC0, 0x07, 0xFF, 0x01, 0x98, 0x03, 0x80,
  0x60, 0x36, 0x00, 0xC0, 0x08, 0x06, 0xC0, 0x30, 0x03, 0x00, 0xD0, 0x06,
  0x00, 0x60, 0x1E, 0x01, 0x80, 0x0C, 0x03, 0xC0, 0x20, 0x01, 0x00, 0x78,
  0x0C, 0x00, 0x60, 0x0F, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x20, 0x01, 0x00,
  0x68, 0x04, 0x00, 0x60, 0x0D, 0x01, 0x80, 0x0C, 0x01, 0xA0, 0x30, 0x03,
  0x80, 0x64, 0x02, 0x00, 0x70, 0x18, 0xC0, 0x60, 0x16, 0x03, 0x18, 0x0E,
  0x0E, 0x41, 0xC3, 0x00, 0xFF, 0x0F, 0xF0, 0x60, 0x0F, 0xC0, 0xF8, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x60, 0x07, 0x80, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x18, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x06,
  0x00, 0x78, 0x02, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0x80, 0x18, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x40, 0x07, 0x81, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0x80, 0x3E, 0x00, 0x18, 0x00, 0x70, 0x03, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0xF0, 0x06, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x00, 0x10, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF3, 0x00, 0x0F, 0xFE, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x00, 0xF0, 0x00, 0x60, 0x07, 0x81, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0xE7, 0x80, 0x1F, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30,
  0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0xF1, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x14, 0x00, 0x00, 0x1A, 0x03, 0x60, 0x00, 0x01, 0xE0, 0x36, 0x00, 0x00,
  0x36, 0x03, 0x60, 0x00, 0x03, 0x60, 0x36, 0x00, 0x00, 0x66, 0x02, 0x20,
  0x00, 0x0C, 0x40, 0x62, 0x00, 0x00, 0xCC, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x63, 0x00, 0x01, 0x8C, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x43, 0x00, 0x06,
  0x18, 0x0C, 0x10, 0x00, 0x61, 0x80, 0xC1, 0x00, 0x0C, 0x18, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0xC1, 0x80, 0x18, 0x10, 0x08, 0x18, 0x01, 0x03, 0x01,
  0x81, 0x80, 0x30, 0x30, 0x18, 0x08, 0x06, 0x03, 0x01, 0x80, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0x80, 0x60, 0x30, 0x0C,
  0x18, 0x06, 0x03, 0x00, 0xC3, 0x00, 0x60, 0x30, 0x04, 0x30, 0x06, 0x02,
  0x00, 0x46, 0x00, 0x40, 0x60, 0x06, 0x60, 0x0C, 0x06, 0x00, 0x6C, 0x00,
  0xC0, 0x60, 0x07, 0x80, 0x0C, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x40, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x80, 0x70, 0x00, 0x06, 0x03, 0x60,
  0x00, 0x18, 0x0D, 0x80, 0x00, 0x60, 0x32, 0x00, 0x01, 0x80, 0xCC, 0x00,
  0x04, 0x02, 0x30, 0x00, 0x30, 0x18, 0x60, 0x00, 0xC0, 0x61, 0x80, 0x03,
  0x01, 0x83, 0x00, 0x0C, 0x06, 0x0C, 0x00, 0x60, 0x10, 0x10, 0x01, 0x80,
  0xC0, 0x60, 0x06, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x18, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x60, 0x03, 0x02, 0x01, 0x80, 0x0C, 0x18, 0x0C, 0x00, 0x18,
  0x60, 0x30, 0x00, 0x61, 0x80, 0xC0, 0x00, 0x86, 0x03, 0x00, 0x03, 0x10,
  0x08, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x1B, 0x01, 0x80, 0x00, 0x6C, 0x06,
  0x00, 0x00, 0xF0, 0x18, 0x00, 0x03, 0x80, 0x40, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0x80, 0x7C, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x38, 0x03, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80,
  0x07, 0x83, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0x80, 0x7C, 0x01, 0x80, 0x0E, 0x03,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x0C,
  0x00, 0x38, 0x0C, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x00, 0x30, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x40,
  0x00, 0x30, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07,
  0x80, 0x38, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x40, 0x01,
  0xC0, 0xF8, 0x3F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x20, 0x03, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20,
  0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x0A, 0x00,
  0x06, 0xC0, 0x01, 0xA0, 0x00, 0x6C, 0x00, 0x1A, 0x00, 0x0C, 0xC0, 0x03,
  0x20, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x40, 0xC0, 0x30,
  0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x40, 0x40, 0x30, 0x30, 0x04, 0x0C, 0x03, 0x03,
  0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x18, 0x01, 0x06, 0x00, 0x41, 0x80,
  0x10, 0xC0, 0x06, 0x30, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x18, 0x80, 0x06,
  0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC3,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0x81, 0x80, 0x01, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x81, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x81, 0x02,
  0x06, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18,
  0x30, 0x60, 0x40, 0x81, 0x83, 0x06, 0x0C, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x19,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x01, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x18,
  0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x04, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x63, 0x00, 0x01, 0x98, 0x00, 0x02, 0xE0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0x81, 0x00, 0x7F, 0x04, 0x07,
  0x8F, 0x10, 0x38, 0x0C, 0xC1, 0x80, 0x1B, 0x0C, 0x00, 0x28, 0x60, 0x00,
  0xE1, 0x80, 0x03, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x1E,
  0x18, 0x00, 0x50, 0x60, 0x03, 0xC1, 0x80, 0x1B, 0x03, 0x00, 0xCC, 0x0F,
  0x0E, 0x20, 0x0F, 0xE0, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x7F, 0x00, 0x63, 0xC7, 0x80, 0xCC, 0x03, 0x81, 0xB0, 0x03,
  0x03, 0xC0, 0x03, 0x05, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0E, 0x00, 0x0C, 0x34, 0x00,
  0x38, 0x68, 0x00, 0xE0, 0xC8, 0x03, 0x81, 0x1E, 0x1E, 0x06, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x38, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0xE0, 0xF0, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x0F, 0xF0, 0xC0, 0x1E, 0x3C, 0x60, 0x1C, 0x03, 0x30, 0x18, 0x00, 0xD0,
  0x18, 0x00, 0x28, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x07,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x01, 0x80,
  0x07, 0x80, 0xC0, 0x06, 0xC0, 0x60, 0x06, 0x60, 0x18, 0x06, 0x20, 0x0F,
  0x0E, 0x10, 0x01, 0xFC, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x70, 0x1C,
  0x03, 0x07, 0x00, 0x61, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x3C, 0x61, 0xFE, 0x0F, 0xFE,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x80, 0xF0, 0x70, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x27, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0x00, 0xF0, 0xE3, 0x01, 0xC0, 0x33,
  0x03, 0x00, 0x1A, 0x06, 0x00, 0x0A, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E,
  0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70,
  0x30, 0x00, 0xF0, 0x30, 0x01, 0xB0, 0x30, 0x03, 0x30, 0x18, 0x06, 0x20,
  0x1E, 0x1C, 0x60, 0x07, 0xF0, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0xFC, 0x7C, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x83, 0xFC,
  0x06, 0x1C, 0x78, 0x19, 0xC0, 0x70, 0x6C, 0x00, 0xC1, 0xE0, 0x03, 0x05,
  0x00, 0x04, 0x38, 0x00, 0x10, 0xE0, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x30, 0x00, 0x18, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x38, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x07, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x60, 0x04, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03,
  0x06, 0x00, 0x0C, 0x30, 0x00, 0x21, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x78,
  0x00, 0x1B, 0x30, 0x00, 0x58, 0xC0, 0x03, 0x81, 0x80, 0x0C, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x70, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x02, 0x0F, 0xE0, 0x1F, 0xC0,
  0x63, 0x8F, 0x07, 0x1E, 0x06, 0x60, 0x30, 0xC0, 0x60, 0x6C, 0x01, 0x98,
  0x03, 0x05, 0x80, 0x1B, 0x00, 0x30, 0x50, 0x01, 0xE0, 0x03, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0xE0, 0x01, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x80, 0x03, 0x08, 0x00, 0x10, 0x00, 0x21, 0x80, 0x03, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x00, 0x61, 0x80, 0x03, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x00, 0x63, 0x00, 0x06, 0x00, 0x04, 0x30, 0x00, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0xC2, 0x00, 0x04, 0x00,
  0x0C, 0x60, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x0F, 0xF0, 0x0C, 0x7C, 0xF0, 0x19, 0xC0, 0x70, 0x36, 0x00, 0x60,
  0x58, 0x00, 0xC0, 0xA0, 0x00, 0xC3, 0x80, 0x01, 0x07, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0x00, 0xFF, 0x00, 0x1E, 0x1E, 0x01, 0xC0, 0x38, 0x18, 0x00, 0xE1, 0x80,
  0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x03, 0x30,
  0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0xC0, 0x1C,
  0x07, 0x83, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x83, 0xF8, 0x00, 0xC7, 0x8F,
  0x00, 0x67, 0x01, 0xC0, 0x36, 0x00, 0x60, 0x16, 0x00, 0x18, 0x0A, 0x00,
  0x0C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x01, 0x81, 0xA0, 0x01, 0xC0,
  0xD0, 0x01, 0xC0, 0x64, 0x01, 0xC0, 0x33, 0xC3, 0xC0, 0x10, 0x7F, 0x80,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x82, 0x03, 0xC7, 0x8C, 0x0E, 0x01, 0x98, 0x30, 0x01, 0xA0, 0xC0,
  0x01, 0x43, 0x00, 0x03, 0x86, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x88, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x71,
  0x80, 0x00, 0xC3, 0x00, 0x03, 0x83, 0x00, 0x0F, 0x06, 0x00, 0x36, 0x0C,
  0x00, 0xCC, 0x0C, 0x03, 0x10, 0x1E, 0x1C, 0x60, 0x0F, 0xE0, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x02, 0x0F, 0xC1, 0x8F, 0x30,
  0x66, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xE1, 0xF0, 0xC0, 0x04, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x88, 0x00, 0xC3, 0xC0, 0xE0, 0x7F, 0xF0,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x07,
  0xFF, 0xDF, 0xFF, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC2, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x61, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x02, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x08, 0x00, 0x1C,
  0x20, 0x00, 0xA0, 0xC0, 0x06, 0x83, 0x00, 0x36, 0x0E, 0x01, 0x98, 0x1C,
  0x3C, 0x60, 0x3F, 0xC1, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x40, 0x00,
  0x66, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00,
  0x30, 0x20, 0x06, 0x02, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x03, 0x03, 0x00, 0x30, 0x30, 0x01, 0x06, 0x00, 0x10, 0x60, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x00, 0x01, 0xB0, 0x00,
  0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x02, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x68, 0x00, 0x70, 0x01, 0xB0, 0x03, 0xC0, 0x0C, 0xC0,
  0x0B, 0x00, 0x33, 0x00, 0x6C, 0x01, 0x8C, 0x01, 0x30, 0x06, 0x30, 0x0C,
  0xC0, 0x30, 0xC0, 0x61, 0x00, 0xC3, 0x01, 0x84, 0x06, 0x0C, 0x0C, 0x10,
  0x18, 0x30, 0x30, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x08,
  0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0x46, 0x01, 0x8C, 0x01,
  0x18, 0x06, 0x30, 0x04, 0xC0, 0x09, 0x80, 0x13, 0x00, 0x26, 0x00, 0x58,
  0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0x40, 0x70,
  0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00,
  0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x60, 0x10, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x30,
  0x00, 0x40, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x08, 0x18, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x07,
  0xC0, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x1E, 0x0F,
  0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 34, 10, 1, -34 },
  { 44, 11, 13, 15, 5, -34 },
  { 62, 28, 34, 29, 2, -34 },
  { 181, 22, 39, 26, 2, -36 },
  { 289, 30, 35, 36, 4, -34 },
  { 421, 28, 34, 32, 2, -34 },
  { 540, 4, 13, 9, 5, -34 },
  { 547, 13, 41, 12, 2, -34 },
  { 614, 13, 41, 12, -3, -34 },
  { 681, 19, 20, 25, 6, -36 },
  { 729, 22, 22, 27, 3, -28 },
  { 790, 7, 11, 9, -2, -5 },
  { 800, 11, 2, 15, 2, -14 },
  { 803, 4, 3, 10, 1, -3 },
  { 805, 21, 34, 15, -2, -34 },
  { 895, 22, 34, 26, 3, -34 },
  { 989, 12, 34, 26, 8, -34 },
  { 1040, 24, 34, 26, 0, -34 },
  { 1142, 24, 34, 26, 1, -34 },
  { 1244, 24, 34, 26, 1, -34 },
  { 1346, 23, 34, 26, 2, -34 },
  { 1444, 23, 34, 26, 3, -34 },
  { 1542, 21, 34, 26, 5, -34 },
  { 1632, 23, 34, 26, 2, -34 },
  { 1730, 23, 34, 26, 2, -34 },
  { 1828, 8, 25, 10, 1, -25 },
  { 1853, 11, 31, 10, -2, -25 },
  { 1896, 21, 22, 27, 4, -28 },
  { 1954, 21, 11, 27, 4, -22 },
  { 1983, 21, 22, 27, 4, -28 },
  { 2041, 16, 34, 19, 4, -34 },
  { 2109, 35, 37, 39, 3, -33 },
  { 2271, 26, 34, 26, -2, -34 },
  { 2382, 25, 34, 28, 2, -34 },
  { 2489, 26, 34, 28, 4, -34 },
  { 2600, 28, 34, 32, 2, -34 },
  { 2719, 24, 34, 25, 2, -34 },
  { 2821, 24, 34, 23, 2, -34 },
  { 2923, 27, 34, 32, 4, -34 },
  { 3038, 30, 34, 32, 2, -34 },
  { 3166, 16, 34, 14, 0, -34 },
  { 3234, 19, 42, 11, -8, -34 },
  { 3334, 28, 34, 26, 2, -34 },
  { 3453, 17, 34, 23, 2, -34 },
  { 3526, 36, 34, 38, 2, -34 },
  { 3679, 30, 34, 32, 2, -34 },
  { 3807, 28, 34, 34, 4, -34 },
  { 3926, 24, 34, 26, 2, -34 },
  { 4028, 28, 42, 34, 4, -34 },
  { 4175, 24, 34, 27, 2, -34 },
  { 4277, 23, 34, 23, 1, -34 },
  { 4375, 23, 34, 23, 4, -34 },
  { 4473, 29, 34, 32, 4, -34 },
  { 4597, 24, 34, 25, 5, -34 },
  { 4699, 36, 34, 39, 6, -34 },
  { 4852, 30, 34, 23, -3, -34 },
  { 4980, 23, 34, 23, 4, -34 },
  { 5078, 27, 34, 25, 0, -34 },
  { 5193, 17, 41, 14, 0, -34 },
  { 5281, 7, 34, 15, 5, -34 },
  { 5311, 17, 41, 14, -3, -34 },
  { 5399, 22, 21, 26, 2, -34 },
  { 5457, 18, 2, 18, -4, 5 },
  { 5462, 6, 8, 11, 7, -36 },
  { 5468, 22, 25, 26, 2, -25 },
  { 5537, 23, 36, 27, 1, -36 },
  { 5641, 19, 25, 21, 3, -25 },
  { 5701, 25, 36, 27, 2, -36 },
  { 5814, 19, 25, 23, 3, -25 },
  { 5874, 26, 47, 13, -6, -36 },
  { 6027, 24, 36, 27, 1, -25 },
  { 6135, 22, 36, 26, 1, -36 },
  { 6234, 10, 34, 10, 1, -34 },
  { 6277, 18, 45, 10, -7, -34 },
  { 6379, 22, 36, 21, 1, -36 },
  { 6478, 10, 36, 10, 1, -36 },
  { 6523, 36, 25, 40, 1, -25 },
  { 6636, 23, 25, 26, 1, -25 },
  { 6708, 21, 25, 27, 3, -25 },
  { 6774, 25, 36, 27, -1, -25 },
  { 6887, 23, 36, 27, 2, -25 },
  { 6991, 18, 25, 18, 1, -25 },
  { 7048, 18, 25, 20, 1, -25 },
  { 7105, 14, 31, 15, 2, -31 },
  { 7160, 22, 25, 26, 3, -25 },
  { 7229, 20, 25, 20, 2, -25 },
  { 7292, 30, 25, 31, 3, -25 },
  { 7386, 24, 25, 22, -2, -25 },
  { 7461, 27, 36, 20, -5, -25 },
  { 7583, 22, 25, 21, -1, -25 },
  { 7652, 17, 41, 16, 1, -34 },
  { 7740, 2, 47, 25, 13, -36 },
  { 7752, 17, 41, 16, -2, -34 },
  { 7840, 21, 5, 27, 4, -19 },
};

const GFXfont NotoSans_ExtraLightItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRALIGHTITALIC47PT7B_H_
