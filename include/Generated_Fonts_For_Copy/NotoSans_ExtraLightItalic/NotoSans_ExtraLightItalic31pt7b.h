#ifndef _NOTOSANS_EXTRALIGHTITALIC31PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x30, 0xC2, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x82,
  0x08, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x23, 0x22, 0x62, 0x42, 0x46, 0x44,
  0x44, 0x84, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00,
  0x10, 0x20, 0x02, 0x04, 0x00, 0x41, 0x01, 0xFF, 0xFF, 0x02, 0x04, 0x00,
  0x41, 0x80, 0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x20, 0x3F,
  0xFF, 0xE0, 0x40, 0x80, 0x08, 0x30, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08,
  0x10, 0x01, 0x04, 0x00, 0x40, 0x80, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x0F, 0xC0, 0x74, 0xE1, 0x88, 0x06, 0x10, 0x08, 0x20, 0x10, 0x80,
  0x21, 0x00, 0x22, 0x00, 0x74, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x4C, 0x00,
  0x8C, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x88, 0x23, 0x1F, 0xF8,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x44, 0x20,
  0x11, 0x04, 0x04, 0x20, 0xC1, 0x8C, 0x18, 0x21, 0x02, 0x08, 0x20, 0x42,
  0x04, 0x08, 0xC0, 0x81, 0x11, 0x10, 0x44, 0xFA, 0x09, 0x30, 0xC2, 0x64,
  0x17, 0x89, 0x82, 0x02, 0x20, 0x40, 0x84, 0x08, 0x30, 0x81, 0x04, 0x30,
  0x21, 0x04, 0x08, 0x40, 0x81, 0x08, 0x18, 0x62, 0x01, 0x08, 0x80, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x60, 0xC0, 0x08, 0x08, 0x03, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x0C, 0x01, 0x81, 0x00, 0x10, 0x40, 0x03, 0x30, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x06, 0x60, 0x03, 0x04, 0x06, 0x40, 0x40, 0x90, 0x04,
  0x22, 0x00, 0xCC, 0xC0, 0x09, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x20, 0x0D,
  0x06, 0x03, 0x10, 0x3F, 0x83, 0x00, 0x25, 0xA4, 0x94, 0x01, 0x81, 0x01,
  0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80,
  0x40, 0x30, 0x08, 0x00, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x30, 0x30, 0x00, 0x02,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x0C, 0x20, 0x19, 0x00, 0x28, 0xE0, 0xF8,
  0x0A, 0x00, 0x90, 0x08, 0x40, 0x82, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F,
  0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x13, 0x22, 0x64, 0x88, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x30, 0x20, 0x80,
  0xC4, 0x01, 0x30, 0x04, 0x80, 0x16, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80,
  0x12, 0x00, 0x4C, 0x02, 0x10, 0x18, 0x60, 0xC0, 0xFC, 0x00, 0x03, 0x0F,
  0x1A, 0x62, 0xC2, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x01, 0xFC, 0x06, 0x06,
  0x04, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x18, 0x08, 0x40, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x1F,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x88, 0x06, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0A, 0x00, 0x1A, 0x00, 0x32, 0x00, 0x66, 0x00, 0xC4,
  0x00, 0x84, 0x01, 0x04, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x08,
  0x30, 0x08, 0x60, 0x08, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x03, 0xFF, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x1F, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0xC0, 0x60,
  0x7F, 0x80, 0x00, 0x10, 0x01, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC7, 0x01, 0x39, 0xC2, 0x80,
  0x86, 0x00, 0x98, 0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x66, 0x00, 0x84, 0x02, 0x0C, 0x08, 0x07, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x01, 0xFC, 0x06, 0x06, 0x04, 0x02, 0x08, 0x02, 0x08, 0x03, 0x08,
  0x02, 0x08, 0x02, 0x0C, 0x04, 0x06, 0x18, 0x03, 0x70, 0x01, 0xC0, 0x0E,
  0x60, 0x18, 0x10, 0x20, 0x08, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0x40, 0x08, 0x40, 0x18, 0x30, 0x30, 0x1F, 0xC0, 0x03, 0xF8, 0x0C,
  0x18, 0x20, 0x10, 0xC0, 0x11, 0x00, 0x26, 0x00, 0x4C, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x40, 0x0C, 0xC0, 0x38, 0xC0, 0xA0, 0xFE, 0x40, 0x60, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x1F, 0xE0, 0x00, 0x08, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x02, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x84, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0xC0, 0x0C, 0x00, 0x60, 0x60, 0x00,
  0x41, 0x80, 0x00, 0x42, 0x00, 0x00, 0x88, 0x03, 0xC0, 0xB0, 0x30, 0xC1,
  0x40, 0xC0, 0x83, 0x82, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x10, 0x08, 0x18,
  0x20, 0x30, 0x30, 0x40, 0x40, 0xA0, 0x80, 0x81, 0x41, 0x03, 0x06, 0x82,
  0x0A, 0x19, 0x06, 0x66, 0xE3, 0x03, 0x83, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x04, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x32,
  0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0x83, 0x00, 0x20, 0x40,
  0x10, 0x10, 0x0C, 0x04, 0x02, 0x01, 0x01, 0xFF, 0xC0, 0x40, 0x10, 0x30,
  0x06, 0x08, 0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x60, 0x00,
  0xB0, 0x00, 0x30, 0x07, 0xFE, 0x02, 0x01, 0x81, 0x00, 0x61, 0x80, 0x10,
  0x80, 0x08, 0x40, 0x04, 0x20, 0x06, 0x10, 0x02, 0x18, 0x03, 0x08, 0x06,
  0x07, 0xFC, 0x02, 0x01, 0x83, 0x00, 0x61, 0x80, 0x10, 0x80, 0x08, 0x40,
  0x04, 0x20, 0x02, 0x30, 0x01, 0x10, 0x01, 0x88, 0x01, 0x84, 0x03, 0x87,
  0xFE, 0x00, 0x01, 0xFF, 0x83, 0x80, 0x83, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x80, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x80, 0xE0, 0x10, 0x06, 0x06, 0x00, 0x60, 0x80,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x62, 0x00,
  0x0C, 0x40, 0x01, 0x88, 0x00, 0x33, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00,
  0x31, 0x00, 0x04, 0x20, 0x01, 0x8C, 0x00, 0x61, 0x00, 0x18, 0x20, 0x0E,
  0x04, 0x07, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x1F, 0xFC, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x1F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xC1, 0xC0, 0x20, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x01,
  0xFC, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x02,
  0x20, 0x00, 0x84, 0x00, 0x61, 0x80, 0x10, 0x30, 0x0C, 0x07, 0xFE, 0x00,
  0x04, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00,
  0x04, 0x1F, 0xFF, 0xC1, 0x00, 0x0C, 0x30, 0x00, 0x83, 0x00, 0x08, 0x20,
  0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x03, 0x0C, 0x00, 0x20, 0x07, 0xC0, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x3F, 0x00, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x40, 0xFC, 0x00, 0x04, 0x00, 0xE0, 0x80, 0x30, 0x10, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x46, 0x00, 0x19,
  0x80, 0x02, 0x60, 0x00, 0x5E, 0x00, 0x0C, 0x40, 0x03, 0x0C, 0x00, 0x60,
  0x80, 0x08, 0x18, 0x01, 0x01, 0x00, 0x20, 0x30, 0x0C, 0x02, 0x01, 0x00,
  0x60, 0x20, 0x04, 0x04, 0x00, 0x81, 0x80, 0x08, 0x00, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0F, 0xFF, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x0F, 0x00, 0x0A, 0x09, 0x00, 0x1A, 0x09, 0x00, 0x12,
  0x09, 0x00, 0x36, 0x09, 0x00, 0x26, 0x19, 0x00, 0x44, 0x11, 0x80, 0x44,
  0x10, 0x80, 0x84, 0x10, 0x81, 0x8C, 0x30, 0x81, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xC4, 0x08, 0x20, 0x4C, 0x18, 0x60, 0x48, 0x10,
  0x40, 0x50, 0x10, 0x40, 0x50, 0x10, 0x40, 0x60, 0x10, 0xC0, 0x60, 0x30,
  0x04, 0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x20, 0xF0, 0x02, 0x09, 0x00,
  0x20, 0x98, 0x02, 0x08, 0x80, 0x60, 0x88, 0x04, 0x18, 0x40, 0x41, 0x04,
  0x04, 0x10, 0x60, 0x41, 0x02, 0x0C, 0x30, 0x30, 0x83, 0x01, 0x08, 0x20,
  0x10, 0x82, 0x00, 0x98, 0x20, 0x09, 0x86, 0x00, 0xD0, 0x40, 0x05, 0x04,
  0x00, 0x50, 0x40, 0x03, 0x0C, 0x00, 0x20, 0x03, 0xFC, 0x03, 0x80, 0xC1,
  0x80, 0x18, 0xC0, 0x02, 0x20, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0xC4,
  0x00, 0x61, 0x80, 0x30, 0x30, 0x18, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x04,
  0x06, 0x04, 0x03, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x18, 0x03, 0x10, 0x02, 0x10, 0x04, 0x10, 0x78, 0x3F, 0xC0, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0x80, 0xC1, 0x80, 0x18,
  0xC0, 0x02, 0x20, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0xC4, 0x00, 0x61,
  0x80, 0x30, 0x30, 0x18, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x04, 0x06, 0x04, 0x03,
  0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x03,
  0x10, 0x06, 0x10, 0x0C, 0x1F, 0xF0, 0x30, 0x60, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x30, 0x20, 0x10, 0x60, 0x10, 0x40, 0x18, 0x40, 0x08, 0x40, 0x08,
  0xC0, 0x0C, 0x03, 0xFC, 0x18, 0x04, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x88, 0x0E, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0x80, 0x03, 0x20,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x09, 0x80, 0x02, 0x40, 0x01, 0x90, 0x00,
  0x44, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0xC3, 0x00, 0x60, 0x60,
  0x30, 0x0F, 0xF0, 0x00, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x20, 0x60, 0x20,
  0x20, 0x40, 0x20, 0x40, 0x20, 0x80, 0x21, 0x80, 0x21, 0x00, 0x23, 0x00,
  0x22, 0x00, 0x36, 0x00, 0x34, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x02, 0x80, 0x28, 0x06, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88, 0x10,
  0x81, 0x08, 0x10, 0x81, 0x08, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x60,
  0xC4, 0x08, 0x40, 0xC4, 0x08, 0x40, 0xCC, 0x08, 0x80, 0xC8, 0x08, 0x80,
  0x58, 0x0D, 0x00, 0x50, 0x0D, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x02, 0x00, 0x30, 0x20, 0x04, 0x01,
  0x00, 0xC0, 0x10, 0x18, 0x01, 0x81, 0x00, 0x08, 0x20, 0x00, 0x84, 0x00,
  0x04, 0xC0, 0x00, 0x58, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x90, 0x00, 0x19, 0x00, 0x03, 0x18, 0x00, 0x20, 0x80, 0x04, 0x08,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x60, 0x60, 0x02, 0x0C, 0x00,
  0x30, 0x80, 0x07, 0x80, 0x19, 0x00, 0x22, 0x00, 0x86, 0x03, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x60, 0x30, 0x80, 0x22, 0x00, 0x48, 0x00, 0xF0, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x03, 0xF0, 0x00, 0x84,
  0x10, 0x84, 0x21, 0x0C, 0x21, 0x08, 0x42, 0x18, 0x42, 0x10, 0x84, 0x10,
  0x84, 0x07, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x83, 0xF0, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x80, 0x08, 0x80, 0x31,
  0x00, 0x42, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x20, 0x18, 0xC0, 0x11,
  0x00, 0x2C, 0x00, 0x60, 0xFF, 0xF0, 0x91, 0x22, 0x03, 0x80, 0x39, 0x91,
  0x81, 0x48, 0x06, 0x60, 0x19, 0x00, 0x6C, 0x01, 0xA0, 0x06, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x32, 0x01, 0x88, 0x0A, 0x10, 0x48,
  0x7E, 0x20, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x38, 0x11, 0x98, 0x2C, 0x08, 0x50, 0x18, 0xC0,
  0x13, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x06, 0xC0, 0x09,
  0x80, 0x13, 0x00, 0x66, 0x00, 0x9C, 0x02, 0x24, 0x18, 0x47, 0xE0, 0x03,
  0xE0, 0xE3, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x04, 0x3F,
  0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x03, 0x86, 0x0E, 0x64, 0x18, 0x14, 0x20, 0x0C, 0x60,
  0x0C, 0x40, 0x0C, 0xC0, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80,
  0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x50, 0x80, 0xD0, 0xC1, 0xA0, 0x7E,
  0x20, 0x03, 0xC0, 0xE6, 0x18, 0x13, 0x01, 0x60, 0x14, 0x01, 0x40, 0x2C,
  0x0C, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x04, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x40, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x03, 0xFC, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x01, 0xE1, 0x07,
  0x32, 0x0C, 0x0A, 0x10, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0x40,
  0x28, 0x40, 0x78, 0x60, 0xD0, 0x3F, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x80, 0xC0, 0xFF, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x18, 0x11,
  0x9C, 0x58, 0x11, 0x40, 0x46, 0x01, 0x30, 0x04, 0xC0, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x0D, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x0B, 0x00, 0x68,
  0x01, 0x20, 0x04, 0x0C, 0x30, 0x00, 0x00, 0x21, 0x04, 0x10, 0x43, 0x08,
  0x20, 0x82, 0x18, 0x41, 0x04, 0x30, 0x82, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x0F, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x01, 0x10, 0x08, 0x40, 0x41, 0x02, 0x04, 0x30, 0x31, 0x80, 0x8C,
  0x02, 0x60, 0x0B, 0x80, 0x3B, 0x01, 0x84, 0x04, 0x18, 0x10, 0x20, 0x40,
  0xC3, 0x01, 0x08, 0x06, 0x20, 0x08, 0x04, 0x10, 0x43, 0x08, 0x20, 0x86,
  0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x43, 0x0C, 0x20,
  0x00, 0xE0, 0x38, 0x26, 0x71, 0x9C, 0x50, 0x24, 0x08, 0xC0, 0x50, 0x11,
  0x80, 0xA0, 0x26, 0x01, 0x80, 0x4C, 0x02, 0x00, 0x90, 0x04, 0x01, 0x20,
  0x08, 0x02, 0x40, 0x30, 0x0D, 0x80, 0x40, 0x12, 0x00, 0x80, 0x24, 0x01,
  0x00, 0x48, 0x02, 0x00, 0xB0, 0x0C, 0x03, 0x40, 0x10, 0x04, 0x80, 0x20,
  0x08, 0x00, 0x60, 0x23, 0x38, 0x58, 0x10, 0xE0, 0x21, 0x80, 0x66, 0x00,
  0x8C, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x19, 0x80, 0x22, 0x00, 0x44,
  0x00, 0x88, 0x03, 0x30, 0x06, 0x60, 0x08, 0x80, 0x10, 0x03, 0xC0, 0x3D,
  0xC1, 0x81, 0x88, 0x02, 0x60, 0x0D, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0x4C, 0x02, 0x18,
  0x30, 0x3F, 0x80, 0x00, 0x1C, 0x02, 0x33, 0x01, 0x60, 0x40, 0xE0, 0x30,
  0x60, 0x08, 0x60, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00,
  0xC6, 0x00, 0x43, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x10, 0xE0, 0x10, 0x48,
  0x30, 0x23, 0xF0, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC2, 0x1C, 0xC8, 0x60, 0x51,
  0x00, 0x66, 0x00, 0xC8, 0x01, 0xB0, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x32, 0x00, 0x44, 0x00, 0x88, 0x03, 0x10, 0x0A, 0x20, 0x3C, 0x20, 0xD0,
  0x7E, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xE2, 0x74, 0x58, 0x0A, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x00, 0x03, 0xC0, 0xC7, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x20, 0x06,
  0x00, 0x4C, 0x0C, 0x7F, 0x80, 0x10, 0x10, 0x10, 0x30, 0xFF, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xF8, 0x20, 0x04, 0x80, 0x12, 0x00, 0xD8, 0x02, 0x40, 0x09, 0x00, 0x24,
  0x00, 0x90, 0x06, 0xC0, 0x12, 0x00, 0x48, 0x03, 0x20, 0x0C, 0x80, 0x62,
  0x02, 0x8C, 0x12, 0x1F, 0x88, 0x80, 0x1C, 0x01, 0x20, 0x09, 0x00, 0x88,
  0x0C, 0x60, 0x41, 0x06, 0x08, 0x20, 0x42, 0x02, 0x10, 0x11, 0x00, 0x98,
  0x06, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x40, 0x38, 0x0C, 0x06,
  0x80, 0xC0, 0x48, 0x16, 0x0C, 0x81, 0x20, 0x88, 0x22, 0x08, 0x82, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x22, 0x08, 0x82, 0x20, 0x88, 0x24, 0x0D, 0x02,
  0x40, 0xF0, 0x2C, 0x0E, 0x02, 0x80, 0x60, 0x38, 0x04, 0x01, 0x00, 0x08,
  0x03, 0x04, 0x04, 0x04, 0x08, 0x06, 0x10, 0x02, 0x20, 0x03, 0x60, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x04, 0x40, 0x08, 0x60, 0x10,
  0x20, 0x30, 0x30, 0x60, 0x10, 0xC0, 0x18, 0x04, 0x00, 0xC1, 0x00, 0x40,
  0x40, 0x10, 0x10, 0x08, 0x06, 0x02, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08,
  0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x22, 0x00, 0x04, 0x80, 0x01, 0x40,
  0x00, 0x50, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x03, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x06, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0xC0, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x18, 0x06, 0x03, 0x00,
  0x00, 0x7F, 0x03, 0x03, 0xF8, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraLightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 8, 8, 10, 3, -22 },
  { 26, 19, 22, 19, 1, -22 },
  { 79, 15, 26, 17, 1, -24 },
  { 128, 19, 22, 24, 3, -22 },
  { 181, 19, 22, 21, 1, -22 },
  { 234, 3, 8, 6, 3, -22 },
  { 237, 9, 27, 8, 1, -22 },
  { 268, 9, 27, 8, -2, -22 },
  { 299, 13, 14, 17, 4, -24 },
  { 322, 15, 14, 18, 2, -18 },
  { 349, 4, 8, 6, -1, -4 },
  { 353, 8, 1, 10, 1, -9 },
  { 354, 2, 2, 7, 1, -2 },
  { 355, 13, 22, 10, -1, -22 },
  { 391, 14, 22, 17, 2, -22 },
  { 430, 8, 22, 17, 5, -22 },
  { 452, 16, 22, 17, 0, -22 },
  { 496, 15, 22, 17, 1, -22 },
  { 538, 16, 22, 17, 0, -22 },
  { 582, 16, 22, 17, 1, -22 },
  { 626, 15, 23, 17, 2, -23 },
  { 670, 14, 22, 17, 3, -22 },
  { 709, 16, 22, 17, 1, -22 },
  { 753, 15, 22, 17, 1, -22 },
  { 795, 5, 17, 7, 1, -17 },
  { 806, 7, 21, 7, -1, -17 },
  { 825, 15, 14, 18, 2, -18 },
  { 852, 15, 8, 18, 2, -15 },
  { 867, 15, 14, 18, 2, -18 },
  { 894, 11, 22, 13, 2, -22 },
  { 925, 23, 25, 26, 2, -22 },
  { 997, 18, 22, 17, -2, -22 },
  { 1047, 17, 22, 19, 1, -22 },
  { 1094, 17, 22, 18, 3, -22 },
  { 1141, 19, 22, 21, 1, -22 },
  { 1194, 16, 22, 16, 1, -22 },
  { 1238, 16, 22, 15, 1, -22 },
  { 1282, 18, 22, 21, 3, -22 },
  { 1332, 20, 22, 21, 1, -22 },
  { 1387, 10, 22, 9, 0, -22 },
  { 1415, 12, 27, 7, -5, -22 },
  { 1456, 19, 22, 17, 1, -22 },
  { 1509, 12, 22, 15, 1, -22 },
  { 1542, 24, 22, 25, 1, -22 },
  { 1608, 20, 22, 21, 1, -22 },
  { 1663, 18, 22, 22, 3, -22 },
  { 1713, 16, 22, 17, 1, -22 },
  { 1757, 18, 27, 22, 3, -22 },
  { 1818, 16, 22, 17, 1, -22 },
  { 1862, 15, 22, 15, 1, -22 },
  { 1904, 15, 22, 15, 3, -22 },
  { 1946, 18, 22, 21, 3, -22 },
  { 1996, 16, 22, 17, 3, -22 },
  { 2040, 24, 22, 26, 4, -22 },
  { 2106, 20, 22, 15, -2, -22 },
  { 2161, 15, 22, 15, 3, -22 },
  { 2203, 18, 22, 17, 0, -22 },
  { 2253, 11, 27, 9, 0, -22 },
  { 2291, 5, 22, 10, 3, -22 },
  { 2305, 11, 27, 9, -2, -22 },
  { 2343, 15, 13, 17, 1, -22 },
  { 2368, 12, 1, 12, -3, 3 },
  { 2370, 3, 5, 7, 5, -24 },
  { 2372, 14, 17, 17, 2, -17 },
  { 2402, 15, 24, 18, 1, -24 },
  { 2447, 12, 17, 14, 2, -17 },
  { 2473, 16, 24, 18, 2, -24 },
  { 2521, 12, 17, 15, 2, -17 },
  { 2547, 17, 31, 9, -4, -24 },
  { 2613, 16, 24, 18, 1, -17 },
  { 2661, 14, 24, 17, 1, -24 },
  { 2703, 6, 22, 7, 1, -22 },
  { 2720, 11, 29, 7, -4, -22 },
  { 2760, 14, 24, 14, 1, -24 },
  { 2802, 6, 24, 7, 1, -24 },
  { 2820, 23, 17, 26, 1, -17 },
  { 2869, 15, 17, 17, 1, -17 },
  { 2901, 14, 17, 18, 2, -17 },
  { 2931, 17, 24, 18, -1, -17 },
  { 2982, 15, 24, 18, 2, -17 },
  { 3027, 11, 17, 12, 1, -17 },
  { 3051, 12, 17, 13, 0, -17 },
  { 3077, 8, 20, 10, 2, -20 },
  { 3097, 14, 16, 17, 2, -16 },
  { 3125, 13, 16, 13, 2, -16 },
  { 3151, 20, 16, 21, 2, -16 },
  { 3191, 16, 16, 14, -1, -16 },
  { 3223, 18, 24, 13, -3, -16 },
  { 3277, 14, 16, 14, 0, -16 },
  { 3305, 11, 27, 10, 1, -22 },
  { 3343, 1, 31, 17, 9, -24 },
  { 3347, 11, 27, 10, -1, -22 },
  { 3385, 15, 3, 18, 2, -12 },
};

const GFXfont NotoSans_ExtraLightItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRALIGHTITALIC31PT7B_H_
