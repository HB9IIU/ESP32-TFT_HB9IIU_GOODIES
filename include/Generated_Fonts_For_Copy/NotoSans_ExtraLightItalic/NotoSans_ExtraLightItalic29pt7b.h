#ifndef _NOTOSANS_EXTRALIGHTITALIC29PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x42, 0x08, 0x20, 0x86,
  0x10, 0x00, 0x00, 0x30, 0xC0, 0x22, 0x85, 0x12, 0x24, 0x48, 0xA1, 0x44,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08,
  0x20, 0x08, 0x20, 0x7F, 0xFF, 0x02, 0x08, 0x02, 0x04, 0x01, 0x04, 0x00,
  0x82, 0x00, 0x81, 0x00, 0x41, 0x0B, 0xFF, 0xF8, 0x10, 0x40, 0x10, 0x20,
  0x08, 0x20, 0x04, 0x10, 0x04, 0x08, 0x02, 0x08, 0x00, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x01, 0xDF, 0x08, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10,
  0x80, 0x64, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0xE0, 0x04, 0xC0, 0x21, 0x00,
  0x84, 0x02, 0x10, 0x08, 0xC0, 0x46, 0x3F, 0xF0, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x0F, 0x00, 0x42, 0x20, 0x10, 0x82, 0x04, 0x10, 0x41,
  0x84, 0x08, 0x20, 0x81, 0x08, 0x10, 0x62, 0x02, 0x08, 0xC0, 0xC1, 0x11,
  0x98, 0x24, 0xC9, 0x09, 0x21, 0xA2, 0x64, 0x13, 0x89, 0x02, 0x02, 0x20,
  0x40, 0x84, 0x08, 0x10, 0x82, 0x04, 0x30, 0x41, 0x06, 0x08, 0x40, 0x42,
  0x08, 0x08, 0xC6, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xC2, 0x00, 0x60, 0x40,
  0x10, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40, 0x80, 0x18, 0x40, 0x02,
  0x60, 0x00, 0x60, 0x00, 0x78, 0x00, 0x62, 0x03, 0x20, 0x40, 0x90, 0x18,
  0x64, 0x02, 0x12, 0x00, 0x48, 0x80, 0x0C, 0x30, 0x03, 0x04, 0x01, 0x41,
  0x81, 0x88, 0x3F, 0x83, 0x00, 0x29, 0x24, 0xA4, 0x01, 0x02, 0x04, 0x0C,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x80,
  0x02, 0x00, 0x20, 0x02, 0x08, 0x40, 0x64, 0x01, 0xC3, 0x07, 0xC1, 0xC0,
  0x32, 0x06, 0x20, 0xC1, 0x00, 0x10, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x0F, 0xFF, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x32, 0x24, 0x48, 0x80, 0xFE, 0xF0, 0x00,
  0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x03, 0xE0,
  0x61, 0x86, 0x06, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x06,
  0x80, 0x24, 0x03, 0x30, 0x10, 0xC3, 0x03, 0xF0, 0x00, 0x02, 0x1C, 0x5B,
  0x28, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x30,
  0x40, 0x81, 0x06, 0x00, 0x01, 0xF8, 0x0E, 0x18, 0x10, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x38, 0x61,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x03, 0x80, 0xFC, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x20, 0x18, 0x7F, 0x80, 0x00, 0x06, 0x00,
  0x14, 0x00, 0x70, 0x00, 0xA0, 0x02, 0x40, 0x08, 0x80, 0x23, 0x00, 0x84,
  0x02, 0x08, 0x08, 0x10, 0x30, 0x20, 0xC0, 0x83, 0x01, 0x04, 0x02, 0x10,
  0x04, 0x7F, 0xFF, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x84, 0x06, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x43, 0x81, 0x61, 0x86, 0x03,
  0x30, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00,
  0x84, 0x06, 0x18, 0x30, 0x3F, 0x00, 0x7F, 0xF8, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x18, 0x20, 0xC0, 0x42, 0x01,
  0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x04, 0x30, 0x0F, 0x00, 0x78,
  0x06, 0x18, 0x30, 0x31, 0x00, 0x44, 0x00, 0xB0, 0x02, 0xC0, 0x0B, 0x00,
  0x44, 0x01, 0x18, 0x18, 0x1F, 0xC0, 0x03, 0xE0, 0x18, 0x60, 0x80, 0x84,
  0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x33,
  0x01, 0xC6, 0x0A, 0x0F, 0xC8, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0xFE, 0x00, 0x10, 0xC4, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x18, 0x04, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x08, 0x10, 0x40, 0x82, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x1F, 0x18,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x07, 0xBC, 0x00, 0xC0, 0x18, 0x18, 0x00, 0x61,
  0x80, 0x01, 0x18, 0x00, 0x04, 0x80, 0xF0, 0x28, 0x18, 0x61, 0x41, 0x82,
  0x0C, 0x18, 0x10, 0x60, 0x80, 0x83, 0x0C, 0x04, 0x18, 0x40, 0x40, 0xC2,
  0x02, 0x06, 0x10, 0x30, 0x50, 0x81, 0x86, 0x82, 0x34, 0x64, 0x0E, 0x1C,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x28, 0x00, 0x28,
  0x00, 0x48, 0x00, 0xC8, 0x00, 0x88, 0x01, 0x84, 0x01, 0x04, 0x02, 0x04,
  0x02, 0x04, 0x04, 0x04, 0x0F, 0xFC, 0x08, 0x04, 0x18, 0x06, 0x10, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x07, 0xF0,
  0x0C, 0x1E, 0x0C, 0x02, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x03,
  0x10, 0x02, 0x10, 0x04, 0x10, 0x38, 0x1F, 0xF0, 0x30, 0x08, 0x20, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x18,
  0x40, 0x30, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0x83, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18, 0x08, 0x0F, 0xF0, 0x07, 0xE0,
  0x06, 0x1E, 0x03, 0x00, 0x81, 0x00, 0x20, 0x80, 0x18, 0x40, 0x04, 0x60,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x26, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x06, 0x60, 0x06, 0x20, 0x06,
  0x10, 0x06, 0x08, 0x1C, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x10, 0x7F, 0xC1, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x21, 0xFF, 0x82, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xC0, 0xC1, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x0F, 0xEC, 0x00, 0x36, 0x00, 0x13, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x30, 0x03, 0x08, 0x01, 0x03, 0x01, 0x80, 0xFF, 0x80,
  0x04, 0x00, 0x61, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x01, 0x86, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10,
  0x7F, 0xFE, 0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0xC1,
  0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x0C,
  0x00, 0x40, 0x0F, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0xF8, 0x00, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x0F, 0x80, 0x04, 0x00, 0x86, 0x00,
  0x82, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x61, 0x00, 0x21,
  0x00, 0x11, 0x00, 0x09, 0x80, 0x07, 0x40, 0x07, 0x30, 0x02, 0x08, 0x01,
  0x06, 0x00, 0x81, 0x00, 0x40, 0xC0, 0x60, 0x20, 0x20, 0x18, 0x10, 0x04,
  0x08, 0x02, 0x0C, 0x00, 0x80, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0F, 0xFE, 0x04, 0x00,
  0x04, 0x38, 0x00, 0x30, 0xA0, 0x01, 0xC2, 0x80, 0x05, 0x0A, 0x00, 0x2C,
  0x28, 0x00, 0xA1, 0xA0, 0x04, 0x84, 0x40, 0x32, 0x11, 0x00, 0x88, 0x44,
  0x04, 0x61, 0x10, 0x11, 0x0C, 0x40, 0x84, 0x21, 0x06, 0x10, 0x82, 0x10,
  0x42, 0x08, 0xC2, 0x08, 0x22, 0x08, 0x40, 0x90, 0x21, 0x02, 0x40, 0x84,
  0x0A, 0x02, 0x10, 0x18, 0x10, 0xC0, 0x40, 0x40, 0x04, 0x00, 0x61, 0x80,
  0x08, 0x28, 0x01, 0x05, 0x00, 0x20, 0xB0, 0x04, 0x12, 0x01, 0x86, 0x40,
  0x20, 0x84, 0x04, 0x10, 0x80, 0x82, 0x18, 0x10, 0x41, 0x06, 0x18, 0x20,
  0x82, 0x02, 0x10, 0x40, 0x42, 0x08, 0x04, 0x41, 0x00, 0x90, 0x40, 0x1A,
  0x08, 0x01, 0x41, 0x00, 0x28, 0x20, 0x03, 0x0C, 0x00, 0x40, 0x01, 0xFC,
  0x01, 0xC1, 0x80, 0xC0, 0x10, 0x60, 0x06, 0x10, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0F, 0x00,
  0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03,
  0x18, 0x01, 0x82, 0x00, 0xC0, 0x60, 0x60, 0x0F, 0xF0, 0x00, 0x07, 0xE0,
  0x18, 0x78, 0x30, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x46, 0x00, 0x88,
  0x01, 0x10, 0x06, 0x20, 0x08, 0x40, 0x61, 0xFF, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0xC1, 0x80, 0xC0, 0x10, 0x60, 0x06, 0x10,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00,
  0x34, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x19,
  0x00, 0x04, 0x40, 0x03, 0x18, 0x01, 0x82, 0x00, 0xC0, 0x60, 0x60, 0x0F,
  0xF0, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x07, 0xE0, 0x18, 0x78, 0x30, 0x18, 0x40, 0x10, 0x80, 0x21, 0x00,
  0x46, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x18, 0x40, 0xE1, 0xFE, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x10, 0x60, 0x20, 0x80, 0x61, 0x00,
  0x42, 0x00, 0x8C, 0x00, 0x80, 0x03, 0xF0, 0x30, 0x31, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x20, 0x30, 0xFF, 0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x08, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x08, 0x80,
  0x06, 0x20, 0x01, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x23, 0x00, 0x18, 0x40, 0x04, 0x10, 0x03, 0x06,
  0x00, 0x80, 0xC0, 0xC0, 0x1F, 0xE0, 0x00, 0x80, 0x03, 0x00, 0x0A, 0x00,
  0x34, 0x00, 0x4C, 0x01, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x40,
  0x80, 0x81, 0x02, 0x02, 0x04, 0x06, 0x10, 0x04, 0x20, 0x08, 0x80, 0x13,
  0x00, 0x24, 0x00, 0x58, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80,
  0x20, 0x06, 0x00, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x14, 0x06, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x44, 0x08, 0x83, 0x10, 0x42,
  0x08, 0x41, 0x08, 0x61, 0x0C, 0x21, 0x04, 0x20, 0x8C, 0x11, 0x82, 0x20,
  0x44, 0x08, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x50,
  0x0A, 0x01, 0x40, 0x30, 0x02, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x60,
  0x40, 0x18, 0x08, 0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00,
  0x23, 0x00, 0x04, 0xC0, 0x00, 0x50, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x50, 0x00, 0x1A, 0x00, 0x06, 0x20, 0x00, 0x84, 0x00, 0x20, 0xC0, 0x08,
  0x08, 0x03, 0x01, 0x00, 0xC0, 0x10, 0x10, 0x02, 0x0C, 0x00, 0x60, 0x80,
  0x0E, 0x00, 0x2C, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x01, 0x02, 0x08, 0x08,
  0x60, 0x21, 0x00, 0xC8, 0x01, 0x60, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x07, 0xFF, 0x84, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x84, 0x1F, 0x00, 0x84, 0x21, 0x04,
  0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x82, 0x10, 0x84, 0x21, 0x80, 0x07,
  0xE0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x80, 0x00,
  0x40, 0x03, 0x00, 0x14, 0x00, 0x48, 0x02, 0x20, 0x18, 0x80, 0x41, 0x02,
  0x04, 0x18, 0x10, 0x40, 0x22, 0x00, 0x98, 0x02, 0xC0, 0x04, 0xFF, 0xF0,
  0xC4, 0x23, 0x01, 0x80, 0x19, 0x91, 0x81, 0x44, 0x06, 0x20, 0x08, 0x80,
  0x24, 0x00, 0x90, 0x06, 0x40, 0x11, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0x40,
  0x51, 0x01, 0x86, 0x1A, 0x0F, 0x88, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x0E, 0x04, 0xEC, 0x14, 0x08, 0x60, 0x33,
  0x00, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x16, 0x00, 0x50, 0x02, 0x40, 0x09,
  0x00, 0x24, 0x01, 0x28, 0x0C, 0xB0, 0x62, 0x7E, 0x00, 0x03, 0xC1, 0x8C,
  0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x18, 0x21, 0xFC, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x01, 0xC6, 0x06, 0x64, 0x18,
  0x14, 0x10, 0x0C, 0x20, 0x0C, 0x60, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0x40, 0x30, 0x40, 0x50, 0x60,
  0x90, 0x3F, 0x20, 0x03, 0x81, 0x9C, 0x40, 0x90, 0x14, 0x02, 0x80, 0x60,
  0x34, 0x3C, 0xF8, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x18, 0x11,
  0xFC, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x01,
  0xC2, 0x0C, 0xC8, 0x60, 0x50, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x10, 0x02,
  0x20, 0x04, 0x40, 0x08, 0x80, 0x33, 0x00, 0x46, 0x01, 0x84, 0x03, 0x08,
  0x0A, 0x18, 0x2C, 0x1F, 0x90, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x10, 0x30, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x41, 0x02, 0x67, 0x14, 0x08, 0xC0, 0x4C,
  0x02, 0x60, 0x12, 0x00, 0x90, 0x05, 0x80, 0x28, 0x03, 0x40, 0x12, 0x00,
  0x90, 0x05, 0x80, 0x28, 0x02, 0x40, 0x10, 0x0C, 0x20, 0x00, 0x00, 0x01,
  0x04, 0x10, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x80, 0x00,
  0x60, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x70, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x22, 0x02, 0x10, 0x20, 0x82, 0x08, 0x20, 0x42, 0x02, 0x20, 0x12,
  0x01, 0xF8, 0x0E, 0x40, 0x63, 0x02, 0x08, 0x10, 0x61, 0x81, 0x08, 0x0C,
  0x40, 0x20, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x86, 0x10, 0x41, 0x04, 0x30, 0x82, 0x00, 0x00, 0xC0, 0x70, 0x4C, 0xC6,
  0x61, 0x41, 0x20, 0xC6, 0x05, 0x01, 0x30, 0x18, 0x04, 0xC0, 0x60, 0x12,
  0x01, 0x00, 0xC8, 0x04, 0x02, 0x60, 0x10, 0x09, 0x00, 0x40, 0x24, 0x02,
  0x00, 0x90, 0x08, 0x06, 0x40, 0x20, 0x13, 0x00, 0x80, 0x48, 0x06, 0x01,
  0x20, 0x10, 0x0C, 0x00, 0xC0, 0x4E, 0xE1, 0x40, 0x86, 0x02, 0x30, 0x0C,
  0xC0, 0x22, 0x00, 0x88, 0x02, 0x60, 0x09, 0x00, 0x64, 0x01, 0x10, 0x04,
  0x40, 0x13, 0x00, 0x48, 0x02, 0x20, 0x08, 0x01, 0x80, 0x77, 0x0C, 0x0C,
  0x40, 0x24, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xA0,
  0x05, 0x00, 0x28, 0x02, 0x40, 0x31, 0x03, 0x07, 0xE0, 0x00, 0x38, 0x04,
  0xEC, 0x05, 0x02, 0x06, 0x03, 0x0C, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x18, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x28,
  0x0C, 0x2C, 0x18, 0x27, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xC2, 0x0C, 0xC8, 0x60,
  0x50, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x33, 0x00, 0x46, 0x01, 0x84, 0x03, 0x08, 0x0A, 0x18, 0x2C, 0x1F,
  0x90, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x00, 0xC2, 0x64, 0x50, 0x0C, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x03, 0x80, 0xCF, 0x10, 0x03, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x80, 0x87,
  0xF0, 0x10, 0x10, 0x20, 0x20, 0xFF, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xF8, 0x20, 0x09, 0x00, 0x50,
  0x06, 0x80, 0x24, 0x01, 0x20, 0x0B, 0x00, 0x50, 0x06, 0x80, 0x24, 0x01,
  0x20, 0x19, 0x01, 0x48, 0x0C, 0x41, 0xA1, 0xF1, 0x00, 0xC0, 0x1A, 0x01,
  0x90, 0x08, 0x80, 0x84, 0x04, 0x20, 0x41, 0x86, 0x04, 0x20, 0x23, 0x01,
  0x10, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00, 0x40, 0x00, 0x80, 0x80,
  0x60, 0x50, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x21, 0x10, 0x88,
  0x44, 0x22, 0x21, 0x18, 0x88, 0x44, 0x24, 0x13, 0x09, 0x04, 0x82, 0x81,
  0x60, 0xA0, 0x30, 0x30, 0x0C, 0x0C, 0x02, 0x00, 0x18, 0x06, 0x18, 0x10,
  0x10, 0x40, 0x21, 0x00, 0x26, 0x00, 0x58, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x80, 0x09, 0x00, 0x21, 0x00, 0x82, 0x03, 0x02, 0x0C, 0x04, 0x30, 0x04,
  0x00, 0x0C, 0x01, 0x82, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x98,
  0x00, 0x48, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0xFF,
  0x00, 0x00, 0x40, 0xE0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0xE0, 0x38, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x38, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x04, 0x01, 0xC0, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x20, 0x0C, 0x01, 0xC0, 0x70, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0xE0, 0x20, 0x00, 0x18,
  0x03, 0x9C, 0x38, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraLightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 21, 6, 1, -21 },
  { 17, 7, 8, 9, 3, -21 },
  { 24, 17, 21, 18, 1, -21 },
  { 69, 14, 24, 16, 1, -22 },
  { 111, 19, 21, 22, 2, -21 },
  { 161, 18, 21, 20, 1, -21 },
  { 209, 3, 8, 5, 3, -21 },
  { 212, 8, 26, 7, 1, -21 },
  { 238, 8, 26, 7, -2, -21 },
  { 264, 12, 12, 16, 4, -22 },
  { 282, 14, 13, 17, 2, -17 },
  { 305, 4, 7, 6, -1, -3 },
  { 309, 7, 1, 9, 1, -8 },
  { 310, 2, 2, 6, 1, -2 },
  { 311, 13, 21, 9, -1, -21 },
  { 346, 13, 21, 16, 2, -21 },
  { 381, 7, 21, 16, 5, -21 },
  { 400, 15, 21, 16, 0, -21 },
  { 440, 14, 21, 16, 1, -21 },
  { 477, 15, 21, 16, 0, -21 },
  { 517, 15, 21, 16, 1, -21 },
  { 557, 14, 21, 16, 2, -21 },
  { 594, 13, 21, 16, 3, -21 },
  { 629, 14, 21, 16, 1, -21 },
  { 666, 14, 21, 16, 1, -21 },
  { 703, 5, 16, 6, 1, -16 },
  { 713, 7, 20, 6, -1, -16 },
  { 731, 14, 13, 17, 2, -17 },
  { 754, 14, 7, 17, 2, -14 },
  { 767, 14, 13, 17, 2, -17 },
  { 790, 10, 21, 12, 2, -21 },
  { 817, 21, 24, 24, 2, -21 },
  { 880, 16, 21, 16, -1, -21 },
  { 922, 16, 21, 17, 1, -21 },
  { 964, 16, 21, 17, 2, -21 },
  { 1006, 17, 21, 20, 1, -21 },
  { 1051, 15, 21, 15, 1, -21 },
  { 1091, 15, 21, 14, 1, -21 },
  { 1131, 17, 21, 20, 2, -21 },
  { 1176, 19, 21, 20, 1, -21 },
  { 1226, 10, 21, 8, 0, -21 },
  { 1253, 12, 26, 7, -5, -21 },
  { 1292, 17, 21, 16, 1, -21 },
  { 1337, 11, 21, 14, 1, -21 },
  { 1366, 22, 21, 24, 1, -21 },
  { 1424, 19, 21, 20, 1, -21 },
  { 1474, 18, 21, 21, 2, -21 },
  { 1522, 15, 21, 16, 1, -21 },
  { 1562, 18, 26, 21, 2, -21 },
  { 1621, 15, 21, 16, 1, -21 },
  { 1661, 14, 21, 14, 1, -21 },
  { 1698, 14, 21, 14, 3, -21 },
  { 1735, 18, 21, 20, 2, -21 },
  { 1783, 15, 21, 16, 3, -21 },
  { 1823, 22, 21, 24, 4, -21 },
  { 1881, 19, 21, 14, -2, -21 },
  { 1931, 14, 21, 14, 3, -21 },
  { 1968, 17, 21, 16, 0, -21 },
  { 2013, 11, 26, 9, 0, -21 },
  { 2049, 5, 21, 9, 3, -21 },
  { 2063, 11, 26, 9, -2, -21 },
  { 2099, 14, 13, 16, 1, -21 },
  { 2122, 12, 1, 11, -3, 3 },
  { 2124, 4, 4, 7, 4, -22 },
  { 2126, 14, 16, 16, 1, -16 },
  { 2154, 14, 22, 17, 1, -22 },
  { 2193, 11, 16, 13, 2, -16 },
  { 2215, 16, 22, 17, 1, -22 },
  { 2259, 11, 16, 14, 2, -16 },
  { 2281, 16, 29, 8, -4, -22 },
  { 2339, 15, 23, 17, 1, -16 },
  { 2383, 13, 22, 16, 1, -22 },
  { 2419, 6, 21, 6, 1, -21 },
  { 2435, 11, 28, 6, -4, -21 },
  { 2474, 13, 22, 13, 1, -22 },
  { 2510, 6, 22, 6, 1, -22 },
  { 2527, 22, 16, 25, 1, -16 },
  { 2571, 14, 16, 16, 1, -16 },
  { 2599, 13, 16, 16, 2, -16 },
  { 2625, 16, 23, 17, -1, -16 },
  { 2671, 15, 23, 17, 1, -16 },
  { 2715, 11, 16, 11, 1, -16 },
  { 2737, 12, 16, 12, 0, -16 },
  { 2761, 8, 19, 9, 2, -19 },
  { 2780, 13, 15, 16, 2, -15 },
  { 2805, 13, 15, 12, 1, -15 },
  { 2830, 18, 15, 19, 2, -15 },
  { 2864, 15, 15, 13, -1, -15 },
  { 2893, 17, 22, 12, -3, -15 },
  { 2940, 13, 15, 13, 0, -15 },
  { 2965, 10, 26, 10, 1, -21 },
  { 2998, 1, 29, 16, 8, -22 },
  { 3002, 10, 26, 10, -1, -21 },
  { 3035, 14, 3, 17, 2, -12 },
};

const GFXfont NotoSans_ExtraLightItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRALIGHTITALIC29PT7B_H_
