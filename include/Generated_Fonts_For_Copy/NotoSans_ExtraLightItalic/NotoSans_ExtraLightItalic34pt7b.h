#ifndef _NOTOSANS_EXTRALIGHTITALIC34PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x40, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x40, 0x00, 0x00, 0x00, 0x30, 0x60, 0x63, 0x42,
  0x42, 0x42, 0xC6, 0x84, 0x84, 0x84, 0x84, 0x00, 0x60, 0x40, 0x04, 0x08,
  0x00, 0x40, 0x80, 0x0C, 0x08, 0x00, 0x81, 0x80, 0x08, 0x10, 0x00, 0x81,
  0x03, 0xFF, 0xFF, 0x01, 0x02, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x20,
  0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x04, 0x04, 0x0F, 0xFF, 0xFC, 0x04,
  0x08, 0x00, 0xC0, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01,
  0x01, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x01, 0xF8, 0x07, 0x4F, 0x0C, 0x40, 0x18, 0x40, 0x10, 0x40, 0x10,
  0xC0, 0x10, 0x80, 0x10, 0x80, 0x18, 0x80, 0x0E, 0x80, 0x03, 0x80, 0x01,
  0xE0, 0x01, 0x30, 0x01, 0x08, 0x01, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02,
  0x08, 0x02, 0x10, 0x82, 0x60, 0xFF, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x01, 0x8C, 0x20, 0x08, 0x41,
  0x80, 0x84, 0x0C, 0x0C, 0x20, 0x60, 0xC3, 0x03, 0x04, 0x18, 0x10, 0x40,
  0x80, 0x86, 0x04, 0x04, 0x60, 0x20, 0x62, 0x3D, 0x02, 0x23, 0x38, 0x13,
  0x20, 0xE1, 0x13, 0x05, 0xF1, 0x10, 0x22, 0x11, 0x81, 0x01, 0x88, 0x08,
  0x08, 0x40, 0x40, 0x82, 0x02, 0x08, 0x10, 0x30, 0xC0, 0x81, 0x04, 0x04,
  0x08, 0x40, 0x20, 0x84, 0x01, 0x8C, 0x60, 0x07, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0xF0, 0x00, 0x60, 0xC0, 0x06, 0x02, 0x00, 0x20, 0x18, 0x01, 0x00,
  0xC0, 0x08, 0x04, 0x00, 0x40, 0x60, 0x02, 0x02, 0x00, 0x08, 0x60, 0x00,
  0x6E, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x30, 0x00, 0x60, 0x80,
  0x66, 0x02, 0x02, 0x60, 0x18, 0x22, 0x00, 0x63, 0x10, 0x01, 0x11, 0x80,
  0x05, 0x04, 0x00, 0x30, 0x20, 0x01, 0xC1, 0x80, 0x32, 0x06, 0x07, 0x18,
  0x1F, 0xE0, 0x60, 0x69, 0x2D, 0x24, 0x80, 0x00, 0xC0, 0x40, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0xC1, 0x00, 0xC4, 0x00, 0xD0, 0x40, 0xFF, 0x07,
  0x00, 0x34, 0x01, 0x88, 0x0C, 0x20, 0x60, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x7F, 0xFF, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x08, 0xC6, 0x23, 0x11, 0x98, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x03, 0xFC, 0x06, 0x06, 0x0C, 0x02, 0x18, 0x03, 0x10,
  0x03, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x03, 0x40,
  0x03, 0x40, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0,
  0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x18, 0x40, 0x10, 0x60, 0x30, 0x30,
  0x60, 0x1F, 0x80, 0x01, 0x83, 0xC3, 0x66, 0x2E, 0x12, 0x08, 0x0C, 0x04,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x00, 0x18, 0x00, 0xFF, 0x81, 0xC0,
  0x60, 0x40, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x38, 0x01, 0xFF, 0x03, 0x80, 0xC1, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x07, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x61, 0x80, 0x60, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x68, 0x00, 0x36, 0x00, 0x19, 0x00, 0x04, 0x40, 0x02, 0x10, 0x01, 0x0C,
  0x00, 0x83, 0x00, 0x60, 0x80, 0x30, 0x20, 0x18, 0x08, 0x0C, 0x06, 0x06,
  0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x03, 0xFF, 0x81, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x60, 0x07, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC3, 0x00,
  0xC0, 0xFF, 0x80, 0x00, 0x0E, 0x80, 0x7F, 0x80, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0xFC, 0x0D, 0xC3, 0x05, 0x80, 0xC3, 0x00, 0x21, 0x80, 0x19, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x18, 0x00, 0x84, 0x00, 0xC2,
  0x00, 0x41, 0x80, 0x40, 0x60, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x60, 0x03, 0xFC, 0x06, 0x06,
  0x0C, 0x03, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x18, 0x03, 0x08, 0x02,
  0x0C, 0x04, 0x06, 0x18, 0x03, 0x60, 0x03, 0xC0, 0x0C, 0x70, 0x30, 0x18,
  0x60, 0x08, 0xC0, 0x0C, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0xC0, 0x18, 0x60, 0x30, 0x1F, 0xC0, 0x00, 0x40, 0x03, 0xF8,
  0x0C, 0x0C, 0x18, 0x06, 0x10, 0x02, 0x30, 0x03, 0x20, 0x03, 0x20, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x06, 0x20, 0x0E, 0x30, 0x1A,
  0x1E, 0xE6, 0x07, 0x84, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x81, 0x80, 0xFE, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x07, 0xFC, 0x40, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x08, 0x80, 0x7F, 0x82, 0x60, 0x30, 0x60, 0x90, 0x10, 0x10,
  0x34, 0x08, 0x04, 0x0F, 0x06, 0x01, 0x02, 0x81, 0x00, 0xC0, 0xA0, 0x40,
  0x20, 0x28, 0x30, 0x08, 0x0A, 0x0C, 0x06, 0x04, 0x83, 0x01, 0x81, 0x20,
  0xC0, 0xA0, 0x88, 0x10, 0x48, 0x63, 0x03, 0xE3, 0xE0, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x22, 0x00, 0x0C,
  0x60, 0x01, 0x0C, 0x00, 0x60, 0x80, 0x08, 0x10, 0x02, 0x02, 0x00, 0xC0,
  0x40, 0x10, 0x08, 0x06, 0x01, 0x80, 0xFF, 0xF0, 0x30, 0x02, 0x04, 0x00,
  0x41, 0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x23, 0x00, 0x06, 0x40, 0x00,
  0xD8, 0x00, 0x0E, 0x00, 0x01, 0x07, 0xFE, 0x03, 0x00, 0xE0, 0xC0, 0x08,
  0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x02, 0x10,
  0x01, 0x84, 0x00, 0xC3, 0x01, 0xC0, 0xFF, 0xE0, 0x20, 0x0C, 0x08, 0x00,
  0x82, 0x00, 0x31, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x31,
  0x00, 0x08, 0xC0, 0x06, 0x30, 0x03, 0x08, 0x03, 0x83, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xFC, 0x0E, 0x01, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0xC0, 0x70, 0x0C, 0x01, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x60,
  0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x03, 0x10, 0x00, 0x31, 0x00, 0x03,
  0x30, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x01, 0x84, 0x00,
  0x30, 0xC0, 0x06, 0x0C, 0x01, 0xC0, 0x80, 0xF0, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x86, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0x82, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x86, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xC1, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x03, 0x80,
  0x20, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x03, 0xFC, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x88,
  0x00, 0x08, 0x80, 0x00, 0x8C, 0x00, 0x18, 0x40, 0x01, 0x86, 0x00, 0x10,
  0x30, 0x01, 0x01, 0x80, 0x70, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x08, 0x60,
  0x00, 0xC3, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x18,
  0x60, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00,
  0x18, 0x7F, 0xFF, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x20, 0x07,
  0xE0, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x86, 0x03, 0xF0,
  0x00, 0x04, 0x00, 0x70, 0xC0, 0x0C, 0x0C, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x0C, 0x00, 0x81, 0x80, 0x18, 0x30, 0x01, 0x06, 0x00, 0x10, 0xC0, 0x01,
  0x18, 0x00, 0x33, 0x00, 0x03, 0x58, 0x00, 0x28, 0x80, 0x03, 0x0C, 0x00,
  0x20, 0x40, 0x06, 0x06, 0x00, 0x60, 0x20, 0x04, 0x03, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0x80, 0x80, 0x0C, 0x08, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0F,
  0xFF, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xA0, 0x00, 0x28, 0x28,
  0x00, 0x1E, 0x0A, 0x00, 0x05, 0x82, 0xC0, 0x02, 0x41, 0x90, 0x01, 0x90,
  0x44, 0x00, 0x44, 0x11, 0x00, 0x33, 0x04, 0x40, 0x08, 0x83, 0x10, 0x04,
  0x20, 0xC6, 0x03, 0x08, 0x20, 0x80, 0x82, 0x08, 0x20, 0x61, 0x82, 0x08,
  0x10, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x82, 0x04, 0x10, 0x31, 0x03, 0x04,
  0x04, 0xC0, 0xC1, 0x01, 0x20, 0x20, 0xC0, 0x58, 0x08, 0x20, 0x14, 0x02,
  0x08, 0x06, 0x01, 0x82, 0x01, 0x80, 0x60, 0x04, 0x00, 0x08, 0x70, 0x00,
  0xC2, 0x80, 0x04, 0x16, 0x00, 0x20, 0x90, 0x01, 0x04, 0x80, 0x08, 0x66,
  0x00, 0xC2, 0x10, 0x04, 0x10, 0xC0, 0x20, 0x82, 0x01, 0x0C, 0x10, 0x18,
  0x60, 0xC0, 0xC2, 0x02, 0x04, 0x10, 0x18, 0x20, 0x80, 0x41, 0x0C, 0x03,
  0x18, 0x60, 0x08, 0xC2, 0x00, 0x44, 0x10, 0x03, 0x20, 0x80, 0x09, 0x0C,
  0x00, 0x78, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x00, 0x3C,
  0x00, 0x1F, 0xF0, 0x07, 0x01, 0xC0, 0xC0, 0x04, 0x18, 0x00, 0x63, 0x00,
  0x02, 0x20, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x14, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x4C, 0x00, 0x0C,
  0x40, 0x01, 0x86, 0x00, 0x10, 0x30, 0x07, 0x01, 0x80, 0xC0, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x06, 0x03, 0x83, 0x00, 0x41, 0x00, 0x30, 0x80, 0x08,
  0x40, 0x04, 0x60, 0x02, 0x30, 0x03, 0x10, 0x01, 0x88, 0x00, 0x8C, 0x00,
  0xC6, 0x00, 0xC2, 0x07, 0x81, 0xFE, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0x01, 0xC0,
  0xC0, 0x04, 0x18, 0x00, 0x63, 0x00, 0x02, 0x20, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x06, 0x80, 0x00, 0x4C, 0x00, 0x0C, 0x40, 0x01, 0x86, 0x00, 0x10, 0x30,
  0x07, 0x01, 0x80, 0xC0, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x07, 0xFC,
  0x06, 0x03, 0x83, 0x00, 0x41, 0x00, 0x30, 0x80, 0x08, 0x40, 0x04, 0x60,
  0x02, 0x30, 0x03, 0x10, 0x01, 0x88, 0x01, 0x8C, 0x00, 0x86, 0x01, 0x83,
  0xFF, 0x01, 0x03, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x20, 0x08,
  0x10, 0x04, 0x08, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x42, 0x00, 0x31, 0x00,
  0x08, 0x00, 0x38, 0x03, 0xFF, 0x06, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x80,
  0x70, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x18, 0x80, 0x00, 0x84,
  0x00, 0x04, 0x20, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x10, 0x80, 0x00,
  0x84, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x10, 0x80,
  0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x10,
  0x80, 0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x80, 0x06, 0x0C, 0x00,
  0x60, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0xD0,
  0x00, 0x24, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x01, 0x86, 0x00,
  0x41, 0x80, 0x30, 0x20, 0x08, 0x08, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x20, 0x20, 0x08, 0x10, 0x03, 0x04, 0x00, 0xC2, 0x00, 0x11, 0x80, 0x04,
  0x40, 0x01, 0x30, 0x00, 0x48, 0x00, 0x16, 0x00, 0x05, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x1B, 0x00, 0x70,
  0x02, 0x60, 0x0A, 0x00, 0x4C, 0x03, 0x40, 0x19, 0x80, 0x48, 0x02, 0x30,
  0x09, 0x80, 0xC6, 0x02, 0x30, 0x10, 0x40, 0x46, 0x06, 0x08, 0x10, 0xC0,
  0x81, 0x02, 0x08, 0x30, 0x20, 0x81, 0x04, 0x04, 0x10, 0x21, 0x80, 0x86,
  0x04, 0x20, 0x10, 0x80, 0x84, 0x02, 0x30, 0x11, 0x00, 0x44, 0x02, 0x20,
  0x09, 0x80, 0x4C, 0x01, 0x20, 0x09, 0x00, 0x2C, 0x01, 0x60, 0x05, 0x00,
  0x28, 0x00, 0xE0, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x08, 0x00, 0x80, 0x40, 0x08, 0x03, 0x00, 0x80, 0x08,
  0x0C, 0x00, 0x40, 0xC0, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x64, 0x00,
  0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x2C,
  0x00, 0x02, 0x20, 0x00, 0x31, 0x80, 0x03, 0x04, 0x00, 0x30, 0x20, 0x01,
  0x01, 0x80, 0x10, 0x04, 0x01, 0x00, 0x30, 0x18, 0x00, 0x81, 0x80, 0x04,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0xA0, 0x01, 0x90, 0x01, 0x8C, 0x00, 0x82,
  0x00, 0x81, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x40, 0x10, 0x60, 0x08, 0x60,
  0x06, 0x20, 0x01, 0x20, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x0F, 0xE0, 0x00, 0xC1, 0x04, 0x10, 0x41, 0x82, 0x08, 0x20, 0x82, 0x0C,
  0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x03, 0xF0, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x80, 0x08,
  0x80, 0x31, 0x00, 0x42, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x20, 0x08,
  0xC0, 0x11, 0x00, 0x24, 0x00, 0x78, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xF8,
  0xC4, 0x62, 0x10, 0x07, 0xF3, 0x0C, 0x1A, 0x18, 0x0A, 0x30, 0x0A, 0x20,
  0x06, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x38, 0x80, 0x38, 0xC0, 0x50, 0x61,
  0x90, 0x3F, 0x10, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0xFC, 0x04, 0x83,
  0x06, 0x80, 0xC2, 0x80, 0x21, 0x80, 0x10, 0xC0, 0x0C, 0xC0, 0x06, 0x60,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x23,
  0x00, 0x31, 0x80, 0x10, 0xA0, 0x10, 0xD8, 0x30, 0x47, 0xF0, 0x00, 0x07,
  0xFC, 0x30, 0x11, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x20, 0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x07, 0xF1, 0x03, 0x06, 0x41, 0x80, 0x70, 0xC0, 0x18, 0x60, 0x06,
  0x10, 0x01, 0x84, 0x00, 0x63, 0x00, 0x18, 0x80, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x06, 0x08, 0x02, 0x83, 0x01,
  0x20, 0x60, 0x88, 0x0F, 0xC4, 0x00, 0x03, 0xF0, 0x30, 0x61, 0x80, 0x8C,
  0x03, 0x20, 0x0D, 0x80, 0x24, 0x01, 0xB0, 0x1C, 0xFF, 0xC2, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x20,
  0x7F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x83, 0x06, 0x43,
  0x00, 0xA3, 0x00, 0x63, 0x00, 0x31, 0x00, 0x18, 0x80, 0x0C, 0xC0, 0x06,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00,
  0x61, 0x00, 0x50, 0xC0, 0x48, 0x30, 0x4C, 0x0F, 0xC4, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0xC0,
  0x3F, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0xFC, 0x09, 0x06, 0x1A,
  0x03, 0x14, 0x01, 0x18, 0x01, 0x18, 0x01, 0x30, 0x03, 0x30, 0x02, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06, 0x60, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x0C, 0xC0, 0x0C, 0x80, 0x08, 0x04, 0x0C, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x08, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83,
  0x04, 0x08, 0x10, 0x60, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0xF8, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x07, 0x08, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x10,
  0x60, 0x10, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x27, 0x00, 0x29, 0x00, 0x31,
  0x80, 0x60, 0x80, 0x60, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x40, 0x20, 0xC0,
  0x30, 0x80, 0x10, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10,
  0x60, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x00, 0x08, 0xF8, 0x3F, 0x02, 0xC3, 0x18, 0x61, 0x60, 0x6C, 0x0C,
  0x50, 0x0E, 0x03, 0x18, 0x03, 0x00, 0x46, 0x01, 0x80, 0x33, 0x00, 0x60,
  0x0C, 0xC0, 0x10, 0x02, 0x20, 0x04, 0x00, 0x88, 0x01, 0x00, 0x22, 0x00,
  0xC0, 0x19, 0x80, 0x30, 0x06, 0x60, 0x08, 0x01, 0x10, 0x02, 0x00, 0x44,
  0x00, 0x80, 0x11, 0x00, 0x60, 0x0C, 0xC0, 0x18, 0x02, 0x20, 0x04, 0x00,
  0x80, 0x08, 0xFC, 0x09, 0x86, 0x1A, 0x03, 0x14, 0x01, 0x18, 0x01, 0x18,
  0x03, 0x30, 0x03, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60,
  0x06, 0x60, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xC0, 0x0C, 0x80,
  0x08, 0x07, 0xF0, 0x18, 0x18, 0x60, 0x11, 0x80, 0x36, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x50, 0x01, 0xB0, 0x02, 0x20, 0x08, 0x70, 0x60, 0x3F, 0x80, 0x02,
  0x3F, 0x00, 0x48, 0x30, 0x1A, 0x03, 0x02, 0x80, 0x20, 0x60, 0x04, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20,
  0x01, 0x0C, 0x00, 0x61, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00, 0x40, 0xA0,
  0x10, 0x36, 0x0C, 0x04, 0x7F, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xF1, 0x0C, 0x19, 0x18, 0x0D, 0x30, 0x06, 0x60, 0x06, 0x40,
  0x06, 0x40, 0x06, 0xC0, 0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x0C, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x28, 0xC0, 0x68, 0x60, 0x98, 0x3F,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x08, 0xF8, 0x48, 0x06, 0x80, 0x28, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x07,
  0xFC, 0x30, 0x21, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0xC0, 0x61, 0xFE, 0x00, 0x08, 0x04, 0x04, 0x02, 0x0F,
  0xF9, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x03, 0xE0, 0x30, 0x03, 0x30, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x0C, 0xC0, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18,
  0x80, 0x28, 0xC0, 0x58, 0x41, 0x90, 0x7F, 0x10, 0x80, 0x0E, 0x00, 0x28,
  0x01, 0xA0, 0x04, 0xC0, 0x21, 0x01, 0x84, 0x04, 0x10, 0x30, 0x40, 0x81,
  0x06, 0x04, 0x10, 0x18, 0x80, 0x26, 0x00, 0x90, 0x02, 0xC0, 0x0A, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x0E, 0x01, 0x80, 0x28, 0x07, 0x01,
  0xA0, 0x3C, 0x04, 0x80, 0x90, 0x32, 0x06, 0x40, 0x8C, 0x11, 0x06, 0x30,
  0xC4, 0x10, 0xC2, 0x10, 0xC3, 0x18, 0x42, 0x0C, 0x41, 0x18, 0x13, 0x04,
  0x40, 0x48, 0x1B, 0x01, 0x60, 0x68, 0x05, 0x00, 0xA0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x82, 0x01, 0x81, 0x01,
  0x80, 0x40, 0x80, 0x20, 0x80, 0x18, 0x80, 0x04, 0x80, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x41, 0x80,
  0x40, 0x40, 0x60, 0x30, 0x60, 0x08, 0x60, 0x06, 0x00, 0x02, 0x00, 0x30,
  0x20, 0x02, 0x02, 0x00, 0x60, 0x30, 0x04, 0x03, 0x00, 0x80, 0x10, 0x18,
  0x01, 0x01, 0x00, 0x10, 0x30, 0x01, 0x02, 0x00, 0x18, 0x60, 0x01, 0x84,
  0x00, 0x08, 0xC0, 0x00, 0x88, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x0A,
  0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xF0, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x30, 0x0F, 0x00, 0x00, 0x18, 0x01, 0xDE, 0x06, 0x07, 0xF8, 0x01,
  0xC0,
};

const GFXglyph NotoSans_ExtraLightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 24, 7, 1, -24 },
  { 22, 8, 9, 11, 4, -24 },
  { 31, 20, 24, 21, 1, -24 },
  { 91, 16, 28, 19, 2, -26 },
  { 147, 21, 25, 26, 3, -25 },
  { 213, 21, 25, 23, 1, -25 },
  { 279, 3, 9, 6, 4, -24 },
  { 283, 10, 29, 9, 1, -24 },
  { 320, 10, 29, 9, -2, -24 },
  { 357, 14, 15, 18, 4, -26 },
  { 384, 15, 16, 19, 3, -20 },
  { 414, 5, 8, 7, -2, -4 },
  { 419, 8, 1, 11, 1, -10 },
  { 420, 2, 2, 7, 1, -2 },
  { 421, 16, 24, 11, -2, -24 },
  { 469, 16, 25, 19, 2, -25 },
  { 519, 9, 24, 19, 5, -24 },
  { 546, 17, 25, 19, 0, -25 },
  { 600, 17, 25, 19, 1, -25 },
  { 654, 18, 24, 19, 0, -24 },
  { 708, 17, 24, 19, 1, -24 },
  { 759, 17, 25, 19, 2, -25 },
  { 813, 15, 24, 19, 4, -24 },
  { 858, 16, 25, 19, 2, -25 },
  { 908, 16, 25, 19, 2, -25 },
  { 958, 6, 18, 7, 1, -18 },
  { 972, 9, 22, 7, -2, -18 },
  { 997, 15, 15, 19, 3, -20 },
  { 1026, 15, 8, 19, 3, -16 },
  { 1041, 15, 15, 19, 3, -20 },
  { 1070, 12, 25, 14, 3, -25 },
  { 1108, 26, 27, 28, 2, -24 },
  { 1196, 19, 24, 19, -2, -24 },
  { 1253, 18, 24, 20, 2, -24 },
  { 1307, 19, 25, 20, 3, -25 },
  { 1367, 20, 24, 23, 2, -24 },
  { 1427, 17, 24, 18, 2, -24 },
  { 1478, 17, 24, 16, 2, -24 },
  { 1529, 20, 25, 23, 3, -25 },
  { 1592, 21, 24, 23, 2, -24 },
  { 1655, 11, 24, 10, 0, -24 },
  { 1688, 14, 30, 8, -6, -24 },
  { 1741, 20, 24, 19, 2, -24 },
  { 1801, 12, 24, 17, 2, -24 },
  { 1837, 26, 24, 28, 2, -24 },
  { 1915, 21, 24, 23, 2, -24 },
  { 1978, 20, 25, 24, 3, -25 },
  { 2041, 17, 24, 19, 2, -24 },
  { 2092, 20, 31, 24, 3, -25 },
  { 2170, 17, 24, 19, 2, -24 },
  { 2221, 16, 25, 17, 1, -25 },
  { 2271, 17, 24, 17, 3, -24 },
  { 2322, 21, 24, 23, 3, -24 },
  { 2385, 18, 24, 18, 3, -24 },
  { 2439, 27, 24, 28, 4, -24 },
  { 2520, 21, 24, 17, -2, -24 },
  { 2583, 17, 24, 17, 3, -24 },
  { 2634, 19, 24, 18, 0, -24 },
  { 2691, 13, 29, 10, 0, -24 },
  { 2739, 6, 24, 11, 3, -24 },
  { 2757, 12, 29, 10, -2, -24 },
  { 2801, 15, 15, 19, 2, -24 },
  { 2830, 13, 1, 13, -3, 4 },
  { 2832, 4, 5, 8, 5, -26 },
  { 2835, 16, 18, 19, 2, -18 },
  { 2871, 17, 26, 19, 1, -26 },
  { 2927, 14, 18, 15, 2, -18 },
  { 2959, 18, 26, 19, 2, -26 },
  { 3018, 14, 18, 17, 2, -18 },
  { 3050, 18, 34, 9, -4, -26 },
  { 3127, 17, 26, 19, 1, -18 },
  { 3183, 16, 26, 19, 1, -26 },
  { 3235, 7, 25, 7, 1, -25 },
  { 3257, 13, 33, 7, -5, -25 },
  { 3311, 16, 26, 15, 1, -26 },
  { 3363, 7, 26, 7, 1, -26 },
  { 3386, 26, 18, 29, 1, -18 },
  { 3445, 16, 18, 19, 1, -18 },
  { 3481, 15, 18, 19, 2, -18 },
  { 3515, 19, 26, 19, -1, -18 },
  { 3577, 16, 26, 19, 2, -18 },
  { 3629, 13, 18, 13, 1, -18 },
  { 3659, 14, 18, 14, 0, -18 },
  { 3691, 9, 22, 11, 2, -22 },
  { 3716, 16, 18, 19, 2, -18 },
  { 3752, 14, 18, 14, 2, -18 },
  { 3784, 22, 18, 23, 2, -18 },
  { 3834, 17, 18, 16, -1, -18 },
  { 3873, 20, 26, 14, -4, -18 },
  { 3938, 15, 18, 15, 0, -18 },
  { 3972, 12, 29, 11, 1, -24 },
  { 4016, 2, 34, 18, 9, -26 },
  { 4025, 13, 29, 11, -2, -24 },
  { 4073, 15, 4, 19, 3, -14 },
};

const GFXfont NotoSans_ExtraLightItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRALIGHTITALIC34PT7B_H_
