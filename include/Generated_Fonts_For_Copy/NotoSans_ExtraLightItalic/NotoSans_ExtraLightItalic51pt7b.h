#ifndef _NOTOSANS_EXTRALIGHTITALIC51PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x30, 0x73,
  0x06, 0x20, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0x8C,
  0x08, 0xC1, 0x88, 0x18, 0x81, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x07,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x10, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xBF, 0x01, 0xE1, 0x83, 0x03, 0x81, 0x00,
  0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00,
  0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x84, 0x00, 0x01, 0xE4, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x09, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x20, 0x30, 0x00, 0x20, 0x60,
  0xC0, 0x61, 0xC0, 0xFE, 0x6F, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x01, 0xFC, 0x00, 0x06, 0x01,
  0x83, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x60, 0x03, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x06, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x18, 0x01, 0x80, 0xC0,
  0x0C, 0x00, 0xC0, 0xC0, 0x04, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x60, 0xC0,
  0x03, 0x00, 0x30, 0x60, 0x01, 0x80, 0x10, 0x61, 0xF8, 0xC0, 0x18, 0x61,
  0xFE, 0x60, 0x0C, 0x61, 0x81, 0x90, 0x0C, 0x31, 0x80, 0xCC, 0x0C, 0x30,
  0xC0, 0x27, 0x0E, 0x30, 0xC0, 0x19, 0xFE, 0x38, 0x60, 0x0C, 0x7C, 0x18,
  0x60, 0x06, 0x00, 0x18, 0x30, 0x03, 0x00, 0x18, 0x18, 0x01, 0x00, 0x0C,
  0x18, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x18, 0x0E, 0x03,
  0x00, 0x0E, 0x06, 0x03, 0x00, 0x03, 0x8E, 0x03, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C,
  0x3C, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x61, 0x80, 0x30, 0x01, 0x86, 0x00, 0x70, 0x03, 0x18, 0x00, 0x60,
  0x0C, 0x60, 0x00, 0x60, 0x30, 0xC0, 0x00, 0x60, 0x61, 0x80, 0x00, 0xC1,
  0x86, 0x00, 0x00, 0xC6, 0x0C, 0x00, 0x00, 0xDC, 0x18, 0x00, 0x01, 0xF0,
  0x30, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x60, 0x00, 0x1D, 0x80,
  0xE0, 0x00, 0xE3, 0x80, 0xE0, 0x03, 0x83, 0x00, 0xF8, 0x7C, 0x03, 0x00,
  0x7F, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x33, 0x26, 0x66, 0x64,
  0xCC, 0xC8, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x00, 0x60, 0x0E, 0x01, 0x00, 0x1E, 0x04, 0x00, 0x1E,
  0x30, 0x00, 0x1C, 0xC0, 0x00, 0x1E, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0xF0,
  0x00, 0x06, 0x40, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00,
  0x60, 0x30, 0x07, 0x00, 0x40, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x06,
  0x1C, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x0C,
  0x01, 0x80, 0x0E, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0,
  0x70, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x38, 0x07, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x76, 0x0F,
  0x60, 0xE3, 0x1E, 0x19, 0xC0, 0xDC, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xC0, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x0E, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x20, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x02, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x19, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x80, 0x00, 0xE0, 0x60, 0x01, 0xE0, 0x3F, 0x07, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0x80, 0x20, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0xFF, 0x80, 0x31, 0xE1, 0xE0,
  0x19, 0x80, 0x18, 0x1B, 0x80, 0x06, 0x0D, 0x00, 0x03, 0x07, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x84, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x1E, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0x39, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x38, 0x18, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x01, 0xF0, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x1C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x83, 0x00, 0x06, 0xC1, 0xC0, 0x06, 0xC0, 0x70, 0x0E, 0x60, 0x1F,
  0xFE, 0x30, 0x03, 0xF8, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x07, 0x0F, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0x83, 0xC0, 0x70, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x31, 0xC0,
  0x01, 0xFC, 0x00, 0xC6, 0x00, 0x3F, 0xFC, 0x03, 0x30, 0x01, 0xC0, 0x30,
  0x0C, 0xC0, 0x0C, 0x00, 0xC0, 0x36, 0x00, 0x60, 0x03, 0x00, 0xD8, 0x03,
  0x00, 0x18, 0x03, 0x60, 0x18, 0x00, 0x60, 0x0D, 0x00, 0x60, 0x01, 0x80,
  0x3C, 0x03, 0x00, 0x04, 0x00, 0xF0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x30,
  0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x03, 0x00, 0x6C, 0x06, 0x00, 0x18, 0x01,
  0xB0, 0x18, 0x00, 0x60, 0x06, 0xC0, 0x60, 0x03, 0x80, 0x33, 0x00, 0x80,
  0x0E, 0x01, 0xCC, 0x03, 0x00, 0x78, 0x06, 0x30, 0x0C, 0x03, 0x20, 0x30,
  0xC0, 0x1C, 0x38, 0xC3, 0x81, 0x80, 0x3F, 0xC1, 0xFC, 0x06, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x70, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x03, 0xF8,
  0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x60, 0x01,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x18, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C,
  0x06, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x04, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x07, 0x80,
  0x60, 0x00, 0x78, 0x01, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xE0,
  0x07, 0xC0, 0x1E, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x3F, 0xFC, 0xC0, 0x00, 0xFF, 0xE3, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x70, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x06, 0x6C,
  0x00, 0x00, 0x33, 0x30, 0x00, 0x00, 0xD8, 0xE0, 0x00, 0x03, 0xC1, 0x80,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x02, 0x80, 0x00, 0x00, 0xF8, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x6C, 0x00, 0x00,
  0x33, 0x01, 0x98, 0x00, 0x00, 0xE6, 0x03, 0x10, 0x00, 0x01, 0x98, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x18, 0xC0, 0x00,
  0x30, 0xC0, 0x61, 0x80, 0x00, 0x61, 0x80, 0xC3, 0x00, 0x01, 0x86, 0x01,
  0x82, 0x00, 0x06, 0x0C, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x18, 0x18, 0x00, 0x60, 0x60, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x07, 0x03, 0x00, 0xC0, 0x40, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x08,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x60, 0x0C, 0x03, 0x00, 0x31, 0x80, 0x18,
  0x06, 0x00, 0x63, 0x00, 0x30, 0x0C, 0x00, 0xCC, 0x00, 0x60, 0x30, 0x01,
  0xB0, 0x00, 0xC0, 0x60, 0x01, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xC0,
  0x3E, 0x00, 0x00, 0x60, 0x1B, 0x00, 0x00, 0x30, 0x0D, 0x80, 0x00, 0x30,
  0x06, 0x60, 0x00, 0x18, 0x06, 0x30, 0x00, 0x0C, 0x03, 0x0C, 0x00, 0x06,
  0x01, 0x86, 0x00, 0x07, 0x00, 0xC3, 0x00, 0x03, 0x00, 0x60, 0xC0, 0x01,
  0x80, 0x60, 0x60, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x60, 0x18, 0x0C, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x30, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x30, 0x00,
  0x60, 0x60, 0x18, 0x00, 0x30, 0x60, 0x0C, 0x00, 0x0C, 0x30, 0x0C, 0x00,
  0x06, 0x18, 0x06, 0x00, 0x01, 0x8C, 0x03, 0x00, 0x00, 0xC4, 0x01, 0x80,
  0x00, 0x66, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0xC0, 0x00, 0x0D, 0x80, 0x60,
  0x00, 0x03, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x18, 0x1F, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x1C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x01, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x18, 0x1F, 0xE0, 0x03, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x80, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3E, 0x01, 0xE0, 0x38, 0x00, 0x20,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x1F, 0x87, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0xC0, 0x00, 0x68, 0x00, 0x0C, 0xC0, 0x00, 0x68, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0x40,
  0x01, 0x8C, 0x00, 0x30, 0x40, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x03, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0xE0,
  0x60, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x0C, 0x00, 0xC0, 0x60, 0x0C,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x04, 0x06, 0x00, 0x60, 0x60, 0x04, 0x0C, 0x00, 0x60, 0x60, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x06, 0x60,
  0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x2C,
  0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x0E, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30,
  0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x00, 0x3F, 0xF0, 0x04, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x20, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x08,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xC0, 0xC1, 0x81, 0x81, 0x03, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0x04, 0x07, 0x87, 0x18, 0x1C, 0x03, 0x30,
  0x60, 0x03, 0x61, 0x80, 0x06, 0xC6, 0x00, 0x05, 0x1C, 0x00, 0x0E, 0x30,
  0x00, 0x1C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x63, 0x00, 0x00, 0xCE, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x0E,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x78, 0x60, 0x01, 0xB0, 0x60, 0x06, 0x60,
  0xE0, 0x38, 0x80, 0xF1, 0xE3, 0x00, 0xFF, 0x06, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x0F, 0xF0, 0x06, 0x3C, 0x3C, 0x06, 0x70, 0x0E, 0x04, 0xC0, 0x06,
  0x0D, 0x80, 0x07, 0x0D, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x58, 0x00, 0x30, 0xC8, 0x00, 0x60,
  0xCC, 0x01, 0xC0, 0xC7, 0x87, 0x80, 0x83, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x07, 0xFF, 0x01, 0xF0, 0xF0, 0x38, 0x01, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x10, 0x1F, 0x1F, 0x00, 0x7F, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x30, 0x03, 0xC3, 0xC6,
  0x00, 0xE0, 0x0C, 0xC0, 0x30, 0x00, 0x98, 0x0C, 0x00, 0x1E, 0x03, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x36, 0x03, 0x00, 0x0C, 0x80, 0x30,
  0x03, 0x10, 0x07, 0x00, 0xC6, 0x00, 0x78, 0xF0, 0xC0, 0x07, 0xFC, 0x18,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xF1, 0xE0,
  0x38, 0x07, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03,
  0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x1C, 0x60, 0x07,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x08, 0x1F, 0x0F, 0x80,
  0x7F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x10, 0x07,
  0x87, 0x8C, 0x03, 0x80, 0x33, 0x01, 0x80, 0x04, 0xC0, 0xC0, 0x01, 0xA0,
  0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C,
  0x0C, 0x00, 0x0F, 0x03, 0x00, 0x06, 0xC0, 0xC0, 0x03, 0x30, 0x18, 0x01,
  0x98, 0x07, 0x00, 0xC6, 0x00, 0xF1, 0xE1, 0x80, 0x1F, 0xE0, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0xFF, 0x80, 0xC3, 0xC7, 0x81, 0x9C, 0x03, 0x82, 0x60, 0x03,
  0x0D, 0x80, 0x06, 0x1A, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x31,
  0xC0, 0x00, 0x63, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x38, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x70,
  0x01, 0x81, 0xC0, 0x03, 0x07, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x70, 0x00,
  0x19, 0xE0, 0x00, 0x66, 0xC0, 0x00, 0xD8, 0xC0, 0x01, 0xE1, 0x80, 0x03,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x01, 0x00, 0x18, 0x3F, 0x80, 0x3F, 0xC0, 0x63, 0x87, 0x03, 0xC7, 0x81,
  0x18, 0x06, 0x18, 0x07, 0x04, 0xC0, 0x18, 0xC0, 0x0C, 0x36, 0x00, 0x36,
  0x00, 0x30, 0xF0, 0x00, 0xD0, 0x00, 0xC3, 0x80, 0x03, 0xC0, 0x03, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x00, 0x03, 0x18, 0x00, 0x18, 0x00, 0x08, 0x60,
  0x00, 0x60, 0x00, 0x63, 0x00, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x00,
  0x06, 0x30, 0x00, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00,
  0x31, 0x80, 0x01, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x63, 0x00, 0x03, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x06, 0x0F, 0xF8, 0x06, 0x3E, 0x3C, 0x06, 0x70, 0x0E, 0x04, 0xC0,
  0x06, 0x0D, 0x80, 0x06, 0x0D, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x7F,
  0xC0, 0x03, 0xE3, 0xE0, 0x0E, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x8E, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x1C, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x38, 0x00, 0x60, 0x38, 0x03, 0x80, 0x3C, 0x1E,
  0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC1, 0xFE, 0x00, 0x18,
  0xF0, 0xF0, 0x03, 0x38, 0x07, 0x00, 0x4C, 0x00, 0x60, 0x1B, 0x00, 0x0E,
  0x03, 0x40, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x02, 0xC0, 0x01,
  0x80, 0xC8, 0x00, 0x60, 0x19, 0x80, 0x38, 0x03, 0x1E, 0x1E, 0x00, 0x61,
  0xFF, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xC1, 0x01, 0xE1, 0xE3, 0x03, 0x80, 0x33, 0x06, 0x00, 0x13, 0x0C, 0x00,
  0x1A, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0xF0, 0xC0, 0x01, 0xB0, 0xC0, 0x03, 0x30, 0x60, 0x06, 0x60, 0x70, 0x0C,
  0x60, 0x3C, 0x78, 0x60, 0x1F, 0xE0, 0x60, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x0F, 0xE0, 0xC7, 0xC8,
  0x19, 0xC0, 0x02, 0x60, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xFC, 0x07, 0xC3, 0xF0, 0xE0, 0x02, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x08, 0x00, 0xE0, 0xF8, 0x3C, 0x07, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF1, 0x81, 0xFE,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0xF0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xE0, 0xC0, 0x03, 0x60,
  0xC0, 0x06, 0x60, 0x60, 0x1C, 0x60, 0x7C, 0xF8, 0x40, 0x1F, 0xE0, 0xC0,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80,
  0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x00, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x10, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x30, 0x70, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x01, 0x18, 0x00, 0x0C, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xB0, 0x00,
  0xE0, 0x01, 0x98, 0x00, 0xD0, 0x00, 0xCC, 0x00, 0x68, 0x00, 0xC6, 0x00,
  0x66, 0x00, 0x63, 0x00, 0x33, 0x00, 0x61, 0x80, 0x31, 0x80, 0x30, 0xC0,
  0x18, 0xC0, 0x38, 0x60, 0x18, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x0C, 0x18, 0x0C, 0x04, 0x06, 0x0C, 0x06, 0x02, 0x06, 0x06, 0x06, 0x01,
  0x83, 0x01, 0x03, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x61, 0x80,
  0x31, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x06, 0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x01, 0xB0,
  0x00, 0xF0, 0x00, 0xD0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xE1,
  0xF0, 0x0F, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_ExtraLightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 36, 11, 2, -36 },
  { 46, 12, 13, 17, 6, -36 },
  { 66, 30, 36, 32, 2, -36 },
  { 201, 24, 42, 28, 2, -39 },
  { 327, 33, 38, 39, 4, -37 },
  { 484, 31, 38, 35, 2, -37 },
  { 632, 4, 13, 9, 6, -36 },
  { 639, 14, 44, 13, 2, -36 },
  { 716, 14, 44, 13, -3, -36 },
  { 793, 22, 22, 27, 6, -39 },
  { 854, 23, 24, 29, 4, -30 },
  { 923, 7, 13, 10, -2, -6 },
  { 935, 12, 2, 16, 2, -15 },
  { 938, 3, 3, 11, 2, -3 },
  { 940, 23, 36, 16, -2, -36 },
  { 1044, 24, 38, 28, 3, -37 },
  { 1158, 13, 36, 28, 8, -36 },
  { 1217, 26, 37, 28, 0, -37 },
  { 1338, 26, 38, 28, 1, -37 },
  { 1462, 26, 37, 28, 1, -37 },
  { 1583, 25, 37, 28, 2, -36 },
  { 1699, 25, 38, 28, 3, -37 },
  { 1818, 24, 36, 28, 5, -36 },
  { 1926, 25, 38, 28, 2, -37 },
  { 2045, 25, 38, 28, 2, -37 },
  { 2164, 8, 27, 11, 2, -27 },
  { 2191, 12, 34, 11, -2, -27 },
  { 2242, 23, 23, 29, 4, -30 },
  { 2309, 23, 12, 29, 4, -24 },
  { 2344, 23, 23, 29, 4, -30 },
  { 2411, 18, 37, 21, 4, -37 },
  { 2495, 38, 41, 43, 3, -36 },
  { 2690, 29, 37, 28, -3, -37 },
  { 2825, 28, 36, 31, 2, -36 },
  { 2951, 28, 38, 30, 4, -37 },
  { 3084, 30, 36, 34, 2, -36 },
  { 3219, 26, 36, 27, 2, -36 },
  { 3336, 27, 36, 25, 2, -36 },
  { 3458, 30, 38, 35, 4, -37 },
  { 3601, 33, 36, 35, 2, -36 },
  { 3750, 17, 36, 15, 0, -36 },
  { 3827, 21, 45, 12, -9, -36 },
  { 3946, 30, 36, 28, 2, -36 },
  { 4081, 19, 36, 25, 2, -36 },
  { 4167, 39, 36, 41, 2, -36 },
  { 4343, 33, 36, 35, 2, -36 },
  { 4492, 31, 38, 37, 4, -37 },
  { 4640, 27, 36, 29, 2, -36 },
  { 4762, 31, 46, 37, 4, -37 },
  { 4941, 27, 36, 29, 2, -36 },
  { 5063, 25, 38, 25, 1, -37 },
  { 5182, 25, 36, 25, 5, -36 },
  { 5295, 31, 37, 35, 4, -36 },
  { 5439, 26, 36, 27, 5, -36 },
  { 5556, 40, 36, 42, 6, -36 },
  { 5736, 32, 36, 25, -3, -36 },
  { 5880, 25, 36, 25, 5, -36 },
  { 5993, 29, 36, 27, 0, -36 },
  { 6124, 19, 44, 15, 0, -36 },
  { 6229, 8, 36, 16, 5, -36 },
  { 6265, 20, 44, 15, -4, -36 },
  { 6375, 24, 23, 28, 2, -37 },
  { 6444, 19, 2, 19, -4, 5 },
  { 6449, 7, 8, 12, 7, -39 },
  { 6456, 23, 29, 28, 3, -28 },
  { 6540, 24, 40, 29, 2, -39 },
  { 6660, 20, 29, 23, 3, -28 },
  { 6733, 27, 40, 29, 3, -39 },
  { 6868, 20, 29, 25, 3, -28 },
  { 6941, 28, 51, 14, -7, -39 },
  { 7120, 26, 40, 29, 1, -28 },
  { 7250, 23, 39, 28, 2, -39 },
  { 7363, 10, 37, 11, 2, -37 },
  { 7410, 19, 49, 11, -7, -37 },
  { 7527, 23, 39, 23, 2, -39 },
  { 7640, 10, 39, 11, 2, -39 },
  { 7689, 38, 28, 43, 2, -28 },
  { 7822, 24, 28, 28, 2, -28 },
  { 7906, 23, 28, 29, 3, -27 },
  { 7987, 27, 39, 29, -1, -27 },
  { 8119, 24, 40, 29, 3, -28 },
  { 8239, 19, 27, 19, 2, -27 },
  { 8304, 20, 29, 22, 1, -28 },
  { 8377, 14, 35, 16, 3, -34 },
  { 8439, 24, 28, 28, 3, -27 },
  { 8523, 21, 27, 22, 3, -27 },
  { 8594, 33, 27, 34, 3, -27 },
  { 8706, 26, 27, 24, -2, -27 },
  { 8794, 30, 39, 22, -6, -27 },
  { 8941, 23, 27, 22, -1, -27 },
  { 9019, 19, 44, 17, 1, -36 },
  { 9124, 2, 51, 27, 14, -39 },
  { 9137, 18, 44, 17, -2, -36 },
  { 9236, 23, 4, 29, 4, -20 },
};

const GFXfont NotoSans_ExtraLightItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRALIGHTITALIC51PT7B_H_
