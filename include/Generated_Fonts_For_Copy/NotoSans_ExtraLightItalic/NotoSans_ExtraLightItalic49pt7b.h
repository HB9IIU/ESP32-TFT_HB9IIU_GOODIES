#ifndef _NOTOSANS_EXTRALIGHTITALIC49PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x0E, 0x00, 0x18, 0x33, 0x03,
  0x30, 0x63, 0x06, 0x30, 0x62, 0x06, 0x20, 0x46, 0x0C, 0x60, 0xC4, 0x0C,
  0x40, 0x84, 0x08, 0xC1, 0x80, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x0C,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x08, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x30,
  0x03, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x40, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x78, 0xC3, 0x81, 0xC1, 0x80, 0x07,
  0x02, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40,
  0x60, 0x00, 0x80, 0x80, 0x01, 0x81, 0x00, 0x03, 0x86, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x90, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x38, 0x00, 0x04, 0x18, 0x00, 0x08, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x02, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x38, 0x40, 0x30, 0xE0, 0xF8, 0x4F, 0x80, 0xFF,
  0xFC, 0x00, 0x0B, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x0C,
  0x30, 0x00, 0x30, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x60, 0x03, 0x03, 0x00,
  0xC0, 0x0C, 0x06, 0x01, 0x80, 0x18, 0x08, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0x30,
  0x30, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x83, 0x00, 0x18, 0x03, 0x06,
  0x00, 0x30, 0x06, 0x18, 0x7E, 0x60, 0x08, 0x61, 0xCE, 0xC0, 0x31, 0x86,
  0x07, 0x80, 0xC3, 0x18, 0x0D, 0x81, 0x8C, 0x60, 0x1B, 0x8E, 0x30, 0xC0,
  0x33, 0xF8, 0x41, 0x00, 0x60, 0x01, 0x86, 0x00, 0xC0, 0x06, 0x0C, 0x01,
  0x80, 0x18, 0x10, 0x03, 0x00, 0x30, 0x60, 0x06, 0x00, 0xC0, 0xC0, 0x0C,
  0x03, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x06, 0x06, 0x00, 0x30, 0x18, 0x0C,
  0x00, 0x30, 0x30, 0x30, 0x00, 0x71, 0xC0, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01, 0x87, 0x80, 0x00, 0x06, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x01, 0x8C, 0x01, 0x80, 0x0C, 0xC0,
  0x06, 0x00, 0xCE, 0x00, 0x18, 0x06, 0x60, 0x00, 0xE0, 0x63, 0x00, 0x03,
  0x06, 0x30, 0x00, 0x0C, 0x71, 0x80, 0x00, 0x33, 0x0C, 0x00, 0x01, 0xB0,
  0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x60, 0x70,
  0x00, 0x73, 0x01, 0xC0, 0x0E, 0x0C, 0x07, 0x83, 0xE0, 0x30, 0x1F, 0xFC,
  0x01, 0x80, 0x19, 0x8C, 0x63, 0x10, 0x8C, 0x62, 0x10, 0x8C, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x18, 0x03, 0xC0,
  0x80, 0x07, 0x84, 0x00, 0x0E, 0x20, 0x08, 0x1F, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xC0, 0x00, 0x1A, 0x00, 0x03, 0x98, 0x00, 0x38, 0x40, 0x03, 0x83,
  0x00, 0x38, 0x18, 0x03, 0x80, 0x60, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x1C, 0x30, 0x61, 0x83,
  0x0E, 0x18, 0x30, 0xC1, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0x77, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC1, 0xC0, 0x0E, 0x00, 0xC0,
  0x38, 0x01, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18,
  0x00, 0x1C, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0x78, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0x01,
  0xF0, 0x73, 0x0E, 0x63, 0x86, 0x70, 0x6C, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x01,
  0x80, 0x70, 0x00, 0x60, 0x20, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xE0, 0xC0, 0x01, 0xE0, 0x7E, 0x07,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x01, 0xC0,
  0x01, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0D, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x04, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0xF8, 0x1F,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0x02, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x1E,
  0x00, 0x30, 0xFF, 0x80, 0x33, 0xC1, 0xE0, 0x66, 0x00, 0x70, 0x6C, 0x00,
  0x30, 0x78, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1E, 0x0F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xC1, 0xC0, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x38, 0x00, 0x30, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x70, 0x00, 0x60, 0x38, 0x01, 0xC0,
  0x1F, 0x07, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x70,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x07, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x1E, 0x0C, 0x00, 0x36,
  0x0E, 0x00, 0x6C, 0x07, 0x83, 0xCC, 0x01, 0xFF, 0x0C, 0x00, 0x38, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x78, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0x03, 0xC1, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x70, 0x00, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0x0F, 0x08, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x0F, 0xE0, 0x0C, 0x30, 0x01, 0xFF, 0xC0,
  0x23, 0x00, 0x38, 0x06, 0x01, 0x98, 0x03, 0x00, 0x30, 0x0D, 0x80, 0x30,
  0x03, 0x00, 0x6C, 0x03, 0x00, 0x18, 0x03, 0x40, 0x18, 0x00, 0xC0, 0x1E,
  0x01, 0x80, 0x04, 0x00, 0xF0, 0x0C, 0x00, 0x60, 0x05, 0x80, 0xC0, 0x03,
  0x00, 0x6C, 0x06, 0x00, 0x18, 0x03, 0x60, 0x30, 0x01, 0x80, 0x1B, 0x01,
  0x80, 0x0C, 0x01, 0x98, 0x0C, 0x00, 0x60, 0x0C, 0xC0, 0x60, 0x07, 0x00,
  0xC6, 0x03, 0x00, 0x78, 0x06, 0x30, 0x1C, 0x06, 0x40, 0x61, 0x80, 0x70,
  0x63, 0x0E, 0x0C, 0x01, 0xFE, 0x1F, 0xE0, 0x30, 0x03, 0x80, 0x3C, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x06, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0xE0, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80,
  0x60, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0x80, 0x7E, 0x00, 0x30, 0x00,
  0x70, 0x06, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xE0, 0xFC, 0x01, 0xE0, 0x01, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x08, 0x00,
  0xF8, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x70, 0x10, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x0C,
  0x00, 0x0F, 0x00, 0x60, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC,
  0x1F, 0xC0, 0x1E, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xF1, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x3C, 0x00,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01,
  0x8F, 0x00, 0x00, 0x0C, 0xD8, 0x00, 0x00, 0x6C, 0x60, 0x00, 0x03, 0xC3,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x04, 0x80, 0x00, 0x06, 0x60,
  0x33, 0x00, 0x00, 0x1B, 0x00, 0xCC, 0x00, 0x00, 0xCC, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x23, 0x00, 0x00, 0xC2, 0x01,
  0x84, 0x00, 0x03, 0x18, 0x06, 0x18, 0x00, 0x18, 0x60, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x61, 0x80, 0x03, 0x06, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x0C,
  0x18, 0x00, 0x60, 0xC0, 0x30, 0x20, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x03, 0x03, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x01, 0x80,
  0x60, 0x10, 0x06, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x30, 0x0C, 0x03, 0x00,
  0x61, 0x80, 0x30, 0x0C, 0x01, 0x8C, 0x00, 0xC0, 0x30, 0x06, 0x30, 0x03,
  0x00, 0x80, 0x09, 0x80, 0x08, 0x06, 0x00, 0x36, 0x00, 0x60, 0x18, 0x00,
  0xF0, 0x01, 0x80, 0x60, 0x03, 0xC0, 0x06, 0x01, 0x80, 0x0E, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x20, 0x1E, 0x00,
  0x00, 0xC0, 0x26, 0x00, 0x01, 0x80, 0xCC, 0x00, 0x03, 0x01, 0x8C, 0x00,
  0x06, 0x03, 0x18, 0x00, 0x08, 0x06, 0x30, 0x00, 0x30, 0x08, 0x30, 0x00,
  0x60, 0x30, 0x60, 0x00, 0xC0, 0x60, 0x60, 0x01, 0x80, 0xC0, 0xC0, 0x06,
  0x01, 0x80, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x60, 0x06, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x18, 0x10, 0x0C,
  0x00, 0x30, 0x60, 0x10, 0x00, 0x30, 0xC0, 0x60, 0x00, 0x61, 0x80, 0xC0,
  0x00, 0x43, 0x01, 0x80, 0x00, 0xC4, 0x03, 0x00, 0x01, 0x98, 0x04, 0x00,
  0x01, 0xB0, 0x18, 0x00, 0x03, 0x60, 0x30, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x0E, 0x06, 0x00, 0x1E, 0x03, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xC0,
  0x07, 0x80, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x60, 0x03,
  0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x1C, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x7C, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x3F, 0x01,
  0xE0, 0x03, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x03, 0xC0, 0xFC, 0x3F, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x01, 0xB0,
  0x00, 0x34, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x33, 0x00, 0x02, 0x40,
  0x00, 0xCC, 0x00, 0x19, 0x00, 0x06, 0x30, 0x00, 0x46, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x18, 0x30, 0x01, 0x86, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x03, 0x81, 0x00,
  0x30, 0x60, 0x0C, 0x04, 0x01, 0x81, 0x80, 0x30, 0x10, 0x06, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x06, 0x06,
  0x01, 0x80, 0xC0, 0x18, 0x18, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x18,
  0x01, 0x83, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0x83, 0x00, 0x18, 0x60,
  0x03, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x20,
  0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C,
  0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x64, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x10, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0x40,
  0x03, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x02, 0x01,
  0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x2E, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC3, 0x86, 0x0C, 0x30, 0x60, 0x83, 0x00, 0x7F, 0x82, 0x03, 0xE3,
  0x84, 0x0E, 0x01, 0x98, 0x38, 0x01, 0xB0, 0xE0, 0x01, 0x61, 0x80, 0x02,
  0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x31,
  0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00,
  0x01, 0xC3, 0x00, 0x07, 0x06, 0x00, 0x1E, 0x0C, 0x00, 0x6C, 0x1C, 0x01,
  0x98, 0x18, 0x06, 0x20, 0x1C, 0x38, 0x40, 0x1F, 0xE1, 0x80, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x63, 0x87, 0x81,
  0x8C, 0x03, 0x83, 0x30, 0x03, 0x06, 0x80, 0x03, 0x0F, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCE, 0x00, 0x03,
  0x1C, 0x00, 0x06, 0x28, 0x00, 0x18, 0xD0, 0x00, 0x61, 0xB0, 0x01, 0xC3,
  0x30, 0x07, 0x04, 0x38, 0x78, 0x08, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x3C, 0x1C, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x08, 0x1E, 0x1E, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0xE1, 0x80, 0x1F, 0x1E, 0x30, 0x07, 0x00, 0x66, 0x01, 0xC0,
  0x04, 0x80, 0x70, 0x00, 0xF0, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x38, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x08, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x80, 0x60,
  0x01, 0xB0, 0x0E, 0x00, 0x64, 0x00, 0xC0, 0x38, 0x80, 0x0F, 0x1E, 0x30,
  0x00, 0xFF, 0x06, 0x00, 0x00, 0x7F, 0x80, 0x1E, 0x1C, 0x03, 0x80, 0x60,
  0x60, 0x06, 0x0C, 0x00, 0x21, 0x80, 0x03, 0x38, 0x00, 0x63, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x03, 0xF0, 0xFF, 0xF8,
  0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x10, 0x1E, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0x08, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x21, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x7C,
  0x78, 0xC0, 0x70, 0x06, 0x60, 0x70, 0x01, 0x30, 0x70, 0x00, 0xD0, 0x30,
  0x00, 0x38, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C,
  0x30, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x07,
  0x81, 0x80, 0x06, 0xC0, 0xE0, 0x06, 0x40, 0x30, 0x0E, 0x60, 0x0E, 0x1E,
  0x30, 0x03, 0xFC, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x20, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x83, 0xFC, 0x06, 0x3C, 0x78, 0x31, 0x80, 0x70, 0xCC, 0x00, 0xC3,
  0x60, 0x03, 0x0F, 0x00, 0x04, 0x38, 0x00, 0x11, 0xC0, 0x00, 0xC7, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x88, 0x00, 0x06, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00,
  0x23, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x60,
  0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x87, 0x00, 0x3F, 0x80, 0x07,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x07, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x61, 0x80, 0x01, 0x1C, 0x00, 0x0C, 0xF8, 0x00, 0x37, 0x60, 0x00, 0xF0,
  0xC0, 0x03, 0x83, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0x06, 0x1F, 0xE0, 0x1F, 0xC0, 0x21, 0xC7, 0x83, 0x87, 0x01,
  0x38, 0x0C, 0x30, 0x0C, 0x1B, 0x00, 0x63, 0x00, 0x60, 0xD0, 0x01, 0xB0,
  0x01, 0x87, 0x00, 0x0F, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x00, 0x63, 0x80,
  0x03, 0x80, 0x03, 0x1C, 0x00, 0x18, 0x00, 0x10, 0xC0, 0x00, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0x63, 0x00, 0x03,
  0x00, 0x03, 0x18, 0x00, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x80, 0x01, 0x86,
  0x00, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x60, 0x00, 0x63, 0x00, 0x03, 0x00,
  0x03, 0x18, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x80, 0x01, 0x86, 0x00,
  0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0x63, 0x00, 0x03, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x01, 0x86, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x03, 0x07, 0xF8, 0x02, 0x1E, 0x3C, 0x06, 0x30, 0x0E,
  0x06, 0x60, 0x06, 0x06, 0xC0, 0x06, 0x07, 0x80, 0x03, 0x07, 0x00, 0x02,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0x80,
  0x07, 0x87, 0x80, 0x70, 0x07, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x18, 0x60,
  0x00, 0x63, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x1C,
  0x0C, 0x00, 0xE0, 0x1E, 0x1E, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC1, 0xFC,
  0x00, 0x21, 0xC3, 0xC0, 0x08, 0xC0, 0x38, 0x06, 0x60, 0x06, 0x01, 0xB0,
  0x00, 0xC0, 0x78, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x38,
  0x00, 0x0C, 0x0A, 0x00, 0x06, 0x06, 0x80, 0x03, 0x01, 0xB0, 0x01, 0xC0,
  0x66, 0x00, 0xE0, 0x18, 0xE1, 0xE0, 0x06, 0x1F, 0xF0, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC1, 0x01, 0xF1, 0xE3, 0x03, 0x80, 0x33, 0x07, 0x00, 0x13, 0x0E, 0x00,
  0x1A, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00,
  0xF0, 0x60, 0x01, 0xB0, 0x70, 0x03, 0x20, 0x30, 0x0E, 0x60, 0x1C, 0x3C,
  0x60, 0x0F, 0xF0, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x06, 0x1F, 0xC1, 0x0F, 0x20, 0x46, 0x00, 0x33, 0x00, 0x0D, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xF0, 0xFC, 0x38, 0x01, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x84, 0x00, 0x70, 0xF0, 0x3C, 0x0F,
  0xFE, 0x00, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x0F, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x10, 0x1F, 0xC0, 0x1C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x31, 0x80, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80,
  0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x0F, 0x0C, 0x00, 0x34, 0x18, 0x00,
  0x58, 0x30, 0x03, 0xB0, 0x70, 0x0E, 0x60, 0x78, 0xF0, 0x80, 0x7F, 0xC1,
  0x00, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6,
  0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x06, 0x04, 0x00, 0x30, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x00, 0x40, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00,
  0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x2C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x07, 0x80, 0x06, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x36, 0x00, 0x2C,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x31, 0x80, 0x61, 0x80, 0x63, 0x00,
  0xC3, 0x01, 0x86, 0x03, 0x06, 0x03, 0x04, 0x06, 0x0C, 0x0C, 0x08, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x10, 0x60, 0x30, 0xC0, 0x20, 0x80, 0x61, 0x80,
  0x43, 0x00, 0xC6, 0x00, 0x84, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x30, 0x03,
  0x20, 0x06, 0x60, 0x06, 0xC0, 0x0C, 0xC0, 0x0D, 0x00, 0x0B, 0x00, 0x1E,
  0x00, 0x16, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x81,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x70, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x1E,
  0x0F, 0x80, 0xE0, 0x07, 0xFE, 0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraLightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 35, 11, 1, -35 },
  { 45, 12, 13, 16, 5, -35 },
  { 65, 29, 35, 30, 2, -35 },
  { 192, 23, 40, 27, 2, -37 },
  { 307, 31, 36, 38, 4, -35 },
  { 447, 29, 36, 33, 2, -36 },
  { 578, 5, 13, 9, 5, -35 },
  { 587, 14, 43, 12, 2, -35 },
  { 663, 14, 43, 12, -3, -35 },
  { 739, 21, 21, 26, 6, -37 },
  { 795, 22, 23, 28, 4, -29 },
  { 859, 7, 12, 10, -2, -6 },
  { 870, 11, 2, 15, 2, -14 },
  { 873, 4, 3, 11, 1, -3 },
  { 875, 22, 35, 15, -2, -35 },
  { 972, 23, 36, 27, 3, -36 },
  { 1076, 12, 35, 27, 8, -35 },
  { 1129, 25, 35, 27, 0, -35 },
  { 1239, 25, 35, 27, 1, -35 },
  { 1349, 25, 35, 27, 1, -35 },
  { 1459, 24, 35, 27, 2, -35 },
  { 1564, 24, 36, 27, 3, -36 },
  { 1672, 23, 35, 27, 5, -35 },
  { 1773, 24, 35, 27, 2, -35 },
  { 1878, 24, 35, 27, 2, -35 },
  { 1983, 9, 26, 11, 1, -26 },
  { 2013, 11, 32, 11, -2, -26 },
  { 2057, 22, 22, 28, 4, -29 },
  { 2118, 22, 11, 28, 4, -23 },
  { 2149, 22, 22, 28, 4, -29 },
  { 2210, 17, 35, 20, 4, -35 },
  { 2285, 37, 39, 41, 3, -35 },
  { 2466, 28, 35, 27, -3, -35 },
  { 2589, 27, 35, 29, 2, -35 },
  { 2708, 27, 35, 29, 4, -35 },
  { 2827, 29, 35, 33, 2, -35 },
  { 2954, 25, 35, 26, 2, -35 },
  { 3064, 25, 35, 24, 2, -35 },
  { 3174, 29, 35, 34, 4, -35 },
  { 3301, 31, 35, 33, 2, -35 },
  { 3437, 16, 35, 14, 0, -35 },
  { 3507, 20, 44, 12, -8, -35 },
  { 3617, 29, 35, 27, 2, -35 },
  { 3744, 18, 35, 24, 2, -35 },
  { 3823, 38, 35, 40, 2, -35 },
  { 3990, 31, 35, 33, 2, -35 },
  { 4126, 29, 36, 35, 4, -36 },
  { 4257, 25, 35, 27, 2, -35 },
  { 4367, 29, 44, 35, 4, -36 },
  { 4527, 25, 35, 28, 2, -35 },
  { 4637, 24, 35, 24, 1, -35 },
  { 4742, 23, 35, 24, 5, -35 },
  { 4843, 30, 35, 34, 4, -35 },
  { 4975, 25, 35, 26, 5, -35 },
  { 5085, 38, 35, 41, 6, -35 },
  { 5252, 31, 35, 24, -3, -35 },
  { 5388, 24, 35, 24, 5, -35 },
  { 5493, 28, 35, 26, 0, -35 },
  { 5616, 18, 43, 15, 0, -35 },
  { 5713, 8, 35, 15, 5, -35 },
  { 5748, 19, 43, 15, -4, -35 },
  { 5851, 23, 21, 27, 2, -35 },
  { 5912, 19, 2, 18, -4, 5 },
  { 5917, 6, 8, 12, 7, -38 },
  { 5923, 23, 26, 27, 2, -26 },
  { 5998, 23, 37, 28, 2, -37 },
  { 6105, 19, 26, 22, 3, -26 },
  { 6167, 27, 37, 28, 2, -37 },
  { 6292, 20, 26, 24, 3, -26 },
  { 6357, 27, 49, 13, -6, -37 },
  { 6523, 25, 38, 28, 1, -26 },
  { 6642, 22, 37, 27, 2, -37 },
  { 6744, 9, 35, 11, 2, -35 },
  { 6784, 18, 47, 11, -7, -35 },
  { 6890, 22, 37, 22, 2, -37 },
  { 6992, 9, 37, 11, 2, -37 },
  { 7034, 37, 26, 42, 2, -26 },
  { 7155, 24, 26, 27, 1, -26 },
  { 7233, 22, 26, 28, 3, -26 },
  { 7305, 26, 37, 28, -1, -26 },
  { 7426, 24, 37, 28, 2, -26 },
  { 7537, 18, 26, 18, 2, -26 },
  { 7596, 19, 26, 21, 1, -26 },
  { 7658, 14, 32, 15, 3, -32 },
  { 7714, 23, 26, 27, 3, -26 },
  { 7789, 21, 26, 21, 2, -26 },
  { 7858, 31, 26, 33, 3, -26 },
  { 7959, 25, 26, 23, -2, -26 },
  { 8041, 28, 38, 21, -5, -26 },
  { 8174, 22, 26, 21, -1, -26 },
  { 8246, 18, 43, 16, 1, -35 },
  { 8343, 1, 49, 26, 14, -37 },
  { 8350, 17, 43, 16, -2, -35 },
  { 8442, 22, 5, 28, 4, -20 },
};

const GFXfont NotoSans_ExtraLightItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRALIGHTITALIC49PT7B_H_
