#ifndef _NOTOSANS_EXTRALIGHTITALIC54PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x38,
  0x0E, 0x00, 0x38, 0x39, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x31,
  0x81, 0x8C, 0x0C, 0x60, 0x63, 0x02, 0x10, 0x31, 0x81, 0x8C, 0x0C, 0x60,
  0x40, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x03,
  0xC3, 0x06, 0x03, 0x81, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01,
  0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x10, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE1, 0x00,
  0x00, 0x3D, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x33, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x06,
  0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x38, 0x18, 0x0C, 0x38, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x01,
  0xFF, 0x00, 0x01, 0x80, 0xE0, 0xC0, 0x00, 0xE0, 0x70, 0x18, 0x00, 0x30,
  0x18, 0x06, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x07,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x60, 0x0C, 0x00, 0x60, 0x38, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x00, 0xC1, 0xC0, 0x03, 0x00,
  0x30, 0x60, 0x60, 0xC0, 0x18, 0x30, 0xFF, 0x30, 0x06, 0x18, 0x71, 0xEC,
  0x01, 0x86, 0x38, 0x1B, 0x00, 0xC3, 0x0C, 0x06, 0xC0, 0x61, 0x86, 0x00,
  0xD8, 0x38, 0xC3, 0x80, 0x37, 0xFC, 0x30, 0xC0, 0x0C, 0x7C, 0x18, 0x30,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x01, 0x81,
  0x80, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0x38,
  0x0C, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x06, 0x00, 0x07, 0x0E,
  0x07, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x1C, 0x38, 0x03, 0x00, 0x0C, 0x38, 0x01, 0xC0, 0x0C,
  0x38, 0x00, 0x60, 0x06, 0x18, 0x00, 0x18, 0x06, 0x18, 0x00, 0x0E, 0x03,
  0x0C, 0x00, 0x03, 0x83, 0x06, 0x00, 0x00, 0xC3, 0x07, 0x00, 0x00, 0x33,
  0x83, 0x00, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x03, 0xB8, 0x06, 0x00, 0x07,
  0x0C, 0x03, 0xC0, 0x0F, 0x03, 0x00, 0xFC, 0x3E, 0x01, 0xC0, 0x1F, 0xFC,
  0x00, 0x70, 0x00, 0xA0, 0x00, 0x00, 0x39, 0xCC, 0x63, 0x19, 0x8C, 0x63,
  0x11, 0x8C, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x02, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x3C, 0x04, 0x00, 0x3C, 0x30, 0x00, 0x3C, 0xC0,
  0x00, 0x3A, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00,
  0x39, 0x00, 0x01, 0xC6, 0x00, 0x0E, 0x08, 0x00, 0x70, 0x30, 0x03, 0x80,
  0xC0, 0x1C, 0x01, 0x80, 0x20, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0x06, 0x0E, 0x0C,
  0x1C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x5F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x80, 0xE0, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x1C,
  0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0xC7, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x3E, 0x03, 0xB0, 0x7B, 0x87, 0x18, 0xF0, 0xCE, 0x06, 0xE0,
  0x34, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x03,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xF0, 0x0E, 0x01, 0xF0, 0x00, 0xE0, 0x18, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x40, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x1C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x40, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0x80, 0x20, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x3E, 0x00, 0x30, 0xFF, 0xE0, 0x31,
  0xE0, 0x78, 0x19, 0x80, 0x0E, 0x0D, 0x80, 0x03, 0x0F, 0x80, 0x00, 0xC7,
  0x80, 0x00, 0x63, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x3C, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x03, 0x00, 0xE0,
  0x00, 0x60, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0xE3, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0xC6, 0x00, 0x01, 0xC3, 0x80, 0x03, 0xE0, 0xC0, 0x03, 0xB0,
  0x38, 0x07, 0x18, 0x0F, 0xFF, 0x18, 0x03, 0xFE, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x07, 0x8F, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0xE0, 0xE0, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0xF0, 0x0E, 0x08, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x03, 0xFF, 0x00,
  0x61, 0x80, 0x07, 0x87, 0xC0, 0x11, 0xC0, 0x0F, 0x00, 0x60, 0x0C, 0xC0,
  0x0E, 0x00, 0x30, 0x06, 0x60, 0x0E, 0x00, 0x30, 0x03, 0x60, 0x06, 0x00,
  0x18, 0x01, 0xB0, 0x06, 0x00, 0x0C, 0x00, 0xD8, 0x03, 0x00, 0x0C, 0x00,
  0x7C, 0x03, 0x00, 0x06, 0x00, 0x6C, 0x01, 0x80, 0x03, 0x00, 0x36, 0x00,
  0xC0, 0x01, 0x80, 0x1B, 0x00, 0xC0, 0x01, 0x80, 0x0D, 0x80, 0x60, 0x00,
  0xC0, 0x0C, 0xC0, 0x30, 0x00, 0xE0, 0x06, 0x60, 0x18, 0x00, 0x70, 0x07,
  0x30, 0x0C, 0x00, 0x78, 0x03, 0x18, 0x06, 0x00, 0x2C, 0x03, 0x0C, 0x01,
  0x80, 0x36, 0x03, 0x86, 0x00, 0xE0, 0x73, 0x83, 0x81, 0x80, 0x3F, 0xF0,
  0xFF, 0x80, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xC0, 0x3F, 0xC0, 0x18, 0x00, 0x1E, 0x01, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0xC0, 0x03, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x70,
  0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x1C, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x01, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x78, 0x06, 0x00, 0x03,
  0xC0, 0x0C, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x7F, 0xFC, 0x60, 0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0E, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x00, 0x33, 0xF0, 0x00,
  0x00, 0x6E, 0x60, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x70, 0x03, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x01, 0xB0, 0x0D, 0x80, 0x00, 0x01, 0xD8, 0x0E,
  0xC0, 0x00, 0x00, 0xD8, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x03, 0x30, 0x00,
  0x00, 0x66, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0xCC, 0x00, 0x00, 0x71,
  0x80, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x61, 0x80, 0x00, 0x38, 0xC0, 0x30,
  0xC0, 0x00, 0x18, 0x60, 0x18, 0x60, 0x00, 0x18, 0x30, 0x0C, 0x30, 0x00,
  0x0C, 0x38, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x06, 0x06, 0x00, 0x0E, 0x0C,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x01, 0x81, 0x80, 0x06, 0x03, 0x01, 0xC0,
  0xC0, 0x03, 0x03, 0x80, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x60, 0x30, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x06, 0x01, 0x80, 0x18, 0x60,
  0x07, 0x01, 0x80, 0x0C, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x30, 0x01, 0x80,
  0x60, 0x03, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x98, 0x00, 0x60, 0x18, 0x00,
  0xDC, 0x00, 0x70, 0x18, 0x00, 0x3C, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x18, 0x07, 0x80, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x6C, 0x00,
  0x00, 0xE0, 0x33, 0x00, 0x00, 0x30, 0x0C, 0xE0, 0x00, 0x0C, 0x03, 0x18,
  0x00, 0x03, 0x00, 0xC6, 0x00, 0x00, 0xC0, 0x30, 0xC0, 0x00, 0x60, 0x18,
  0x30, 0x00, 0x18, 0x06, 0x0E, 0x00, 0x06, 0x01, 0x81, 0x80, 0x01, 0x80,
  0x60, 0x60, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x07, 0x00,
  0x70, 0x1C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x30, 0x06, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x18, 0x00, 0x70, 0x38, 0x0E, 0x00,
  0x0C, 0x0C, 0x03, 0x00, 0x03, 0x03, 0x00, 0xC0, 0x00, 0x60, 0xC0, 0x30,
  0x00, 0x18, 0x30, 0x0C, 0x00, 0x03, 0x18, 0x07, 0x00, 0x00, 0xC6, 0x01,
  0x80, 0x00, 0x39, 0x80, 0x60, 0x00, 0x06, 0x60, 0x18, 0x00, 0x01, 0x98,
  0x06, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0x01, 0xFC, 0x00, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0x1C,
  0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x06,
  0x00, 0x07, 0x01, 0xC0, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0x01, 0xFC, 0x00,
  0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x70, 0x30, 0x00, 0x3C, 0x06, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xE0, 0x0F, 0x80,
  0x70, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x40,
  0x00, 0x38, 0x0E, 0x00, 0x1E, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x50, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0xE0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x1C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xF0, 0x00, 0x0C,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x04, 0x00, 0x30, 0x30,
  0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x38,
  0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x07, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x06, 0x06,
  0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x06,
  0x06, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x0D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C,
  0x06, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x03, 0x00,
  0x3F, 0x81, 0x80, 0x7F, 0xF0, 0xC0, 0x70, 0x1C, 0x60, 0x70, 0x03, 0x20,
  0x60, 0x01, 0xB0, 0x70, 0x00, 0x58, 0x70, 0x00, 0x3C, 0x30, 0x00, 0x1E,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1, 0x80,
  0x01, 0x60, 0xE0, 0x01, 0xB0, 0x30, 0x03, 0x98, 0x0C, 0x03, 0x8C, 0x07,
  0xCF, 0x04, 0x00, 0xFF, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x03, 0xF8, 0x01, 0xC3, 0xFF, 0x80, 0x63, 0xC0, 0xF0, 0x19, 0xC0,
  0x0C, 0x06, 0xC0, 0x03, 0x81, 0xA0, 0x00, 0x60, 0xD8, 0x00, 0x18, 0x3C,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x87,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0x58, 0x00, 0x18, 0x33, 0x00, 0x1C,
  0x0C, 0x60, 0x0E, 0x03, 0x1F, 0x1F, 0x00, 0xC1, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x1E, 0x00, 0x80, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x08, 0x03, 0xE3, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0xC0, 0x0F,
  0xFF, 0x0C, 0x01, 0xE0, 0x39, 0x80, 0x38, 0x01, 0x98, 0x06, 0x00, 0x0D,
  0x80, 0xC0, 0x00, 0x58, 0x1C, 0x00, 0x07, 0x81, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x78, 0x0C, 0x00, 0x0D, 0x80, 0xE0, 0x01, 0x98, 0x06, 0x00,
  0x31, 0x80, 0x70, 0x0E, 0x10, 0x03, 0xE3, 0xC3, 0x00, 0x0F, 0xF0, 0x30,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1E, 0x03,
  0x80, 0xE0, 0x06, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC6,
  0x00, 0x03, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x3C, 0x60, 0x03, 0xC1, 0x87, 0xFC, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0C, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x21, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x30, 0x03, 0xFF, 0xC3, 0x00, 0x78, 0x0E,
  0x20, 0x0E, 0x00, 0x66, 0x01, 0x80, 0x03, 0x60, 0x38, 0x00, 0x16, 0x07,
  0x00, 0x01, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x0F, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1E, 0x03, 0x00,
  0x03, 0x60, 0x38, 0x00, 0x66, 0x01, 0x80, 0x0C, 0x60, 0x1C, 0x03, 0x8C,
  0x00, 0xF8, 0xF0, 0xC0, 0x03, 0xFC, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x3F, 0x80, 0x38, 0x7F,
  0xF0, 0x18, 0x70, 0x1C, 0x0C, 0xE0, 0x06, 0x06, 0xE0, 0x03, 0x83, 0x40,
  0x00, 0xC3, 0x60, 0x00, 0x61, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70,
  0x00, 0x0C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x08, 0x38, 0x00, 0xFF, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x07, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x06, 0x00,
  0x38, 0x06, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0C, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x70, 0x00, 0x18, 0xF0, 0x00, 0x19, 0xB0, 0x00, 0x13, 0x38,
  0x00, 0x36, 0x18, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03,
  0x80, 0x60, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0x8E, 0x07, 0x07, 0x03, 0xC0,
  0xCC, 0x01, 0x87, 0x00, 0x60, 0x6C, 0x00, 0x66, 0x00, 0x30, 0x2C, 0x00,
  0x36, 0x00, 0x1C, 0x34, 0x00, 0x1B, 0x00, 0x06, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x87, 0x00, 0x03, 0x80, 0x01, 0x83,
  0x00, 0x01, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x86, 0x00, 0x03,
  0x00, 0x01, 0x87, 0x00, 0x01, 0x80, 0x00, 0xC3, 0x00, 0x01, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x03, 0xF8, 0x03, 0x07, 0xFF, 0x01, 0x8F, 0x03, 0xC0, 0xCE,
  0x00, 0x60, 0x6E, 0x00, 0x38, 0x36, 0x00, 0x0C, 0x36, 0x00, 0x06, 0x1E,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x70, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x63, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x0F, 0x00, 0x70, 0x03, 0xE1, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x7F, 0x00, 0x02, 0x0F,
  0xFE, 0x00, 0x30, 0xE0, 0x78, 0x01, 0x9C, 0x00, 0xC0, 0x0D, 0xC0, 0x07,
  0x00, 0x68, 0x00, 0x18, 0x06, 0xC0, 0x00, 0xC0, 0x3C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03,
  0x00, 0xCC, 0x00, 0x70, 0x06, 0x30, 0x07, 0x00, 0x30, 0xF1, 0xF0, 0x01,
  0x83, 0xFE, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x3F, 0xFC, 0x30, 0x1E, 0x03,
  0x88, 0x0E, 0x00, 0x66, 0x06, 0x00, 0x0D, 0x83, 0x80, 0x01, 0x61, 0xC0,
  0x00, 0x78, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x3C, 0x30,
  0x00, 0x0E, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x03, 0x60, 0xE0, 0x01, 0x98,
  0x18, 0x00, 0xC6, 0x03, 0x00, 0xE3, 0x00, 0xF8, 0xF0, 0xC0, 0x0F, 0xF0,
  0x30, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0x03, 0xF0, 0x20,
  0xFE, 0x06, 0x3C, 0x00, 0x67, 0x00, 0x06, 0xC0, 0x00, 0x68, 0x00, 0x0D,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC1, 0xC0, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x84, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0xF8, 0x7C, 0x03, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC7, 0x01, 0xFE, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x38, 0x00,
  0x06, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x03, 0xC3, 0x00,
  0x01, 0x61, 0x80, 0x01, 0xE0, 0xC0, 0x01, 0xB0, 0x70, 0x01, 0x98, 0x1C,
  0x03, 0x8C, 0x07, 0xCF, 0x86, 0x01, 0xFF, 0x06, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0,
  0x00, 0x33, 0x00, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x01,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0xE0, 0x03, 0x03, 0x00, 0x04, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x00,
  0xB0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x18, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x07, 0x60, 0x00, 0xE0,
  0x00, 0xCC, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x06, 0x30, 0x01,
  0x98, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x18,
  0x01, 0x8C, 0x01, 0x81, 0x80, 0x61, 0x80, 0x30, 0x30, 0x0C, 0x30, 0x0C,
  0x06, 0x03, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x40, 0x60, 0x18, 0x18, 0x0C,
  0x0C, 0x03, 0x03, 0x01, 0x83, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x18,
  0x06, 0x1C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0xE0, 0x06,
  0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x03, 0x30, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x16, 0x00, 0x0D, 0x80, 0x02,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x00, 0xC0,
  0x01, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x70, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0x18, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x5C, 0x1F, 0x00, 0x78, 0x01,
  0xF0, 0xE8, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 39, 12, 2, -39 },
  { 50, 13, 14, 18, 6, -39 },
  { 73, 32, 39, 34, 2, -39 },
  { 229, 25, 44, 30, 3, -41 },
  { 367, 34, 40, 42, 5, -39 },
  { 537, 33, 40, 37, 2, -39 },
  { 702, 5, 14, 10, 6, -39 },
  { 711, 15, 48, 14, 2, -39 },
  { 801, 16, 48, 14, -4, -39 },
  { 897, 22, 23, 29, 7, -41 },
  { 961, 25, 25, 31, 4, -32 },
  { 1040, 8, 13, 11, -2, -6 },
  { 1053, 13, 2, 17, 2, -16 },
  { 1057, 3, 4, 12, 2, -4 },
  { 1059, 24, 39, 17, -2, -39 },
  { 1176, 26, 40, 30, 3, -39 },
  { 1306, 13, 39, 30, 9, -39 },
  { 1370, 28, 39, 30, 0, -39 },
  { 1507, 27, 40, 30, 1, -39 },
  { 1642, 28, 39, 30, 1, -39 },
  { 1779, 27, 40, 30, 2, -39 },
  { 1914, 25, 40, 30, 4, -39 },
  { 2039, 24, 39, 30, 6, -39 },
  { 2156, 26, 40, 30, 3, -39 },
  { 2286, 25, 40, 30, 3, -39 },
  { 2411, 8, 29, 12, 2, -29 },
  { 2440, 12, 36, 12, -2, -29 },
  { 2494, 25, 25, 31, 4, -32 },
  { 2573, 25, 12, 31, 4, -25 },
  { 2611, 25, 25, 31, 4, -32 },
  { 2690, 19, 39, 22, 4, -39 },
  { 2783, 41, 43, 45, 3, -38 },
  { 3004, 30, 39, 30, -3, -39 },
  { 3151, 28, 39, 32, 3, -39 },
  { 3288, 30, 40, 32, 4, -39 },
  { 3438, 31, 39, 36, 3, -39 },
  { 3590, 27, 39, 29, 3, -39 },
  { 3722, 27, 39, 26, 3, -39 },
  { 3854, 32, 40, 37, 4, -39 },
  { 4014, 34, 39, 37, 3, -39 },
  { 4180, 18, 39, 16, 0, -39 },
  { 4268, 22, 49, 13, -9, -39 },
  { 4403, 31, 39, 30, 3, -39 },
  { 4555, 19, 39, 26, 3, -39 },
  { 4648, 41, 39, 44, 3, -39 },
  { 4848, 34, 39, 37, 3, -39 },
  { 5014, 33, 40, 39, 4, -39 },
  { 5179, 27, 39, 30, 3, -39 },
  { 5311, 33, 48, 39, 4, -39 },
  { 5509, 27, 39, 30, 3, -39 },
  { 5641, 27, 40, 27, 1, -39 },
  { 5776, 26, 39, 26, 5, -39 },
  { 5903, 32, 40, 37, 5, -39 },
  { 6063, 27, 39, 29, 6, -39 },
  { 6195, 42, 39, 45, 7, -39 },
  { 6400, 34, 39, 27, -3, -39 },
  { 6566, 26, 39, 26, 5, -39 },
  { 6693, 31, 39, 29, 0, -39 },
  { 6845, 20, 48, 16, 0, -39 },
  { 6965, 9, 39, 17, 5, -39 },
  { 7009, 21, 48, 16, -4, -39 },
  { 7135, 25, 24, 30, 3, -39 },
  { 7210, 21, 2, 20, -5, 6 },
  { 7216, 7, 8, 13, 8, -41 },
  { 7223, 25, 30, 30, 3, -29 },
  { 7317, 26, 42, 31, 2, -41 },
  { 7454, 22, 30, 24, 3, -29 },
  { 7537, 28, 42, 31, 3, -41 },
  { 7684, 22, 30, 27, 3, -29 },
  { 7767, 30, 54, 15, -7, -41 },
  { 7970, 28, 42, 31, 1, -29 },
  { 8117, 25, 41, 30, 2, -41 },
  { 8246, 10, 39, 12, 2, -39 },
  { 8295, 20, 52, 12, -8, -39 },
  { 8425, 24, 41, 24, 2, -41 },
  { 8548, 10, 41, 12, 2, -41 },
  { 8600, 41, 29, 46, 2, -29 },
  { 8749, 25, 29, 30, 2, -29 },
  { 8840, 25, 30, 31, 3, -29 },
  { 8934, 29, 42, 31, -1, -29 },
  { 9087, 26, 42, 31, 3, -29 },
  { 9224, 20, 29, 20, 2, -29 },
  { 9297, 21, 30, 23, 1, -29 },
  { 9376, 15, 37, 17, 3, -36 },
  { 9446, 25, 30, 30, 3, -29 },
  { 9540, 22, 29, 23, 3, -29 },
  { 9620, 35, 29, 36, 3, -29 },
  { 9747, 28, 29, 25, -2, -29 },
  { 9849, 31, 42, 23, -6, -29 },
  { 10012, 25, 29, 24, -1, -29 },
  { 10103, 20, 48, 18, 1, -39 },
  { 10223, 2, 54, 29, 15, -41 },
  { 10237, 20, 48, 18, -3, -39 },
  { 10357, 25, 6, 31, 4, -22 },
};

const GFXfont NotoSans_ExtraLightItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRALIGHTITALIC54PT7B_H_
