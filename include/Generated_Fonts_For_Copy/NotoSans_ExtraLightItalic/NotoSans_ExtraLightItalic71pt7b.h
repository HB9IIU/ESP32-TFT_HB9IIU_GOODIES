#ifndef _NOTOSANS_EXTRALIGHTITALIC71PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E,
  0x30, 0x0C, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x60, 0x18,
  0x60, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xC1, 0x83, 0xE0, 0x03, 0xC0, 0xE0, 0x18, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x0F, 0x9C, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0C, 0xF8, 0x00, 0x00, 0x03, 0x0F,
  0x80, 0x00, 0x00, 0xC1, 0xF0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x70,
  0x0E, 0x00, 0x60, 0x78, 0x03, 0xF8, 0x18, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x18,
  0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0x07,
  0x01, 0xF0, 0x70, 0x00, 0x60, 0x70, 0x3F, 0xE3, 0x80, 0x07, 0x07, 0x07,
  0xEF, 0x9C, 0x00, 0x30, 0x38, 0x78, 0x0E, 0xE0, 0x03, 0x83, 0x87, 0x80,
  0x77, 0x00, 0x38, 0x38, 0x38, 0x01, 0xD8, 0x01, 0xC1, 0x83, 0x80, 0x0E,
  0xE0, 0x1C, 0x1C, 0x18, 0x00, 0x73, 0x83, 0xC1, 0xC1, 0xC0, 0x03, 0x9F,
  0xFC, 0x1C, 0x0C, 0x00, 0x1C, 0x3F, 0x80, 0xC0, 0xE0, 0x00, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x00, 0x0E,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x10, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x80, 0x07, 0x07, 0x00, 0x00, 0x38, 0x00, 0xC1,
  0xC0, 0x00, 0x03, 0x80, 0x38, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x06, 0x00,
  0x00, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x38, 0x00, 0x00,
  0x07, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xF7, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xDC, 0x00, 0xF0,
  0x00, 0x00, 0xF1, 0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x38, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8C, 0x31, 0xC7, 0x18, 0x61, 0x86,
  0x30, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0xC0, 0x18, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x1E, 0x06,
  0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0x7B, 0x00, 0x1C, 0x00, 0xF8, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x04, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x33, 0xFF, 0xFF,
  0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3D, 0xC0,
  0x3C, 0x60, 0x3E, 0x38, 0x1E, 0x0E, 0x1F, 0x03, 0x8F, 0x00, 0xEF, 0x80,
  0x71, 0x80, 0x1C, 0x40, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x04, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x20, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x01, 0xFF, 0x80, 0x03, 0x83, 0xFF, 0xF8,
  0x00, 0xE1, 0xF0, 0x1F, 0x00, 0x31, 0xE0, 0x01, 0xE0, 0x1C, 0xE0, 0x00,
  0x3C, 0x07, 0x70, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x00, 0xE0, 0x7C, 0x00,
  0x00, 0x38, 0x3E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x0E, 0xE0,
  0x38, 0x00, 0x07, 0x30, 0x0F, 0x00, 0x07, 0x9C, 0x01, 0xF0, 0x07, 0xC7,
  0x00, 0x1F, 0xFF, 0xC1, 0xC0, 0x03, 0xFF, 0xC0, 0x60, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xF8, 0x1C, 0x00, 0x3C, 0x10,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x0E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x18, 0x70, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x61, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0x8E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x06, 0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x1C, 0xC0, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x77, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0x9C, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x06, 0x70, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x19,
  0x80, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x03, 0xB8, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0E, 0xE0, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x3B, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0xCE, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x07, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xE3, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0x8E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1C, 0x38, 0x01, 0xC0, 0x00, 0xD8,
  0x00, 0x70, 0xE0, 0x03, 0x00, 0x07, 0x60, 0x03, 0x83, 0x80, 0x0E, 0x00,
  0x39, 0x80, 0x1C, 0x0E, 0x00, 0x3C, 0x01, 0xC7, 0x00, 0xE0, 0x18, 0x00,
  0x78, 0x1E, 0x0E, 0x0F, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x01,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x40,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x10, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0x8E, 0x00, 0x00, 0x40,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x0C, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0x9E, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x1C, 0x00, 0x00, 0x00, 0x37,
  0x07, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3B, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x73, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x03, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x80, 0x06, 0x18, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x30, 0x00, 0xC1,
  0xC0, 0x00, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x07, 0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x01, 0x80,
  0x07, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x03, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x03, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x06, 0x03, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x31,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0xCE, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0xDC, 0x00,
  0x00, 0x01, 0xC0, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x60, 0x03, 0x8C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x38, 0x00, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0x06, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x03, 0x81, 0x80, 0x00, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x00,
  0x03, 0x81, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x00, 0x00,
  0x70, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x87, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x77, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xB8, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01,
  0xF0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x04, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x20, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x01, 0x80,
  0x07, 0x00, 0x18, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xE0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x83, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x00, 0x07, 0xFE,
  0x01, 0x80, 0x0F, 0xFF, 0x81, 0xC0, 0x0F, 0xC1, 0xE0, 0xC0, 0x1F, 0x00,
  0x38, 0x60, 0x1E, 0x00, 0x0E, 0x30, 0x1E, 0x00, 0x03, 0x38, 0x0E, 0x00,
  0x00, 0xDC, 0x0E, 0x00, 0x00, 0x6C, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x00, 0x78, 0x30, 0x00, 0x00, 0x78,
  0x18, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x3F,
  0x03, 0x80, 0x00, 0x1B, 0x01, 0xC0, 0x00, 0x19, 0x80, 0x70, 0x00, 0x18,
  0xC0, 0x3C, 0x00, 0x18, 0xE0, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC0, 0x78,
  0x30, 0x00, 0xFF, 0xF8, 0x18, 0x00, 0x3F, 0xF0, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0xF0, 0x00, 0x1C, 0x0F, 0xFF, 0x80, 0x03, 0x07, 0xC0,
  0xF8, 0x00, 0xE1, 0xE0, 0x07, 0x80, 0x1C, 0x70, 0x00, 0x78, 0x03, 0x9C,
  0x00, 0x07, 0x00, 0x77, 0x00, 0x00, 0xF0, 0x0D, 0xC0, 0x00, 0x0E, 0x03,
  0xB0, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x03,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x38, 0x0D,
  0x80, 0x00, 0x0F, 0x01, 0xB0, 0x00, 0x01, 0xC0, 0x77, 0x00, 0x00, 0x70,
  0x0E, 0x60, 0x00, 0x3C, 0x01, 0x8F, 0x00, 0x0F, 0x00, 0x30, 0xF0, 0x07,
  0xC0, 0x06, 0x0F, 0xFF, 0xF0, 0x01, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x7C, 0x01, 0xF0, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x0E,
  0x00, 0x0F, 0xC0, 0xF0, 0x70, 0x01, 0xF0, 0x01, 0xC3, 0x00, 0x1E, 0x00,
  0x07, 0x38, 0x01, 0xE0, 0x00, 0x1D, 0xC0, 0x1E, 0x00, 0x00, 0x6E, 0x00,
  0xE0, 0x00, 0x03, 0x60, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x06, 0x00,
  0x00, 0x03, 0xC0, 0x30, 0x00, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x03, 0x80, 0x00,
  0x0D, 0xC0, 0x1C, 0x00, 0x00, 0xCC, 0x00, 0x70, 0x00, 0x0C, 0x60, 0x03,
  0xC0, 0x01, 0xC3, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x7C, 0x03, 0xC1,
  0xC0, 0x01, 0xFF, 0xFC, 0x0C, 0x00, 0x03, 0xFF, 0x80, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0xF8, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x01, 0xF0, 0x70, 0x00, 0x7F, 0x03, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x00, 0x7F, 0xFE, 0x07, 0x00, 0x0F,
  0xC0, 0xF0, 0x70, 0x03, 0xE0, 0x03, 0x86, 0x00, 0x78, 0x00, 0x1C, 0x60,
  0x0F, 0x00, 0x00, 0xE6, 0x01, 0xE0, 0x00, 0x06, 0xE0, 0x1C, 0x00, 0x00,
  0x6C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x30, 0x00,
  0x00, 0x3C, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x7C, 0x03,
  0x80, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x01, 0xDC, 0x03, 0x80, 0x00, 0x19,
  0x80, 0x1C, 0x00, 0x07, 0x18, 0x01, 0xE0, 0x00, 0xE3, 0x80, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0xF8, 0x07, 0x83, 0x80, 0x07, 0xFF, 0xF0, 0x30, 0x00,
  0x1F, 0xFC, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xF0, 0x00, 0x70, 0x3F, 0xFE, 0x00,
  0x30, 0x7E, 0x0F, 0x80, 0x38, 0x78, 0x01, 0xE0, 0x1C, 0x70, 0x00, 0x78,
  0x0E, 0x70, 0x00, 0x1C, 0x06, 0x70, 0x00, 0x0E, 0x03, 0x70, 0x00, 0x03,
  0x03, 0xB0, 0x00, 0x01, 0x81, 0xF0, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00,
  0x60, 0x78, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x39, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x30,
  0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x03,
  0x8F, 0xC0, 0x00, 0x01, 0xCE, 0x70, 0x00, 0x00, 0xCE, 0x38, 0x00, 0x00,
  0x6E, 0x0E, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0C,
  0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x31, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x01, 0xCE, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x06, 0x30, 0x00, 0x38, 0xE0,
  0x00, 0x70, 0x19, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xC0, 0x6C, 0x00, 0x03,
  0x98, 0x00, 0x07, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x1F, 0xFF, 0x00, 0x0C,
  0x1F, 0x87, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x01, 0xC7, 0x00, 0x07, 0x80,
  0x73, 0x80, 0x00, 0xE0, 0x19, 0xC0, 0x00, 0x38, 0x06, 0xE0, 0x00, 0x06,
  0x03, 0xB0, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x00, 0x60, 0x3E, 0x00, 0x00,
  0x18, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xFE,
  0x00, 0x00, 0x60, 0x3F, 0xFE, 0x00, 0x01, 0x83, 0xE0, 0x7C, 0x00, 0x06,
  0x1E, 0x00, 0x78, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0x00, 0xE7, 0x00, 0x01,
  0xC0, 0x03, 0x38, 0x00, 0x07, 0x80, 0x0D, 0xC0, 0x00, 0x0E, 0x00, 0x76,
  0x00, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x01,
  0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x01,
  0xB0, 0x00, 0x01, 0xC0, 0x0E, 0xE0, 0x00, 0x0E, 0x00, 0x39, 0x80, 0x00,
  0xF0, 0x00, 0xE3, 0x80, 0x07, 0x80, 0x03, 0x0F, 0x00, 0x7C, 0x00, 0x0C,
  0x1F, 0xFF, 0xE0, 0x00, 0x70, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xC0, 0x07,
  0xFF, 0xE0, 0x70, 0x03, 0xF0, 0x3C, 0x1C, 0x03, 0xE0, 0x03, 0x86, 0x01,
  0xE0, 0x00, 0x71, 0x80, 0xF0, 0x00, 0x0E, 0x60, 0x78, 0x00, 0x01, 0xB8,
  0x1C, 0x00, 0x00, 0x6C, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0x78, 0x30, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x0F,
  0x03, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00,
  0xFC, 0x0E, 0x00, 0x00, 0x77, 0x03, 0x80, 0x00, 0x19, 0x80, 0x70, 0x00,
  0x1C, 0x60, 0x1E, 0x00, 0x0E, 0x38, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x78,
  0x07, 0x83, 0x80, 0x0F, 0xFF, 0xC0, 0xC0, 0x01, 0xFF, 0xC0, 0x70, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x3F, 0xE0, 0x18, 0x1F, 0xF8, 0x03, 0x07, 0xE3, 0x00, 0x61,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x08, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x7C, 0x00, 0x03, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x3E, 0x07, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x1B, 0x81, 0xC0, 0x00,
  0x1D, 0xC0, 0xE0, 0x00, 0x1C, 0xC0, 0x38, 0x00, 0x1C, 0x60, 0x1E, 0x00,
  0x3C, 0x70, 0x07, 0x80, 0x7C, 0x38, 0x01, 0xFF, 0xF8, 0x1C, 0x00, 0x7F,
  0xF0, 0x0C, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0xE0, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x73, 0x80,
  0x00, 0xEC, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0xE0, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x01, 0x80, 0x0E, 0x06, 0x00,
  0x38, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x07, 0x01, 0x80, 0x1C,
  0x03, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xE0, 0x18, 0x03, 0x80, 0x60, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38,
  0x0C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x06,
  0x00, 0x18, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x00,
  0x06, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0x80, 0x01,
  0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xCE, 0x00, 0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1D, 0xC0,
  0x00, 0x37, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x9F, 0xFF, 0xC0, 0x00, 0xDE, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x81, 0xEC, 0x00, 0x07, 0xFF, 0xE4, 0x00,
  0x00, 0x7F, 0xC0,
};

const GFXglyph NotoSans_ExtraLightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 14, 52, 16, 2, -51 },
  { 92, 16, 19, 23, 8, -51 },
  { 130, 43, 51, 44, 2, -51 },
  { 405, 34, 58, 39, 3, -54 },
  { 652, 45, 52, 55, 6, -51 },
  { 945, 43, 52, 48, 3, -51 },
  { 1225, 6, 19, 13, 8, -51 },
  { 1240, 21, 62, 18, 2, -51 },
  { 1403, 21, 62, 18, -5, -51 },
  { 1566, 29, 31, 38, 9, -54 },
  { 1679, 33, 33, 40, 5, -42 },
  { 1816, 10, 17, 14, -3, -8 },
  { 1838, 17, 3, 22, 3, -21 },
  { 1845, 5, 6, 16, 2, -5 },
  { 1849, 32, 51, 22, -3, -51 },
  { 2053, 33, 52, 39, 5, -51 },
  { 2268, 18, 51, 39, 11, -51 },
  { 2383, 35, 51, 39, 1, -51 },
  { 2607, 35, 52, 39, 2, -51 },
  { 2835, 37, 51, 39, 1, -51 },
  { 3071, 35, 52, 39, 3, -51 },
  { 3299, 34, 53, 39, 5, -52 },
  { 3525, 32, 51, 39, 8, -51 },
  { 3729, 35, 52, 39, 3, -51 },
  { 3957, 34, 52, 39, 3, -51 },
  { 4178, 12, 39, 16, 2, -38 },
  { 4237, 17, 47, 16, -3, -38 },
  { 4337, 33, 32, 40, 5, -42 },
  { 4469, 33, 16, 40, 5, -33 },
  { 4535, 33, 32, 40, 5, -42 },
  { 4667, 24, 52, 29, 6, -51 },
  { 4823, 54, 56, 59, 4, -50 },
  { 5201, 40, 51, 39, -4, -51 },
  { 5456, 38, 51, 42, 3, -51 },
  { 5699, 39, 52, 42, 6, -51 },
  { 5953, 42, 51, 48, 3, -51 },
  { 6221, 37, 51, 38, 3, -51 },
  { 6457, 37, 51, 34, 3, -51 },
  { 6693, 41, 52, 49, 6, -51 },
  { 6960, 45, 51, 48, 3, -51 },
  { 7247, 23, 51, 20, 0, -51 },
  { 7394, 29, 64, 17, -12, -51 },
  { 7626, 42, 51, 39, 3, -51 },
  { 7894, 26, 51, 35, 3, -51 },
  { 8060, 55, 51, 58, 3, -51 },
  { 8411, 45, 51, 48, 3, -51 },
  { 8698, 42, 52, 51, 6, -51 },
  { 8971, 37, 51, 40, 3, -51 },
  { 9207, 42, 63, 51, 6, -51 },
  { 9538, 37, 51, 40, 3, -51 },
  { 9774, 35, 52, 35, 1, -51 },
  { 10002, 34, 51, 35, 7, -51 },
  { 10219, 43, 52, 49, 6, -51 },
  { 10499, 37, 51, 38, 7, -51 },
  { 10735, 55, 51, 59, 9, -51 },
  { 11086, 45, 51, 35, -4, -51 },
  { 11373, 34, 51, 35, 7, -51 },
  { 11590, 42, 51, 38, -1, -51 },
  { 11858, 27, 62, 21, -1, -51 },
  { 12068, 11, 51, 22, 7, -51 },
  { 12139, 27, 62, 21, -5, -51 },
  { 12349, 33, 31, 39, 3, -51 },
  { 12477, 27, 3, 27, -6, 7 },
  { 12488, 9, 11, 17, 10, -54 },
  { 12501, 33, 39, 39, 4, -38 },
  { 12662, 35, 55, 40, 2, -54 },
  { 12903, 29, 39, 32, 4, -38 },
  { 13045, 37, 55, 40, 4, -54 },
  { 13300, 29, 39, 35, 4, -38 },
  { 13442, 39, 71, 20, -9, -54 },
  { 13789, 36, 55, 40, 2, -38 },
  { 14037, 33, 54, 40, 2, -54 },
  { 14260, 14, 51, 15, 2, -51 },
  { 14350, 26, 68, 15, -10, -51 },
  { 14571, 33, 54, 32, 2, -54 },
  { 14794, 14, 54, 15, 2, -54 },
  { 14889, 54, 38, 60, 2, -38 },
  { 15146, 34, 38, 40, 2, -38 },
  { 15308, 32, 39, 40, 4, -38 },
  { 15464, 38, 55, 40, -1, -38 },
  { 15726, 34, 55, 40, 4, -38 },
  { 15960, 27, 38, 27, 2, -38 },
  { 16089, 28, 39, 30, 1, -38 },
  { 16226, 20, 48, 22, 4, -47 },
  { 16346, 33, 39, 40, 4, -38 },
  { 16507, 29, 38, 30, 4, -38 },
  { 16645, 45, 38, 47, 4, -38 },
  { 16859, 36, 38, 33, -2, -38 },
  { 17030, 41, 55, 30, -8, -38 },
  { 17312, 32, 38, 31, -1, -38 },
  { 17464, 25, 62, 24, 2, -51 },
  { 17658, 2, 71, 38, 20, -54 },
  { 17676, 25, 62, 24, -3, -51 },
  { 17870, 33, 6, 40, 5, -28 },
};

const GFXfont NotoSans_ExtraLightItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRALIGHTITALIC71PT7B_H_
