#ifndef _NOTOSANS_EXTRALIGHTITALIC56PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x40, 0x00, 0x18, 0x18,
  0xC0, 0xCE, 0x0E, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xCC, 0x04, 0x60,
  0x63, 0x03, 0x18, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x60, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0x8C, 0xFC, 0x07, 0x86, 0x02, 0x03, 0x81, 0x80, 0x01,
  0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x98, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x37, 0x80,
  0x00, 0x0C, 0x78, 0x00, 0x02, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03, 0x82,
  0x00, 0x81, 0xC0, 0xE0, 0x61, 0xE0, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x1E, 0x78, 0x00, 0x0C, 0x07, 0x03,
  0x00, 0x03, 0x81, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x60, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x01, 0x80,
  0xE0, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x01,
  0x81, 0x80, 0x06, 0x00, 0x30, 0x70, 0x00, 0xC0, 0x0E, 0x0C, 0x00, 0x18,
  0x01, 0x83, 0x07, 0xF3, 0x00, 0x30, 0xE3, 0xEF, 0x60, 0x0C, 0x18, 0xE0,
  0x6C, 0x01, 0x86, 0x18, 0x07, 0x80, 0x61, 0x86, 0x00, 0xD8, 0x18, 0x70,
  0xC0, 0x1B, 0xCF, 0x0C, 0x30, 0x03, 0x3F, 0x83, 0x06, 0x00, 0x60, 0xC0,
  0xC1, 0x80, 0x0C, 0x00, 0x38, 0x30, 0x01, 0x80, 0x06, 0x06, 0x00, 0x30,
  0x01, 0x80, 0xC0, 0x06, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x1C, 0x06, 0x00,
  0x30, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x38, 0x0E, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0x30, 0x18, 0x00, 0x38, 0x0E, 0x07, 0x00, 0x03, 0x03, 0x80,
  0xC0, 0x00, 0x78, 0xE0, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x04, 0x1C, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x01, 0x86,
  0x00, 0x1C, 0x00, 0xC3, 0x80, 0x03, 0x80, 0x31, 0xC0, 0x00, 0x60, 0x18,
  0x60, 0x00, 0x0C, 0x0E, 0x18, 0x00, 0x03, 0x83, 0x06, 0x00, 0x00, 0x61,
  0x83, 0x80, 0x00, 0x0C, 0xC0, 0xE0, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x00,
  0x78, 0x06, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0D, 0x80, 0x70, 0x00,
  0x0E, 0x70, 0x0E, 0x00, 0x07, 0x0C, 0x01, 0xC0, 0x07, 0x81, 0x80, 0x3F,
  0x3F, 0x80, 0x70, 0x07, 0xFF, 0x80, 0x0E, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x18, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x18, 0x84, 0x60, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x38, 0x06, 0x00, 0x3C, 0x0C, 0x00,
  0x1E, 0x18, 0x00, 0x0E, 0x20, 0x00, 0x07, 0x41, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x01, 0x86, 0x00, 0x06,
  0x0C, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x30, 0x02, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF4, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE7, 0xC0,
  0x03, 0xC0, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0x38, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x1C, 0x60, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x60,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x7C, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x0F,
  0xC0, 0x77, 0x07, 0x98, 0x38, 0x63, 0xC1, 0x9C, 0x0E, 0xE0, 0x31, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0x80, 0x1E,
  0x01, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x78, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x38, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18,
  0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x1C,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x78, 0x0E,
  0x00, 0x1F, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x1C,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0F, 0x80, 0x0C, 0x1F, 0xF8,
  0x03, 0x1E, 0x0F, 0x81, 0x9C, 0x00, 0xF0, 0x6E, 0x00, 0x0C, 0x1E, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80,
  0x60, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x06, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x00,
  0xFC, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE7, 0xC0, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0C, 0xE0,
  0x00, 0x03, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x3C,
  0x60, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x07, 0x60, 0x70, 0x03,
  0x98, 0x1F, 0x07, 0x8C, 0x01, 0xFF, 0xC3, 0x00, 0x1F, 0x80, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x08, 0x01, 0xE0, 0x03, 0xE7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x0E, 0x07,
  0x01, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x3F, 0xDF, 0x81,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x0F, 0xFC, 0x00, 0xC6, 0x00, 0x0F,
  0x8F, 0x80, 0x31, 0x80, 0x0F, 0x00, 0x60, 0x0C, 0xC0, 0x07, 0x00, 0x18,
  0x03, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xDC, 0x01, 0xC0, 0x03, 0x00, 0x36,
  0x00, 0x60, 0x00, 0xC0, 0x0D, 0x80, 0x30, 0x00, 0x30, 0x03, 0x60, 0x0C,
  0x00, 0x18, 0x00, 0xF8, 0x07, 0x00, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x01,
  0x80, 0x0F, 0x00, 0x60, 0x00, 0xE0, 0x06, 0xC0, 0x18, 0x00, 0x30, 0x01,
  0xB0, 0x06, 0x00, 0x0C, 0x00, 0x6C, 0x01, 0x80, 0x07, 0x00, 0x33, 0x00,
  0x60, 0x01, 0xC0, 0x0C, 0xC0, 0x18, 0x00, 0xF0, 0x06, 0x30, 0x06, 0x00,
  0x6C, 0x03, 0x8C, 0x01, 0xC0, 0x33, 0x01, 0xC1, 0x80, 0x38, 0x18, 0x60,
  0xE0, 0x60, 0x07, 0xFC, 0x1F, 0xF0, 0x18, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x60, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x0C, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1E, 0x03, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x78, 0x00, 0x04, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x60, 0x00, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x30, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x07, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x07,
  0xC0, 0x06, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFC, 0xC0, 0x00,
  0x7F, 0xFC, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFD, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x40, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x60, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0C, 0x7C, 0x00, 0x00, 0x0C,
  0xCE, 0x00, 0x00, 0x0D, 0x86, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E,
  0x03, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x06, 0xC0, 0x00, 0x00, 0x1B,
  0x01, 0xB0, 0x00, 0x00, 0x0F, 0x80, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x1B,
  0x00, 0x00, 0x01, 0x98, 0x06, 0xE0, 0x00, 0x00, 0xE6, 0x03, 0x18, 0x00,
  0x00, 0x33, 0x80, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x31, 0x80, 0x00, 0x06,
  0x30, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x01,
  0x87, 0x00, 0x00, 0x61, 0xC0, 0x60, 0xC0, 0x00, 0x38, 0x60, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x03, 0x83, 0x00, 0x01,
  0x83, 0x80, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x30, 0x38, 0x00, 0x70, 0x30,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x1C, 0x01,
  0x80, 0xE0, 0x0C, 0x06, 0x00, 0xE0, 0x30, 0x03, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x60, 0x03, 0x01, 0xC0, 0x0E,
  0x38, 0x00, 0xC0, 0x60, 0x01, 0x8C, 0x00, 0x70, 0x18, 0x00, 0x66, 0x00,
  0x18, 0x06, 0x00, 0x19, 0x80, 0x06, 0x01, 0x80, 0x06, 0xC0, 0x01, 0x80,
  0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x30, 0x00, 0x78, 0x00, 0x30, 0x0C, 0x00,
  0x0E, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x00, 0xF8,
  0x00, 0x00, 0x60, 0x1B, 0x00, 0x00, 0x0C, 0x03, 0x60, 0x00, 0x01, 0x80,
  0x66, 0x00, 0x00, 0x70, 0x0C, 0xC0, 0x00, 0x0C, 0x03, 0x1C, 0x00, 0x01,
  0x80, 0x61, 0x80, 0x00, 0x30, 0x0C, 0x30, 0x00, 0x06, 0x01, 0x83, 0x00,
  0x01, 0xC0, 0x70, 0x60, 0x00, 0x30, 0x0C, 0x0E, 0x00, 0x06, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0x18, 0x06, 0x01, 0x80, 0x06, 0x01,
  0xC0, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x03,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x18,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x03, 0x00,
  0x07, 0x03, 0x80, 0x60, 0x00, 0x60, 0x60, 0x1C, 0x00, 0x0E, 0x0C, 0x03,
  0x00, 0x00, 0xC1, 0x80, 0x60, 0x00, 0x18, 0x30, 0x0C, 0x00, 0x01, 0x8E,
  0x03, 0x80, 0x00, 0x31, 0x80, 0x60, 0x00, 0x07, 0x30, 0x0C, 0x00, 0x00,
  0x66, 0x01, 0x80, 0x00, 0x0C, 0xC0, 0x30, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x1E, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x0F, 0x80, 0x1C, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0C, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x0F, 0xC0,
  0x1C, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x38, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x07, 0x80, 0x0E, 0x00,
  0xE0, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x17, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x70, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x76, 0x00,
  0x03, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x07,
  0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x07, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x30, 0x0E,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x30, 0x1C, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x60, 0x03, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x8E, 0x00, 0x06, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x9C,
  0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x10,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xC1, 0xC1, 0x83, 0x83, 0x03, 0x02, 0x06, 0x00, 0x1F, 0xC0, 0xC0, 0x1F,
  0xFC, 0x30, 0x1E, 0x03, 0x8C, 0x0E, 0x00, 0x62, 0x07, 0x00, 0x0D, 0x83,
  0x80, 0x01, 0x60, 0xC0, 0x00, 0x78, 0x60, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0F, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0xD8, 0x18, 0x00, 0x66, 0x07, 0x00, 0x31, 0x80, 0xE0,
  0x38, 0xC0, 0x1F, 0x7C, 0x30, 0x03, 0xFC, 0x0C, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x07, 0xF8, 0x00,
  0xC3, 0xFF, 0x80, 0x18, 0xE0, 0x38, 0x06, 0x30, 0x03, 0x80, 0xCC, 0x00,
  0x38, 0x1B, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x60, 0xD0, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0x87, 0x80, 0x00, 0x60, 0xF0, 0x00, 0x1C, 0x1B, 0x00, 0x07, 0x06,
  0x60, 0x01, 0xC0, 0xC7, 0x00, 0xF0, 0x18, 0x7C, 0xFC, 0x03, 0x07, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x07,
  0x80, 0x10, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x02, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0x81, 0x80, 0x07, 0xFF, 0x06, 0x00, 0x78, 0x06, 0x30, 0x03,
  0x80, 0x0C, 0xC0, 0x1C, 0x00, 0x1B, 0x00, 0xE0, 0x00, 0x2C, 0x03, 0x00,
  0x00, 0xB0, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x2C, 0x03, 0x80, 0x01, 0xB0, 0x06, 0x00, 0x0C,
  0xC0, 0x1C, 0x00, 0xE6, 0x00, 0x38, 0x07, 0x18, 0x00, 0x7C, 0xF8, 0x60,
  0x00, 0xFF, 0x81, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x60, 0x70, 0x00, 0xE0, 0xC0,
  0x01, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x18, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC6, 0x00, 0x0F, 0x0C, 0x01, 0xF8,
  0x1F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x03, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xF0, 0x40, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x18,
  0x00, 0xFF, 0xE0, 0xC0, 0x1E, 0x01, 0xC4, 0x01, 0xC0, 0x06, 0x60, 0x1C,
  0x00, 0x1B, 0x01, 0xC0, 0x00, 0x58, 0x0C, 0x00, 0x02, 0xC0, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x01, 0x60, 0x38,
  0x00, 0x1B, 0x00, 0xC0, 0x01, 0x98, 0x07, 0x00, 0x39, 0x80, 0x1C, 0x03,
  0x8C, 0x00, 0x7C, 0xF0, 0x60, 0x01, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0xFF, 0x00, 0x30, 0x7F, 0xF0, 0x0C, 0x70, 0x1E,
  0x06, 0x30, 0x01, 0x81, 0x98, 0x00, 0x70, 0x6C, 0x00, 0x0C, 0x1E, 0x00,
  0x03, 0x0D, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38,
  0x00, 0x07, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x1C, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x06, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x18,
  0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03,
  0x1E, 0x00, 0x01, 0x99, 0x80, 0x00, 0xD8, 0xC0, 0x00, 0xD8, 0x30, 0x00,
  0x78, 0x18, 0x00, 0x38, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x07,
  0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x00, 0x03, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xC3, 0xFF, 0x00, 0xFF,
  0xC0, 0x21, 0xC0, 0xE0, 0xE0, 0x38, 0x18, 0xC0, 0x18, 0x70, 0x07, 0x06,
  0x60, 0x03, 0x30, 0x00, 0xC1, 0xB0, 0x00, 0xCC, 0x00, 0x30, 0x78, 0x00,
  0x36, 0x00, 0x0C, 0x14, 0x00, 0x0F, 0x00, 0x03, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x80, 0x00, 0x61, 0x80, 0x00, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC7, 0x00, 0x01,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x80, 0x00, 0xE3,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x03, 0x03, 0xFC, 0x00, 0xC3, 0xFF, 0xC0, 0x21,
  0xC0, 0x78, 0x18, 0xE0, 0x06, 0x06, 0x60, 0x01, 0xC1, 0xB0, 0x00, 0x30,
  0x78, 0x00, 0x0C, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x30, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06,
  0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x7F, 0x80, 0x01, 0x87, 0xFF, 0x00, 0x04, 0x38, 0x0E, 0x00, 0x31,
  0x80, 0x1C, 0x00, 0xCC, 0x00, 0x38, 0x03, 0x60, 0x00, 0x60, 0x0F, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x06, 0x03, 0xC0, 0x00, 0x30, 0x0F, 0x00, 0x01, 0xC0, 0x36, 0x00, 0x0E,
  0x01, 0xD8, 0x00, 0x70, 0x06, 0x38, 0x07, 0x80, 0x18, 0x7C, 0xFC, 0x00,
  0x60, 0xFF, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x60, 0x0F, 0xFE, 0x0C,
  0x07, 0x80, 0x61, 0x01, 0xC0, 0x06, 0x60, 0x70, 0x00, 0x6C, 0x1C, 0x00,
  0x05, 0x83, 0x00, 0x00, 0xB0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x0F, 0x06, 0x00,
  0x01, 0x60, 0xE0, 0x00, 0x6C, 0x0C, 0x00, 0x19, 0x81, 0xC0, 0x06, 0x60,
  0x1C, 0x03, 0x8C, 0x01, 0xF3, 0xE1, 0x80, 0x1F, 0xF0, 0x30, 0x00, 0x20,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x03, 0xF8, 0x18, 0x7F,
  0x80, 0x87, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x78, 0x03, 0x83, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x08, 0x00, 0x18, 0x30, 0x01, 0xE0, 0xFE, 0x7F, 0x00, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x79, 0xC0, 0x3F, 0xC0, 0x04, 0x00, 0x06, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x03, 0xC3, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0xD8, 0x38, 0x00, 0x66, 0x06, 0x00, 0x39, 0x81,
  0xC0, 0x3C, 0x60, 0x3E, 0x7C, 0x30, 0x07, 0xFE, 0x0C, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30,
  0x60, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x80, 0x0C, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x07, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x87,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0,
  0x00, 0x13, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x06, 0xC0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x01,
  0xE0, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x1C, 0xE0, 0x03, 0x30, 0x01, 0x8E,
  0x00, 0x63, 0x00, 0x38, 0x60, 0x06, 0x30, 0x03, 0x06, 0x00, 0xC3, 0x00,
  0x70, 0x60, 0x0C, 0x30, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0x60, 0x18,
  0x30, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x06,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x60, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x18, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x06,
  0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x02, 0xC0, 0x01, 0xB0,
  0x00, 0x2C, 0x00, 0x1B, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x38, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18,
  0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x8F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x5F, 0x7F, 0x00, 0x3E, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0xFC, 0x80, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 41, 12, 2, -40 },
  { 58, 13, 14, 18, 6, -40 },
  { 81, 33, 40, 35, 2, -40 },
  { 246, 26, 45, 31, 3, -42 },
  { 393, 35, 42, 43, 5, -41 },
  { 577, 34, 42, 38, 2, -41 },
  { 756, 5, 14, 10, 6, -40 },
  { 765, 16, 49, 14, 2, -40 },
  { 863, 16, 49, 14, -4, -40 },
  { 961, 23, 24, 30, 7, -42 },
  { 1030, 26, 26, 32, 4, -33 },
  { 1115, 9, 14, 11, -3, -7 },
  { 1131, 13, 2, 17, 2, -16 },
  { 1135, 3, 5, 12, 2, -4 },
  { 1137, 25, 40, 18, -2, -40 },
  { 1262, 26, 42, 31, 4, -41 },
  { 1399, 14, 40, 31, 9, -40 },
  { 1469, 29, 41, 31, 0, -41 },
  { 1618, 28, 42, 31, 1, -41 },
  { 1765, 29, 40, 31, 1, -40 },
  { 1910, 28, 41, 31, 2, -40 },
  { 2054, 26, 42, 31, 4, -41 },
  { 2191, 25, 40, 31, 6, -40 },
  { 2316, 27, 42, 31, 3, -41 },
  { 2458, 26, 42, 31, 3, -41 },
  { 2595, 9, 31, 12, 2, -30 },
  { 2630, 14, 37, 12, -3, -30 },
  { 2695, 26, 26, 32, 4, -33 },
  { 2780, 26, 13, 32, 4, -26 },
  { 2823, 26, 26, 32, 4, -33 },
  { 2908, 20, 42, 23, 4, -41 },
  { 3013, 42, 45, 47, 3, -40 },
  { 3250, 31, 40, 31, -3, -40 },
  { 3405, 30, 40, 33, 3, -40 },
  { 3555, 30, 42, 33, 5, -41 },
  { 3713, 33, 40, 38, 3, -40 },
  { 3878, 28, 40, 30, 3, -40 },
  { 4018, 28, 40, 27, 3, -40 },
  { 4158, 32, 42, 39, 5, -41 },
  { 4326, 35, 40, 38, 3, -40 },
  { 4501, 18, 40, 16, 0, -40 },
  { 4591, 23, 50, 13, -9, -40 },
  { 4735, 32, 40, 31, 3, -40 },
  { 4895, 20, 40, 27, 3, -40 },
  { 4995, 42, 40, 46, 3, -40 },
  { 5205, 35, 40, 38, 3, -40 },
  { 5380, 33, 42, 40, 5, -41 },
  { 5554, 28, 40, 31, 3, -40 },
  { 5694, 33, 51, 40, 5, -41 },
  { 5905, 28, 40, 32, 3, -40 },
  { 6045, 28, 42, 28, 1, -41 },
  { 6192, 27, 40, 27, 5, -40 },
  { 6327, 34, 41, 39, 5, -40 },
  { 6502, 29, 40, 30, 6, -40 },
  { 6647, 44, 40, 47, 7, -40 },
  { 6867, 35, 40, 28, -3, -40 },
  { 7042, 28, 40, 27, 5, -40 },
  { 7182, 32, 40, 30, 0, -40 },
  { 7342, 22, 49, 17, -1, -40 },
  { 7477, 9, 40, 18, 6, -40 },
  { 7522, 21, 49, 17, -4, -40 },
  { 7651, 26, 25, 31, 3, -40 },
  { 7733, 22, 2, 21, -5, 6 },
  { 7739, 7, 9, 13, 8, -43 },
  { 7747, 26, 31, 31, 3, -30 },
  { 7848, 27, 44, 32, 2, -43 },
  { 7997, 23, 31, 25, 3, -30 },
  { 8087, 30, 44, 32, 3, -43 },
  { 8252, 23, 31, 28, 3, -30 },
  { 8342, 30, 56, 15, -7, -43 },
  { 8552, 29, 43, 32, 1, -30 },
  { 8708, 26, 43, 31, 2, -43 },
  { 8848, 11, 41, 12, 2, -41 },
  { 8905, 21, 54, 12, -8, -41 },
  { 9047, 25, 43, 25, 2, -43 },
  { 9182, 11, 43, 12, 2, -43 },
  { 9242, 42, 30, 48, 2, -30 },
  { 9400, 26, 30, 31, 2, -30 },
  { 9498, 26, 31, 32, 3, -30 },
  { 9599, 30, 43, 32, -1, -30 },
  { 9761, 27, 43, 32, 3, -30 },
  { 9907, 21, 30, 21, 2, -30 },
  { 9986, 22, 31, 24, 1, -30 },
  { 10072, 16, 38, 18, 3, -37 },
  { 10148, 26, 31, 31, 3, -30 },
  { 10249, 23, 30, 24, 3, -30 },
  { 10336, 36, 30, 37, 3, -30 },
  { 10471, 29, 30, 26, -2, -30 },
  { 10580, 32, 44, 24, -6, -30 },
  { 10756, 25, 30, 25, -1, -30 },
  { 10850, 21, 49, 19, 1, -40 },
  { 10979, 1, 57, 30, 16, -43 },
  { 10987, 21, 49, 19, -3, -40 },
  { 11116, 26, 5, 32, 4, -22 },
};

const GFXfont NotoSans_ExtraLightItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRALIGHTITALIC56PT7B_H_
