#ifndef _NOTOSANS_EXTRALIGHTITALIC67PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x07, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x40, 0x00, 0x0C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x0E, 0x38, 0x0E, 0x38,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x70, 0x18, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x30, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x9C, 0xFF, 0x00, 0x7C, 0x18, 0x0E, 0x00,
  0xF0, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x00, 0xF8, 0xC0, 0x00, 0x00, 0x7C, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xBE, 0x00, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x01, 0x83, 0xC0, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x80,
  0x0C, 0x0F, 0x00, 0xF8, 0x0C, 0x3E, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0xF8,
  0x00, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0xC0, 0x00,
  0x1C, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x60, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x38, 0x03, 0x80,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x38, 0x00, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x81, 0xC0,
  0xFC, 0x30, 0x00, 0xE0, 0xE0, 0xFF, 0xCC, 0x00, 0x30, 0x30, 0x78, 0x7B,
  0x00, 0x1C, 0x18, 0x38, 0x0E, 0xC0, 0x06, 0x0E, 0x1C, 0x01, 0xF8, 0x03,
  0x87, 0x0E, 0x00, 0x7E, 0x01, 0xC1, 0x83, 0x80, 0x1D, 0xC0, 0xE0, 0xE1,
  0xC0, 0x03, 0x3F, 0xF0, 0x70, 0x70, 0x00, 0xC7, 0xF8, 0x38, 0x18, 0x00,
  0x30, 0x20, 0x0C, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x07, 0x00,
  0x03, 0x80, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x70,
  0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x06,
  0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0, 0x38,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x06, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x1C, 0x00, 0x06, 0x1E,
  0x00, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x80, 0x38, 0x70, 0x00, 0x03, 0x80, 0x30,
  0x60, 0x00, 0x01, 0xC0, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x00,
  0x00, 0x61, 0xC0, 0xE0, 0x00, 0x00, 0x71, 0x80, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x70, 0x00, 0x00,
  0xE3, 0x80, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x3C, 0x00, 0x07, 0x81, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0x71, 0xC7, 0x18,
  0x63, 0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xF0, 0x03, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x1F, 0x03, 0x00,
  0x00, 0x78, 0x60, 0x00, 0x01, 0xE6, 0x00, 0x10, 0x07, 0xE1, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x1E, 0x00, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x23, 0xBF, 0xEF, 0x20, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xF8, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x60, 0x0F, 0x70,
  0x1E, 0x38, 0x1E, 0x18, 0x3C, 0x0C, 0x3C, 0x0E, 0x78, 0x07, 0x38, 0x03,
  0x88, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xF8, 0x01,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x1C, 0x0F, 0xFE, 0x00, 0x18, 0x3F, 0xFF, 0x80,
  0x38, 0xF8, 0x07, 0xC0, 0x39, 0xC0, 0x01, 0xE0, 0x3B, 0x80, 0x00, 0xE0,
  0x36, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x30, 0x7C, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x0F, 0x0C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x3E, 0x06, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x00, 0xEE, 0x03, 0x80, 0x01,
  0xCC, 0x01, 0xE0, 0x0F, 0x9C, 0x00, 0xFF, 0xFE, 0x1C, 0x00, 0x7F, 0xF8,
  0x18, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x70, 0x1F, 0x03, 0xC0, 0x78, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x18, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x1C, 0x70, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0x18, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xCE, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x33, 0x80, 0x07, 0x00,
  0x03, 0x00, 0x0C, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x70, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xD8, 0x00, 0x70, 0x00, 0x18, 0x00, 0x36, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x7C, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x1B, 0x00, 0x18, 0x00, 0x07, 0x00, 0x06, 0xC0,
  0x0E, 0x00, 0x01, 0x80, 0x03, 0xB0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xEC,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x73, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1C,
  0xC0, 0x0E, 0x00, 0x07, 0x80, 0x0E, 0x30, 0x01, 0x80, 0x03, 0x60, 0x03,
  0x8C, 0x00, 0x60, 0x01, 0xD8, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0xE6, 0x00,
  0xE0, 0xE0, 0x03, 0x80, 0x71, 0xC0, 0xF0, 0x38, 0x00, 0xFC, 0xF8, 0x3C,
  0xF8, 0x06, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xFC,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x04, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x30,
  0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x40, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xF1, 0x80, 0x00, 0x1F, 0xFF, 0xC3, 0x00, 0x00,
  0x3F, 0xFF, 0x86, 0x00, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x03, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x00,
  0x00, 0xC7, 0x70, 0x00, 0x00, 0x03, 0x9C, 0xE0, 0x00, 0x00, 0x07, 0x70,
  0xE0, 0x00, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x05, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0xEC, 0x00,
  0x00, 0x00, 0x1D, 0x80, 0x19, 0x80, 0x00, 0x00, 0x07, 0x70, 0x03, 0x30,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x66, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x1C,
  0xE0, 0x00, 0x00, 0x06, 0x30, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x38,
  0x03, 0x86, 0x00, 0x00, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x60,
  0xC0, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x01, 0x83, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x0E, 0x06, 0x00, 0x00,
  0x38, 0x18, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x38, 0x18, 0x00,
  0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0x80, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x18,
  0x03, 0x00, 0x03, 0x00, 0x70, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0xC0, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x01, 0x80,
  0x06, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x01, 0x80, 0x03, 0x03, 0x00, 0x07, 0x00, 0x70, 0x00, 0x60,
  0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x01,
  0xC7, 0x00, 0x07, 0x00, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xE0, 0x06, 0x00,
  0x03, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x0D, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x80, 0x00, 0x60,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x60, 0x06, 0x60, 0x00, 0x00, 0x18, 0x01, 0x9C, 0x00, 0x00,
  0x0E, 0x00, 0x67, 0x00, 0x00, 0x03, 0x80, 0x38, 0xE0, 0x00, 0x00, 0xC0,
  0x0E, 0x38, 0x00, 0x00, 0x30, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC1,
  0xC0, 0x00, 0x07, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x0E, 0x00,
  0x00, 0x60, 0x07, 0x03, 0x80, 0x00, 0x18, 0x01, 0x80, 0x60, 0x00, 0x0E,
  0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00,
  0x60, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x00, 0x18,
  0x07, 0x00, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x07, 0x00, 0x00, 0x38, 0x18, 0x01, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x60,
  0x00, 0x01, 0x83, 0x80, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x00,
  0x0C, 0x38, 0x03, 0x80, 0x00, 0x03, 0x8C, 0x00, 0xE0, 0x00, 0x00, 0xE3,
  0x00, 0x30, 0x00, 0x00, 0x19, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x70, 0x07,
  0x00, 0x00, 0x00, 0xD8, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01,
  0xF8, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x07,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x06, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x18, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x06, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x18, 0x01, 0x80, 0x07, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00,
  0x70, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xE0,
  0x00, 0x30, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03,
  0x38, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x70, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x01, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x00, 0x03, 0xFC, 0x03, 0x00, 0x0F, 0xFF, 0x07, 0x00, 0x3F, 0x07, 0x86,
  0x00, 0x78, 0x01, 0xC6, 0x00, 0xE0, 0x00, 0xC6, 0x01, 0xC0, 0x00, 0x6E,
  0x03, 0x80, 0x00, 0x6E, 0x07, 0x00, 0x00, 0x2C, 0x0F, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC0,
  0x60, 0x00, 0x06, 0xC0, 0x70, 0x00, 0x06, 0xC0, 0x70, 0x00, 0x0D, 0xC0,
  0x70, 0x00, 0x19, 0x80, 0x38, 0x00, 0x31, 0x80, 0x3C, 0x00, 0xE1, 0x80,
  0x1E, 0x03, 0xC1, 0x80, 0x0F, 0xFF, 0x83, 0x80, 0x07, 0xFE, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x7F, 0x80, 0x01, 0xC0,
  0xFF, 0xF0, 0x00, 0xE1, 0xF0, 0x7C, 0x00, 0x71, 0xC0, 0x0F, 0x00, 0x31,
  0xC0, 0x03, 0xC0, 0x19, 0xC0, 0x00, 0xE0, 0x1D, 0x80, 0x00, 0x38, 0x0F,
  0xC0, 0x00, 0x1C, 0x06, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x03,
  0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xB0, 0x00,
  0x0F, 0x01, 0x9C, 0x00, 0x0F, 0x00, 0xC7, 0x00, 0x0F, 0x00, 0x61, 0xC0,
  0x1F, 0x00, 0x70, 0x7F, 0xFE, 0x00, 0x30, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFC,
  0x0F, 0x00, 0x78, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x04, 0x01, 0xE0, 0x07, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x0F, 0xFF, 0x03,
  0x80, 0x03, 0xF0, 0x7C, 0x30, 0x00, 0x78, 0x00, 0xE3, 0x00, 0x0E, 0x00,
  0x06, 0x70, 0x01, 0xC0, 0x00, 0x37, 0x00, 0x38, 0x00, 0x03, 0x70, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x03, 0x60, 0x07, 0x00, 0x00,
  0x76, 0x00, 0x70, 0x00, 0x06, 0xE0, 0x07, 0x00, 0x00, 0xCC, 0x00, 0x38,
  0x00, 0x38, 0xC0, 0x03, 0xC0, 0x07, 0x0C, 0x00, 0x1E, 0x01, 0xE0, 0xC0,
  0x00, 0xFF, 0xFC, 0x1C, 0x00, 0x07, 0xFF, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC1, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0xC3, 0x80, 0x03, 0xE0, 0x60, 0x0F, 0xF8, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x04, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x06, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xC0, 0x01, 0xFF,
  0xF0, 0x30, 0x01, 0xF8, 0x3E, 0x18, 0x00, 0xF0, 0x01, 0xC6, 0x00, 0x70,
  0x00, 0x31, 0x80, 0x38, 0x00, 0x06, 0x60, 0x1C, 0x00, 0x01, 0xB8, 0x0E,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x06, 0xC0, 0x38, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x01, 0xDC,
  0x03, 0x80, 0x00, 0xE6, 0x00, 0x70, 0x00, 0x71, 0x80, 0x1E, 0x00, 0x38,
  0x60, 0x03, 0xC0, 0x3C, 0x38, 0x00, 0x7F, 0xFC, 0x0E, 0x00, 0x0F, 0xFE,
  0x03, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x02, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x1F, 0xE0,
  0x01, 0xC0, 0xFF, 0xF0, 0x03, 0x87, 0xC1, 0xF0, 0x06, 0x1E, 0x00, 0x70,
  0x0C, 0x70, 0x00, 0x70, 0x19, 0xC0, 0x00, 0xE0, 0x77, 0x00, 0x00, 0xC0,
  0xFC, 0x00, 0x01, 0x81, 0xB0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x06, 0x0F,
  0x00, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x87, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0xF0, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x18,
  0xCE, 0x00, 0x00, 0x37, 0x1C, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x01, 0xF0,
  0x38, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x38, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x06, 0x0F, 0x07,
  0x80, 0x7C, 0x3E, 0x00, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0x18, 0xC0,
  0x03, 0x07, 0x00, 0x1C, 0x03, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC0, 0xEC,
  0x00, 0x0E, 0x70, 0x00, 0x38, 0x1B, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x03,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x3F, 0xE0, 0x01, 0xC0, 0xFF, 0xF0, 0x01, 0x83, 0xF0, 0xFC, 0x01, 0x87,
  0x80, 0x3C, 0x01, 0x8E, 0x00, 0x0E, 0x03, 0x9C, 0x00, 0x0E, 0x03, 0xB8,
  0x00, 0x0E, 0x03, 0xF0, 0x00, 0x06, 0x03, 0x60, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x06, 0x07, 0xC0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3C, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x07, 0xF8, 0x00, 0x03, 0x81,
  0xFF, 0xE0, 0x00, 0x30, 0x7C, 0x1F, 0x00, 0x03, 0x0F, 0x00, 0x78, 0x00,
  0x31, 0xC0, 0x03, 0xC0, 0x03, 0x38, 0x00, 0x1C, 0x00, 0x77, 0x00, 0x00,
  0xE0, 0x06, 0xE0, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x06, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0E, 0xC0, 0x00, 0x3C,
  0x00, 0xEE, 0x00, 0x07, 0x80, 0x0C, 0x70, 0x00, 0xF0, 0x00, 0xC3, 0x80,
  0x3E, 0x00, 0x1C, 0x1F, 0xFF, 0x80, 0x01, 0xC0, 0xFF, 0xE0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x01, 0x80, 0x07, 0xFF, 0x80, 0xC0, 0x0F, 0xC1, 0xF0, 0xC0,
  0x0F, 0x00, 0x1C, 0x60, 0x0E, 0x00, 0x06, 0x30, 0x0E, 0x00, 0x01, 0x98,
  0x0E, 0x00, 0x00, 0xDC, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0x78, 0x0C, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x00, 0x7E, 0x03, 0x80,
  0x00, 0x37, 0x01, 0xC0, 0x00, 0x73, 0x00, 0x70, 0x00, 0x71, 0x80, 0x3C,
  0x00, 0x70, 0xC0, 0x0F, 0x00, 0xF0, 0xE0, 0x03, 0xFF, 0xF0, 0x70, 0x00,
  0xFF, 0xE0, 0x30, 0x00, 0x07, 0x80, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x3F, 0x80, 0xE0, 0x7F, 0xC0, 0x60, 0xFC, 0x40, 0x30, 0xE0, 0x00, 0x18,
  0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0x81,
  0xFC, 0x0F, 0x00, 0x06, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x7C, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x07, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x07, 0x83, 0x00, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00,
  0xD8, 0x18, 0x00, 0x03, 0x30, 0x38, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x39,
  0xC0, 0x70, 0x01, 0xE3, 0x00, 0xF0, 0x0F, 0x86, 0x00, 0xFF, 0xFC, 0x0C,
  0x00, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00,
  0x38, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x18, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x70, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x60, 0x00, 0x39, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0x38,
  0x00, 0x19, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x30, 0xE0, 0x00,
  0xC6, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0x83, 0x80, 0x06, 0x18,
  0x00, 0x70, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0x60, 0x03,
  0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0x81, 0xC0, 0x1C, 0x03,
  0x00, 0x70, 0x38, 0x03, 0x80, 0x60, 0x0C, 0x07, 0x00, 0xE0, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x1C, 0x01,
  0x80, 0xE0, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x06, 0x07,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC6,
  0x00, 0x0E, 0x30, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x30, 0x00,
  0x19, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x6E,
  0x00, 0x03, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x00, 0xC7, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x05, 0xF0, 0xFE, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x90, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 13, 49, 15, 2, -48 },
  { 81, 16, 17, 22, 7, -48 },
  { 115, 40, 48, 42, 2, -48 },
  { 355, 32, 55, 37, 3, -51 },
  { 575, 42, 50, 52, 6, -49 },
  { 838, 40, 50, 46, 3, -49 },
  { 1088, 6, 17, 12, 7, -48 },
  { 1101, 20, 59, 17, 2, -48 },
  { 1249, 19, 59, 17, -4, -48 },
  { 1390, 28, 29, 36, 8, -51 },
  { 1492, 31, 31, 38, 5, -39 },
  { 1613, 10, 17, 13, -3, -8 },
  { 1635, 16, 2, 21, 2, -19 },
  { 1639, 5, 6, 15, 2, -5 },
  { 1643, 30, 48, 21, -3, -48 },
  { 1823, 31, 50, 37, 4, -49 },
  { 2017, 17, 48, 37, 11, -48 },
  { 2119, 33, 49, 37, 1, -49 },
  { 2322, 34, 50, 37, 1, -49 },
  { 2535, 35, 48, 37, 1, -48 },
  { 2745, 33, 49, 37, 3, -48 },
  { 2948, 32, 50, 37, 4, -49 },
  { 3148, 31, 48, 37, 7, -48 },
  { 3334, 33, 50, 37, 3, -49 },
  { 3541, 32, 50, 37, 3, -49 },
  { 3741, 11, 37, 15, 2, -36 },
  { 3792, 16, 45, 15, -3, -36 },
  { 3882, 31, 31, 38, 5, -40 },
  { 4003, 31, 16, 38, 5, -32 },
  { 4065, 31, 31, 38, 5, -40 },
  { 4186, 24, 50, 27, 5, -49 },
  { 4336, 50, 53, 56, 4, -47 },
  { 4668, 37, 48, 37, -3, -48 },
  { 4890, 36, 48, 40, 3, -48 },
  { 5106, 37, 50, 40, 5, -49 },
  { 5338, 40, 48, 45, 3, -48 },
  { 5578, 34, 48, 36, 3, -48 },
  { 5782, 34, 48, 33, 3, -48 },
  { 5986, 39, 50, 46, 5, -49 },
  { 6230, 42, 48, 46, 3, -48 },
  { 6482, 22, 48, 19, 0, -48 },
  { 6614, 27, 60, 16, -11, -48 },
  { 6817, 39, 48, 37, 3, -48 },
  { 7051, 25, 48, 33, 3, -48 },
  { 7201, 51, 48, 54, 3, -48 },
  { 7507, 42, 48, 46, 3, -48 },
  { 7759, 41, 50, 48, 5, -49 },
  { 8016, 35, 48, 38, 3, -48 },
  { 8226, 41, 60, 48, 5, -49 },
  { 8534, 35, 48, 38, 3, -48 },
  { 8744, 33, 50, 33, 1, -49 },
  { 8951, 33, 48, 33, 6, -48 },
  { 9149, 40, 49, 46, 6, -48 },
  { 9394, 34, 48, 36, 7, -48 },
  { 9598, 52, 48, 56, 8, -48 },
  { 9910, 42, 48, 33, -4, -48 },
  { 10162, 33, 48, 33, 6, -48 },
  { 10360, 39, 48, 36, -1, -48 },
  { 10594, 26, 59, 20, -1, -48 },
  { 10786, 10, 48, 21, 7, -48 },
  { 10846, 26, 59, 20, -5, -48 },
  { 11038, 31, 30, 37, 3, -48 },
  { 11155, 26, 2, 25, -6, 7 },
  { 11162, 8, 10, 16, 10, -51 },
  { 11172, 32, 37, 37, 3, -36 },
  { 11320, 33, 52, 38, 2, -51 },
  { 11535, 27, 37, 30, 4, -36 },
  { 11660, 36, 52, 38, 3, -51 },
  { 11894, 27, 37, 33, 4, -36 },
  { 12019, 37, 67, 18, -9, -51 },
  { 12329, 34, 52, 38, 2, -36 },
  { 12550, 31, 51, 37, 2, -51 },
  { 12748, 13, 49, 15, 2, -49 },
  { 12828, 24, 65, 15, -9, -49 },
  { 13023, 31, 51, 30, 2, -51 },
  { 13221, 13, 51, 15, 2, -51 },
  { 13304, 51, 36, 57, 2, -36 },
  { 13534, 32, 36, 37, 2, -36 },
  { 13678, 30, 37, 38, 4, -36 },
  { 13817, 36, 52, 38, -1, -36 },
  { 14051, 33, 52, 38, 3, -36 },
  { 14266, 25, 36, 25, 2, -36 },
  { 14379, 26, 37, 28, 1, -36 },
  { 14500, 20, 45, 21, 3, -44 },
  { 14613, 31, 37, 37, 4, -36 },
  { 14757, 28, 36, 28, 3, -36 },
  { 14883, 43, 36, 45, 4, -36 },
  { 15077, 34, 36, 31, -2, -36 },
  { 15230, 38, 52, 28, -7, -36 },
  { 15477, 30, 36, 29, -1, -36 },
  { 15612, 24, 59, 22, 2, -48 },
  { 15789, 2, 67, 36, 19, -51 },
  { 15806, 24, 59, 22, -3, -48 },
  { 15983, 31, 7, 38, 5, -27 },
};

const GFXfont NotoSans_ExtraLightItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRALIGHTITALIC67PT7B_H_
