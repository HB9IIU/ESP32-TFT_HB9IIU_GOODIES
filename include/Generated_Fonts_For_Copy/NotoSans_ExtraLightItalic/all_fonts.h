#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraLightItalic
// Headers: 67

#include "NotoSans_ExtraLightItalic6pt7b.h"
#include "NotoSans_ExtraLightItalic7pt7b.h"
#include "NotoSans_ExtraLightItalic8pt7b.h"
#include "NotoSans_ExtraLightItalic9pt7b.h"
#include "NotoSans_ExtraLightItalic10pt7b.h"
#include "NotoSans_ExtraLightItalic11pt7b.h"
#include "NotoSans_ExtraLightItalic12pt7b.h"
#include "NotoSans_ExtraLightItalic13pt7b.h"
#include "NotoSans_ExtraLightItalic14pt7b.h"
#include "NotoSans_ExtraLightItalic15pt7b.h"
#include "NotoSans_ExtraLightItalic16pt7b.h"
#include "NotoSans_ExtraLightItalic17pt7b.h"
#include "NotoSans_ExtraLightItalic18pt7b.h"
#include "NotoSans_ExtraLightItalic19pt7b.h"
#include "NotoSans_ExtraLightItalic20pt7b.h"
#include "NotoSans_ExtraLightItalic21pt7b.h"
#include "NotoSans_ExtraLightItalic22pt7b.h"
#include "NotoSans_ExtraLightItalic23pt7b.h"
#include "NotoSans_ExtraLightItalic24pt7b.h"
#include "NotoSans_ExtraLightItalic25pt7b.h"
#include "NotoSans_ExtraLightItalic26pt7b.h"
#include "NotoSans_ExtraLightItalic27pt7b.h"
#include "NotoSans_ExtraLightItalic28pt7b.h"
#include "NotoSans_ExtraLightItalic29pt7b.h"
#include "NotoSans_ExtraLightItalic30pt7b.h"
#include "NotoSans_ExtraLightItalic31pt7b.h"
#include "NotoSans_ExtraLightItalic32pt7b.h"
#include "NotoSans_ExtraLightItalic33pt7b.h"
#include "NotoSans_ExtraLightItalic34pt7b.h"
#include "NotoSans_ExtraLightItalic35pt7b.h"
#include "NotoSans_ExtraLightItalic36pt7b.h"
#include "NotoSans_ExtraLightItalic37pt7b.h"
#include "NotoSans_ExtraLightItalic38pt7b.h"
#include "NotoSans_ExtraLightItalic39pt7b.h"
#include "NotoSans_ExtraLightItalic40pt7b.h"
#include "NotoSans_ExtraLightItalic41pt7b.h"
#include "NotoSans_ExtraLightItalic42pt7b.h"
#include "NotoSans_ExtraLightItalic43pt7b.h"
#include "NotoSans_ExtraLightItalic44pt7b.h"
#include "NotoSans_ExtraLightItalic45pt7b.h"
#include "NotoSans_ExtraLightItalic46pt7b.h"
#include "NotoSans_ExtraLightItalic47pt7b.h"
#include "NotoSans_ExtraLightItalic48pt7b.h"
#include "NotoSans_ExtraLightItalic49pt7b.h"
#include "NotoSans_ExtraLightItalic50pt7b.h"
#include "NotoSans_ExtraLightItalic51pt7b.h"
#include "NotoSans_ExtraLightItalic52pt7b.h"
#include "NotoSans_ExtraLightItalic53pt7b.h"
#include "NotoSans_ExtraLightItalic54pt7b.h"
#include "NotoSans_ExtraLightItalic55pt7b.h"
#include "NotoSans_ExtraLightItalic56pt7b.h"
#include "NotoSans_ExtraLightItalic57pt7b.h"
#include "NotoSans_ExtraLightItalic58pt7b.h"
#include "NotoSans_ExtraLightItalic59pt7b.h"
#include "NotoSans_ExtraLightItalic60pt7b.h"
#include "NotoSans_ExtraLightItalic61pt7b.h"
#include "NotoSans_ExtraLightItalic62pt7b.h"
#include "NotoSans_ExtraLightItalic63pt7b.h"
#include "NotoSans_ExtraLightItalic64pt7b.h"
#include "NotoSans_ExtraLightItalic65pt7b.h"
#include "NotoSans_ExtraLightItalic66pt7b.h"
#include "NotoSans_ExtraLightItalic67pt7b.h"
#include "NotoSans_ExtraLightItalic68pt7b.h"
#include "NotoSans_ExtraLightItalic69pt7b.h"
#include "NotoSans_ExtraLightItalic70pt7b.h"
#include "NotoSans_ExtraLightItalic71pt7b.h"
#include "NotoSans_ExtraLightItalic72pt7b.h"
