#ifndef _NOTOSANS_EXTRALIGHTITALIC53PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x38, 0x33, 0x03, 0x30, 0x33, 0x06, 0x30, 0x66, 0x06, 0x60, 0x66,
  0x04, 0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x88, 0x08, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x01, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xF1, 0x1F, 0x03,
  0xC3, 0x01, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0C,
  0x02, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x04, 0x00, 0x06, 0x04, 0x00, 0x07, 0x0C, 0x00, 0x03, 0xCC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1B, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x10, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x20, 0x18, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0xE0, 0xC0, 0x43, 0xC0, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0x01, 0xE7, 0x00, 0x01, 0x80, 0x60, 0x60, 0x00, 0xE0,
  0x30, 0x18, 0x00, 0x30, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x20, 0x18, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x60, 0x06, 0x06, 0x00, 0x18, 0x01, 0x83, 0x80, 0x04, 0x00,
  0x60, 0xC0, 0x03, 0x00, 0x30, 0x60, 0xF8, 0xC0, 0x0C, 0x30, 0xFF, 0x90,
  0x06, 0x1C, 0x70, 0x66, 0x01, 0x86, 0x38, 0x1D, 0x80, 0xC3, 0x0C, 0x03,
  0x70, 0x71, 0x86, 0x00, 0xCF, 0x78, 0xE1, 0x80, 0x31, 0xF8, 0x30, 0xC0,
  0x0C, 0x00, 0x18, 0x30, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x03, 0x06,
  0x00, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x60, 0x30, 0x00, 0x70, 0x30, 0x1C, 0x00, 0x0E, 0x38,
  0x0E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00, 0x19, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xE3, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x01, 0x80,
  0x07, 0x1C, 0x00, 0xC0, 0x06, 0x38, 0x00, 0x60, 0x0E, 0x30, 0x00, 0x60,
  0x0C, 0x60, 0x00, 0x30, 0x18, 0x60, 0x00, 0x18, 0x38, 0x60, 0x00, 0x1C,
  0x30, 0xC0, 0x00, 0x0C, 0x60, 0xC0, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x07, 0x80, 0x60, 0x00, 0x1C,
  0xC0, 0x70, 0x00, 0x38, 0xE0, 0x3C, 0x00, 0xF0, 0x60, 0x1F, 0x07, 0xC0,
  0x30, 0x07, 0xFF, 0x00, 0x38, 0x00, 0x40, 0x00, 0x00, 0x39, 0x8C, 0x63,
  0x31, 0x8C, 0x62, 0x31, 0x8C, 0x40, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x08, 0x03, 0x00, 0x3C, 0x06,
  0x00, 0x1E, 0x0C, 0x00, 0x0E, 0x10, 0x00, 0x07, 0x20, 0x04, 0x03, 0xCF,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0xE2, 0x00,
  0x03, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x18, 0x00,
  0x80, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x0C, 0x38, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1,
  0x86, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x5F, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x00, 0xC0,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x0C, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x38, 0x00, 0x03, 0x1C,
  0x00, 0x01, 0x8E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x70, 0x00, 0xF1, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x07, 0x60, 0xF3, 0x0E, 0x19, 0xE0,
  0xDC, 0x0C, 0xC0, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xF0,
  0x0E, 0x00, 0x78, 0x00, 0x60, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x0E, 0x01, 0xE0,
  0x00, 0xE0, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x40, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x82, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x78, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0E,
  0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x1C,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x08,
  0x00, 0x07, 0x03, 0x80, 0x07, 0x80, 0xFE, 0x1F, 0x80, 0x0F, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xF3, 0xC0, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0xFF, 0x00, 0x61, 0xF7, 0xE0, 0x33, 0x80, 0x38,
  0x1B, 0x00, 0x0E, 0x1B, 0x00, 0x03, 0x0F, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x30,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x70, 0x01, 0xF1, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x06, 0x00, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE7, 0x00, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x0F, 0xC7, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x83, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0xD8, 0x38, 0x00, 0x7E,
  0x07, 0x00, 0x3B, 0x00, 0xF0, 0x78, 0xC0, 0x0F, 0xF8, 0x30, 0x00, 0x20,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x07, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xE0, 0xE0, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x60, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x0F, 0xE0, 0x06, 0x18, 0x00, 0x7F, 0xFC, 0x03, 0x18, 0x00, 0xE0,
  0x18, 0x03, 0x30, 0x03, 0x80, 0x18, 0x03, 0x30, 0x07, 0x00, 0x18, 0x03,
  0x60, 0x06, 0x00, 0x10, 0x03, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x60, 0x0C,
  0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0x60,
  0x03, 0xC0, 0x30, 0x00, 0x60, 0x06, 0xC0, 0x30, 0x00, 0x60, 0x06, 0xC0,
  0x30, 0x00, 0x60, 0x06, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0xC0, 0x30, 0x00,
  0xC0, 0x0C, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0xC0, 0x30, 0x03, 0xC0, 0x18,
  0xC0, 0x38, 0x06, 0x40, 0x30, 0xC0, 0x18, 0x0C, 0x60, 0xE0, 0x60, 0x0F,
  0x78, 0x7B, 0xC0, 0x60, 0x07, 0xF0, 0x3F, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x01,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xC0, 0x00,
  0x30, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x70, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0x80, 0x07,
  0xC0, 0x18, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xC0, 0x03, 0xC0,
  0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xE0, 0x01, 0x80, 0x1E, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xF1, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x06, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xCE, 0x00, 0x07,
  0xFF, 0x9C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x78,
  0x00, 0x00, 0x19, 0xF0, 0x00, 0x00, 0x37, 0x70, 0x00, 0x00, 0xFC, 0x60,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x36, 0x03, 0x60, 0x00, 0x00,
  0x76, 0x03, 0x30, 0x00, 0x00, 0x6E, 0x03, 0x30, 0x00, 0x00, 0xEC, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x06, 0x30, 0x00, 0x03, 0x1C, 0x06, 0x18, 0x00, 0x07, 0x18,
  0x06, 0x18, 0x00, 0x06, 0x18, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x0C, 0x18, 0x00, 0x38,
  0x30, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x01,
  0xC0, 0x60, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x06, 0x03, 0x00, 0xE0, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x1C, 0x00,
  0xC0, 0x60, 0x03, 0x18, 0x01, 0xC0, 0x60, 0x03, 0x30, 0x01, 0x80, 0x60,
  0x03, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x60, 0x01, 0x80, 0xC0, 0x03, 0xE0,
  0x01, 0x80, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x60, 0x1E, 0x00,
  0x00, 0x30, 0x1B, 0x80, 0x00, 0x18, 0x0C, 0xC0, 0x00, 0x0C, 0x06, 0x60,
  0x00, 0x0C, 0x03, 0x18, 0x00, 0x06, 0x01, 0x8C, 0x00, 0x03, 0x01, 0x83,
  0x00, 0x01, 0x80, 0xC1, 0x80, 0x01, 0xC0, 0x60, 0xE0, 0x00, 0xC0, 0x30,
  0x30, 0x00, 0x60, 0x18, 0x18, 0x00, 0x30, 0x18, 0x06, 0x00, 0x18, 0x0C,
  0x03, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03,
  0x80, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80,
  0x60, 0x01, 0x80, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x30, 0x00, 0x70, 0x30,
  0x18, 0x00, 0x18, 0x38, 0x0C, 0x00, 0x0C, 0x18, 0x06, 0x00, 0x03, 0x0C,
  0x03, 0x00, 0x01, 0x86, 0x03, 0x00, 0x00, 0x63, 0x01, 0x80, 0x00, 0x33,
  0x80, 0xC0, 0x00, 0x19, 0x80, 0x60, 0x00, 0x06, 0xC0, 0x70, 0x00, 0x03,
  0x60, 0x30, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x06, 0x00, 0x7C, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0E, 0x00,
  0x1E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x06, 0x00, 0x7C, 0x00, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x01, 0xE0,
  0x30, 0x00, 0x70, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x30, 0x07,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x07, 0x80, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x64, 0x00, 0x01, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x50, 0x00, 0x0C, 0x60, 0x00, 0x34, 0x00, 0x03, 0x18, 0x00,
  0x0D, 0x80, 0x01, 0x86, 0x00, 0x06, 0x60, 0x00, 0x61, 0x80, 0x01, 0x98,
  0x00, 0x30, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0x31, 0x80, 0x07,
  0x06, 0x00, 0x18, 0x60, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0xE0, 0x60,
  0x03, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x01, 0x80, 0x18, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0x60, 0x38, 0x02, 0x03, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x30, 0x00, 0x81, 0x80, 0x0C,
  0x18, 0x00, 0x30, 0xE0, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x40, 0x00,
  0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x30, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x07,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18,
  0x00, 0x04, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x02, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xC3, 0x06, 0x18, 0x30, 0x61, 0x83, 0x04,
  0x00, 0x06, 0x00, 0x80, 0x3F, 0xE0, 0x80, 0x7C, 0x38, 0xC0, 0x70, 0x06,
  0x60, 0x70, 0x01, 0x30, 0x70, 0x00, 0xD8, 0x70, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x03, 0xC1,
  0x80, 0x03, 0x60, 0xE0, 0x03, 0x30, 0x30, 0x03, 0x10, 0x1C, 0x03, 0x18,
  0x07, 0x8F, 0x0C, 0x01, 0xFF, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x70, 0x7F, 0x80, 0x30, 0xF0, 0xF0, 0x18, 0xC0, 0x1C, 0x0C, 0xC0, 0x06,
  0x06, 0xC0, 0x03, 0x86, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0x61, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x1E, 0x00, 0x07, 0x0B,
  0x00, 0x07, 0x0C, 0xC0, 0x07, 0x06, 0x70, 0x07, 0x03, 0x1F, 0x1F, 0x01,
  0x03, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xC0, 0x7C, 0x1E, 0x07, 0x00, 0x10, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0x00, 0x20, 0x1F, 0x1F, 0x00, 0x7F, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x7F, 0xC1, 0x80,
  0x1F, 0x0F, 0x18, 0x03, 0x80, 0x39, 0x80, 0x70, 0x01, 0x98, 0x0E, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0xD8, 0x0E, 0x00, 0x19, 0x00, 0x60, 0x03, 0x30, 0x07,
  0x00, 0xE3, 0x00, 0x3C, 0x3C, 0x30, 0x01, 0xFF, 0x02, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x3C, 0x07, 0x80,
  0x70, 0x70, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xC6, 0x00, 0x3C,
  0x30, 0x1F, 0xC3, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x30, 0x1F, 0x0F, 0x80, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC6, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFE, 0x04, 0x01, 0xF0, 0xF1, 0x80,
  0x70, 0x07, 0x30, 0x1C, 0x00, 0x66, 0x07, 0x00, 0x06, 0x81, 0xC0, 0x00,
  0xF0, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x01, 0xB0, 0x38, 0x00,
  0x6C, 0x03, 0x00, 0x19, 0x80, 0x70, 0x0E, 0x30, 0x07, 0x87, 0x86, 0x00,
  0x7F, 0xC1, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0xE0,
  0x07, 0xC0, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x07,
  0x07, 0xFC, 0x06, 0x1E, 0x1E, 0x06, 0x30, 0x07, 0x06, 0x60, 0x03, 0x06,
  0xC0, 0x03, 0x0D, 0x80, 0x03, 0x0F, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0x01,
  0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x8F, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x18, 0x70,
  0x00, 0x18, 0xE0, 0x00, 0x19, 0xF0, 0x00, 0x33, 0x30, 0x00, 0x36, 0x38,
  0x00, 0x3C, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0xE0, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x0F, 0xF0, 0x07,
  0xF8, 0x06, 0x3C, 0x78, 0x1E, 0x3C, 0x06, 0x70, 0x1C, 0x38, 0x0E, 0x06,
  0xC0, 0x0C, 0x60, 0x06, 0x04, 0x80, 0x0C, 0xC0, 0x03, 0x0D, 0x80, 0x06,
  0x80, 0x03, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x03, 0x03, 0xFE, 0x01, 0x87,
  0x8F, 0x80, 0xC6, 0x00, 0xE0, 0x66, 0x00, 0x30, 0x36, 0x00, 0x18, 0x36,
  0x00, 0x0C, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38,
  0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0xF8, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x07, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x70, 0x30, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x1F, 0x0F, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x0F, 0xF0,
  0x00, 0xC3, 0xC3, 0xC0, 0x0C, 0x60, 0x0E, 0x00, 0xCC, 0x00, 0x60, 0x09,
  0x80, 0x07, 0x01, 0xB0, 0x00, 0x30, 0x1E, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0x80, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0x98, 0x00, 0xE0,
  0x19, 0xC0, 0x1C, 0x01, 0x8F, 0x8F, 0x80, 0x18, 0x3F, 0xE0, 0x01, 0x80,
  0x40, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x40,
  0x7C, 0x3C, 0x60, 0x70, 0x07, 0x30, 0x70, 0x01, 0x98, 0x70, 0x00, 0x68,
  0x70, 0x00, 0x3C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x86, 0x00,
  0x03, 0xC3, 0x00, 0x01, 0xE1, 0x80, 0x01, 0xB0, 0xE0, 0x01, 0xB0, 0x30,
  0x01, 0x98, 0x1C, 0x03, 0x8C, 0x07, 0x87, 0x86, 0x01, 0xFF, 0x07, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x80, 0xC1, 0xFC, 0x18, 0x79, 0x83, 0x18, 0x00,
  0x66, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0xFE, 0x07, 0xC1, 0xF0, 0xE0, 0x01, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x88, 0x00, 0x30, 0xC0, 0x07, 0x0F, 0x83, 0xE0, 0x3F, 0xF8, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE3, 0x01, 0xFE, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x06, 0x00, 0x07, 0x83, 0x00, 0x02, 0xC1, 0x80, 0x03,
  0x60, 0xE0, 0x07, 0x30, 0x38, 0x07, 0x30, 0x1F, 0x1E, 0x18, 0x03, 0xFE,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x86, 0x00, 0x0C,
  0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18,
  0x01, 0x80, 0x20, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x06,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x04, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x1B, 0x00,
  0x0F, 0x00, 0x0C, 0xC0, 0x03, 0xC0, 0x03, 0x30, 0x01, 0xB0, 0x01, 0x8C,
  0x00, 0x64, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x06, 0x04, 0x01, 0x86, 0x01, 0x81, 0x80, 0xC1, 0x80,
  0xC0, 0x60, 0x30, 0x60, 0x30, 0x18, 0x18, 0x18, 0x1C, 0x06, 0x06, 0x06,
  0x06, 0x01, 0x83, 0x01, 0x83, 0x80, 0x61, 0xC0, 0x60, 0xC0, 0x18, 0x60,
  0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xF8, 0x01, 0xE0,
  0x1E, 0x07, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraLightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 38, 12, 2, -38 },
  { 49, 12, 14, 17, 6, -38 },
  { 70, 31, 38, 33, 2, -38 },
  { 218, 24, 43, 29, 3, -40 },
  { 347, 34, 39, 41, 4, -38 },
  { 513, 32, 39, 36, 2, -38 },
  { 669, 5, 14, 10, 6, -38 },
  { 678, 15, 46, 13, 2, -38 },
  { 765, 16, 46, 13, -4, -38 },
  { 857, 23, 23, 28, 6, -40 },
  { 924, 24, 25, 30, 4, -31 },
  { 999, 7, 13, 11, -2, -6 },
  { 1011, 13, 2, 17, 2, -15 },
  { 1015, 3, 4, 12, 2, -4 },
  { 1017, 23, 38, 17, -2, -38 },
  { 1127, 25, 39, 29, 3, -38 },
  { 1249, 13, 38, 29, 9, -38 },
  { 1311, 27, 38, 29, 0, -38 },
  { 1440, 27, 39, 29, 1, -38 },
  { 1572, 27, 38, 29, 1, -38 },
  { 1701, 26, 39, 29, 2, -38 },
  { 1828, 25, 39, 29, 4, -38 },
  { 1950, 24, 38, 29, 6, -38 },
  { 2064, 26, 39, 29, 2, -38 },
  { 2191, 26, 39, 29, 2, -38 },
  { 2318, 8, 28, 12, 2, -28 },
  { 2346, 12, 35, 12, -2, -28 },
  { 2399, 24, 24, 30, 4, -31 },
  { 2471, 24, 13, 30, 4, -25 },
  { 2510, 24, 24, 30, 4, -31 },
  { 2582, 19, 38, 22, 4, -38 },
  { 2673, 40, 42, 44, 3, -37 },
  { 2883, 30, 38, 29, -3, -38 },
  { 3026, 28, 38, 32, 3, -38 },
  { 3159, 30, 39, 31, 4, -38 },
  { 3306, 31, 38, 36, 3, -38 },
  { 3454, 27, 38, 28, 3, -38 },
  { 3583, 27, 38, 26, 3, -38 },
  { 3712, 31, 39, 36, 4, -38 },
  { 3864, 33, 38, 36, 3, -38 },
  { 4021, 17, 38, 15, 0, -38 },
  { 4102, 22, 47, 13, -9, -38 },
  { 4232, 31, 38, 29, 3, -38 },
  { 4380, 19, 38, 26, 3, -38 },
  { 4471, 40, 38, 43, 3, -38 },
  { 4661, 33, 38, 36, 3, -38 },
  { 4818, 32, 39, 38, 4, -38 },
  { 4974, 27, 38, 30, 3, -38 },
  { 5103, 32, 47, 38, 4, -38 },
  { 5291, 27, 38, 30, 3, -38 },
  { 5420, 26, 39, 26, 1, -38 },
  { 5547, 26, 38, 26, 5, -38 },
  { 5671, 32, 39, 37, 5, -38 },
  { 5827, 28, 38, 29, 5, -38 },
  { 5960, 42, 38, 44, 6, -38 },
  { 6160, 33, 38, 26, -3, -38 },
  { 6317, 26, 38, 26, 5, -38 },
  { 6441, 30, 38, 28, 0, -38 },
  { 6584, 20, 46, 16, 0, -38 },
  { 6699, 9, 38, 17, 5, -38 },
  { 6742, 20, 46, 16, -4, -38 },
  { 6857, 24, 23, 29, 3, -38 },
  { 6926, 21, 1, 20, -5, 6 },
  { 6929, 6, 9, 13, 8, -41 },
  { 6936, 25, 30, 29, 3, -29 },
  { 7030, 25, 41, 30, 2, -40 },
  { 7159, 21, 30, 24, 3, -29 },
  { 7238, 28, 41, 30, 3, -40 },
  { 7382, 21, 30, 26, 3, -29 },
  { 7461, 29, 54, 15, -7, -41 },
  { 7657, 27, 42, 30, 1, -29 },
  { 7799, 24, 40, 30, 2, -40 },
  { 7919, 10, 38, 12, 2, -38 },
  { 7967, 19, 51, 12, -7, -38 },
  { 8089, 24, 40, 24, 2, -40 },
  { 8209, 10, 40, 12, 2, -40 },
  { 8259, 40, 29, 45, 2, -29 },
  { 8404, 25, 29, 30, 2, -29 },
  { 8495, 24, 30, 30, 3, -29 },
  { 8585, 28, 41, 30, -1, -29 },
  { 8729, 25, 41, 30, 3, -29 },
  { 8858, 19, 29, 20, 2, -29 },
  { 8927, 20, 30, 23, 1, -29 },
  { 9002, 15, 36, 17, 3, -35 },
  { 9070, 25, 29, 30, 3, -28 },
  { 9161, 22, 28, 22, 3, -28 },
  { 9238, 34, 28, 35, 3, -28 },
  { 9357, 27, 28, 24, -2, -28 },
  { 9452, 31, 41, 22, -6, -28 },
  { 9611, 24, 28, 23, -1, -28 },
  { 9695, 19, 46, 18, 1, -38 },
  { 9805, 2, 53, 29, 15, -40 },
  { 9819, 19, 46, 18, -2, -38 },
  { 9929, 24, 5, 30, 4, -21 },
};

const GFXfont NotoSans_ExtraLightItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRALIGHTITALIC53PT7B_H_
