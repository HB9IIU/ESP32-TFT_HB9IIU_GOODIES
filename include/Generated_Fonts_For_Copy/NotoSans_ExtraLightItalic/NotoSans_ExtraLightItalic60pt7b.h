#ifndef _NOTOSANS_EXTRALIGHTITALIC60PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x04, 0x00, 0x38, 0x1C, 0xE0, 0x63, 0x01,
  0x8C, 0x06, 0x30, 0x39, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x81,
  0x84, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x0C, 0x0C, 0x20, 0x30, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0x86, 0x0F, 0x01, 0xE0, 0x60, 0x20, 0x3C, 0x0C, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x70, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x01,
  0xE3, 0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x67, 0x80, 0x00, 0x06, 0x1E, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x01,
  0x81, 0xC0, 0xC0, 0x30, 0x78, 0x0F, 0xC3, 0x1F, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x70,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x60, 0x03, 0x80, 0x06, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x00, 0x1C,
  0x18, 0x1F, 0x8C, 0x00, 0x60, 0xE1, 0xFF, 0x30, 0x01, 0x87, 0x0E, 0x0E,
  0xC0, 0x0C, 0x18, 0x70, 0x1B, 0x80, 0x70, 0xC3, 0x80, 0x76, 0x01, 0x87,
  0x0C, 0x00, 0xDC, 0x0C, 0x18, 0x70, 0x03, 0x3F, 0xE0, 0xC1, 0x80, 0x0C,
  0x7F, 0x06, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0xC0, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x60, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x18,
  0x01, 0x80, 0x70, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x70, 0x00, 0x0F, 0x3C, 0x03, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x61, 0xC0, 0x1C, 0x00, 0x1C,
  0x70, 0x01, 0xC0, 0x03, 0x1C, 0x00, 0x18, 0x00, 0xE7, 0x00, 0x01, 0x80,
  0x18, 0xC0, 0x00, 0x38, 0x07, 0x38, 0x00, 0x03, 0x80, 0xC6, 0x00, 0x00,
  0x30, 0x30, 0xC0, 0x00, 0x07, 0x0E, 0x18, 0x00, 0x00, 0x73, 0x83, 0x00,
  0x00, 0x06, 0xE0, 0x60, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x00, 0xEC, 0x03, 0x80, 0x00, 0x78,
  0xC0, 0x78, 0x00, 0x1C, 0x1C, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x7F, 0xFF,
  0x80, 0x18, 0x03, 0xFF, 0xC0, 0x03, 0x80, 0x0E, 0x80, 0x00, 0x00, 0x39,
  0xCC, 0x63, 0x39, 0x8C, 0x63, 0x11, 0x8C, 0x63, 0x10, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0xF0, 0x08, 0x00, 0x3E, 0x0C, 0x00, 0x07, 0x86, 0x00, 0x00, 0x73,
  0x00, 0x20, 0x0F, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x00, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E,
  0x06, 0x07, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x6F, 0xFE, 0x40,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x60,
  0x3C, 0xC0, 0xE3, 0x87, 0x87, 0x1C, 0x0C, 0xF0, 0x19, 0x80, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xE0, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x1E,
  0x00, 0x01, 0xC0, 0x10, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0x80,
  0x02, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x0F, 0xFC, 0x00, 0x61, 0xFF, 0xF8, 0x03, 0x1C, 0x01, 0xE0, 0x39, 0x80,
  0x03, 0x81, 0xD8, 0x00, 0x0C, 0x0D, 0x80, 0x00, 0x70, 0x78, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x80, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x07, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x40, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x0C,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x36, 0x07, 0x00, 0x0E, 0x60, 0x78, 0x01,
  0xCE, 0x03, 0xF3, 0xF8, 0xC0, 0x0F, 0xFE, 0x0C, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x0F, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3C,
  0x0F, 0x03, 0x80, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0x00, 0x70, 0x40, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0xFF, 0x80, 0x18, 0x30, 0x00, 0x7F, 0x7F, 0x00, 0x61,
  0xC0, 0x03, 0xC0, 0x1C, 0x01, 0x86, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x1C, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x73, 0x00,
  0x38, 0x00, 0x30, 0x01, 0xDC, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x19, 0x80, 0x18, 0x00, 0x1C, 0x00, 0x66, 0x00, 0xE0,
  0x00, 0x60, 0x01, 0x98, 0x03, 0x00, 0x01, 0x80, 0x06, 0xE0, 0x0C, 0x00,
  0x06, 0x00, 0x3B, 0x80, 0x30, 0x00, 0x38, 0x00, 0xCE, 0x00, 0xC0, 0x00,
  0xC0, 0x03, 0x38, 0x03, 0x00, 0x07, 0x00, 0x1C, 0xE0, 0x0C, 0x00, 0x1C,
  0x00, 0x63, 0x80, 0x30, 0x00, 0xF0, 0x03, 0x8E, 0x00, 0xC0, 0x06, 0xC0,
  0x1C, 0x18, 0x03, 0x80, 0x3B, 0x00, 0xE0, 0x60, 0x07, 0x01, 0xCE, 0x07,
  0x01, 0x80, 0x1F, 0x3E, 0x1E, 0xF8, 0x07, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x20, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0x80, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x01, 0xE0,
  0x01, 0x80, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x18, 0x00, 0x03, 0xE0, 0x03, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x60, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xC6, 0x00, 0x01, 0xFF,
  0xF8, 0xC0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x00, 0x30, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x18, 0x78, 0x00, 0x00, 0x03,
  0x1F, 0x00, 0x00, 0x00, 0x67, 0x70, 0x00, 0x00, 0x1D, 0xC6, 0x00, 0x00,
  0x03, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x36, 0x00, 0x00, 0x00, 0x36, 0x00, 0xD8, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x0D, 0x80, 0x00, 0x00, 0x3B,
  0x00, 0x77, 0x00, 0x00, 0x00, 0xCC, 0x01, 0x9C, 0x00, 0x00, 0x06, 0x70,
  0x06, 0x30, 0x00, 0x00, 0x39, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x00, 0x07, 0x18, 0x03, 0x8C, 0x00, 0x00, 0x18, 0x60, 0x0C,
  0x38, 0x00, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x30, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x1C, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x1C, 0x01, 0x81, 0xC0,
  0x00, 0xE0, 0x70, 0x06, 0x07, 0x00, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x00,
  0x1C, 0x06, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0xE0, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x70, 0x07, 0x00, 0x60, 0x06, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x70, 0x01, 0x80,
  0x30, 0x01, 0xC1, 0x80, 0x0E, 0x00, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x03,
  0x00, 0x0C, 0x30, 0x00, 0xC0, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x00, 0x70,
  0x00, 0xC6, 0x00, 0x0C, 0x01, 0x80, 0x03, 0xB0, 0x00, 0x70, 0x06, 0x00,
  0x0F, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1E, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x06, 0x00,
  0xF8, 0x00, 0x00, 0x38, 0x03, 0x60, 0x00, 0x00, 0xE0, 0x0D, 0xC0, 0x00,
  0x03, 0x00, 0x73, 0x00, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x06,
  0x38, 0x00, 0x01, 0xC0, 0x18, 0x60, 0x00, 0x07, 0x00, 0x61, 0xC0, 0x00,
  0x18, 0x03, 0x83, 0x00, 0x00, 0x60, 0x0C, 0x0E, 0x00, 0x01, 0x80, 0x30,
  0x18, 0x00, 0x0E, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x00,
  0xC0, 0x1C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x01, 0x80,
  0x18, 0x00, 0x70, 0x06, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0x18, 0x03, 0x80, 0x30, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x30,
  0x07, 0x00, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x60, 0x00,
  0x18, 0x18, 0x01, 0x80, 0x00, 0x70, 0x60, 0x0E, 0x00, 0x00, 0xC1, 0x80,
  0x30, 0x00, 0x03, 0x86, 0x00, 0xC0, 0x00, 0x06, 0x38, 0x03, 0x00, 0x00,
  0x18, 0xC0, 0x1C, 0x00, 0x00, 0x73, 0x00, 0x70, 0x00, 0x00, 0xCC, 0x01,
  0x80, 0x00, 0x03, 0xB0, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x07, 0x80, 0x0C, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xB0, 0x00, 0x07,
  0x18, 0x00, 0x03, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x38,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC1,
  0x80, 0x00, 0xC7, 0x00, 0x03, 0x03, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0x60,
  0x01, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x38, 0x03, 0x00, 0x38, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x1C, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x60, 0x18, 0x00, 0x70, 0x18,
  0x00, 0xC0, 0x30, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xC0,
  0x03, 0x81, 0x80, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x31, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCE, 0x00, 0x01,
  0x98, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC1, 0xC1, 0x83, 0x83, 0x03, 0x07, 0x06, 0x06, 0x04, 0x00, 0x1F, 0xF0,
  0x30, 0x07, 0xFF, 0x83, 0x00, 0xF0, 0x1C, 0x30, 0x1C, 0x00, 0x66, 0x03,
  0x80, 0x03, 0x60, 0x70, 0x00, 0x36, 0x0E, 0x00, 0x01, 0x60, 0xC0, 0x00,
  0x1E, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E,
  0x0E, 0x00, 0x03, 0x60, 0x60, 0x00, 0x66, 0x07, 0x00, 0x0C, 0xC0, 0x30,
  0x01, 0x8C, 0x03, 0xC0, 0x70, 0xC0, 0x1F, 0xFE, 0x0C, 0x00, 0xFF, 0x80,
  0xC0, 0x00, 0x80, 0x10, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x07, 0xFC, 0x00,
  0x70, 0xFF, 0xF0, 0x03, 0x0E, 0x01, 0xC0, 0x18, 0xE0, 0x07, 0x00, 0xCC,
  0x00, 0x1C, 0x0E, 0xC0, 0x00, 0x60, 0x6C, 0x00, 0x03, 0x03, 0x40, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x07, 0x0D, 0x00, 0x00, 0x70, 0x6C, 0x00, 0x07, 0x03, 0x60, 0x00,
  0x70, 0x19, 0x80, 0x07, 0x81, 0x86, 0x00, 0xF0, 0x0C, 0x3F, 0xFF, 0x00,
  0x60, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x3C, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x1F, 0xF8, 0x18, 0x00, 0x7F, 0xFC, 0x18, 0x00, 0xF0, 0x0E, 0x38,
  0x01, 0xC0, 0x03, 0x30, 0x03, 0x80, 0x01, 0xB0, 0x07, 0x00, 0x01, 0xB0,
  0x0E, 0x00, 0x00, 0xB0, 0x0C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x1B, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x36, 0x00,
  0x70, 0x00, 0x66, 0x00, 0x30, 0x01, 0xC6, 0x00, 0x3C, 0x03, 0x86, 0x00,
  0x1F, 0xFF, 0x06, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x1C, 0x03, 0xC0, 0x0E,
  0x07, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x1C,
  0x60, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x10, 0x1E, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x0C, 0x00, 0xFF, 0xF8, 0x30, 0x07, 0x80, 0x70, 0xC0, 0x38,
  0x00, 0x66, 0x01, 0xC0, 0x00, 0xD8, 0x0E, 0x00, 0x03, 0x60, 0x70, 0x00,
  0x05, 0x81, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0F, 0x06, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0D, 0x81, 0xC0, 0x00, 0x36,
  0x03, 0x00, 0x01, 0xB8, 0x0E, 0x00, 0x0C, 0xC0, 0x18, 0x00, 0xE3, 0x00,
  0x78, 0x07, 0x0C, 0x00, 0xFF, 0xF8, 0x70, 0x01, 0xFF, 0x81, 0x80, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x08, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x81, 0xFF, 0x00, 0x38, 0x7F, 0xFC,
  0x03, 0x0E, 0x01, 0xE0, 0x31, 0xC0, 0x0E, 0x03, 0x30, 0x00, 0x70, 0x76,
  0x00, 0x07, 0x06, 0xC0, 0x00, 0x70, 0x68, 0x00, 0x03, 0x07, 0x80, 0x00,
  0x30, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03,
  0x80, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x30, 0x0C, 0x00,
  0x0E, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0xC7, 0x80, 0x00, 0x39, 0xF0, 0x00, 0x06, 0x77, 0x00, 0x00,
  0xDC, 0x60, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x18, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xC7, 0x81, 0xE0, 0xF0, 0x1C, 0x06, 0x70, 0x07, 0x0E, 0x00, 0x70, 0x33,
  0x00, 0x18, 0xE0, 0x03, 0x83, 0xB0, 0x00, 0xE6, 0x00, 0x0C, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x60, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38,
  0x00, 0x06, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x70, 0x00, 0x06, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x01, 0x81, 0xFF, 0x00, 0x30, 0x7F, 0xFC, 0x03, 0x0F, 0x01, 0xE0, 0x31,
  0xC0, 0x0E, 0x03, 0x30, 0x00, 0x70, 0x76, 0x00, 0x07, 0x06, 0xC0, 0x00,
  0x70, 0x68, 0x00, 0x03, 0x07, 0x80, 0x00, 0x30, 0x70, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x3F, 0xE0, 0x00, 0x60, 0xFF, 0xF0, 0x00, 0x61, 0xC0, 0x38,
  0x00, 0x63, 0x80, 0x1C, 0x00, 0x66, 0x00, 0x0E, 0x00, 0xEC, 0x00, 0x06,
  0x00, 0xD8, 0x00, 0x06, 0x00, 0xD0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x38, 0x0D, 0x00, 0x00, 0x70, 0x0D, 0x80, 0x00, 0xE0,
  0x0D, 0x80, 0x01, 0xC0, 0x0C, 0xC0, 0x03, 0xC0, 0x1C, 0x60, 0x0F, 0x00,
  0x18, 0x3F, 0xFE, 0x00, 0x18, 0x1F, 0xF8, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x18, 0x03, 0xFF, 0xE0, 0xC0,
  0x3C, 0x03, 0x86, 0x03, 0x80, 0x06, 0x60, 0x38, 0x00, 0x13, 0x03, 0x80,
  0x00, 0xD8, 0x38, 0x00, 0x02, 0xC1, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0xC3,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1B, 0x07, 0x00,
  0x00, 0xD8, 0x18, 0x00, 0x0D, 0xC0, 0xE0, 0x00, 0xCC, 0x03, 0x00, 0x1C,
  0x60, 0x1E, 0x01, 0xC3, 0x00, 0x7F, 0xFC, 0x38, 0x01, 0xFF, 0x81, 0x80,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x81, 0xFC, 0x0C, 0x1F, 0xF0, 0x30, 0xE0, 0x00,
  0xC7, 0x00, 0x03, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xA0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xFC, 0x0F, 0x00, 0x38, 0x38, 0x00, 0x10, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x08, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0x60, 0xE0, 0x00, 0x66, 0x06, 0x00, 0x0E, 0x60,
  0x70, 0x01, 0xCC, 0x07, 0x80, 0x78, 0xC0, 0x3F, 0xFE, 0x0C, 0x00, 0xFF,
  0xC0, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x38, 0x00,
  0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x0E, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x38, 0x07, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xC0, 0x00, 0xC6, 0x00, 0x0D, 0x80, 0x03, 0x8C, 0x00,
  0x1B, 0x00, 0x06, 0x18, 0x00, 0x66, 0x00, 0x1C, 0x30, 0x00, 0xCC, 0x00,
  0x30, 0x60, 0x03, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x30, 0x01, 0x81, 0x80,
  0x18, 0x70, 0x03, 0x03, 0x00, 0x30, 0xE0, 0x0C, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x0C, 0x01, 0x81, 0x80, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x06, 0x03, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0xE0, 0x60, 0x18,
  0x1C, 0x01, 0xC1, 0x80, 0x30, 0x30, 0x03, 0x83, 0x00, 0x60, 0xE0, 0x07,
  0x0C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x27, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13,
  0xFF, 0xC0, 0x01, 0x78, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x1E, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 44, 13, 2, -43 },
  { 67, 14, 16, 20, 7, -43 },
  { 95, 36, 43, 37, 2, -43 },
  { 289, 28, 48, 33, 3, -45 },
  { 457, 38, 44, 46, 5, -43 },
  { 666, 35, 45, 41, 3, -44 },
  { 863, 5, 16, 11, 7, -43 },
  { 873, 17, 52, 15, 2, -43 },
  { 984, 17, 52, 15, -4, -43 },
  { 1095, 25, 25, 32, 7, -45 },
  { 1174, 28, 28, 34, 4, -35 },
  { 1272, 9, 15, 12, -3, -7 },
  { 1289, 15, 2, 19, 2, -17 },
  { 1293, 4, 5, 13, 2, -4 },
  { 1296, 27, 43, 19, -3, -43 },
  { 1442, 28, 45, 33, 4, -44 },
  { 1600, 15, 43, 33, 10, -43 },
  { 1681, 30, 43, 33, 1, -43 },
  { 1843, 31, 44, 33, 1, -43 },
  { 2014, 31, 43, 33, 1, -43 },
  { 2181, 30, 44, 33, 2, -43 },
  { 2346, 29, 45, 33, 4, -44 },
  { 2510, 28, 43, 33, 6, -43 },
  { 2661, 29, 44, 33, 3, -43 },
  { 2821, 28, 44, 33, 3, -43 },
  { 2975, 10, 33, 13, 2, -32 },
  { 3017, 15, 40, 13, -3, -32 },
  { 3092, 28, 27, 34, 4, -35 },
  { 3187, 28, 14, 34, 4, -28 },
  { 3236, 28, 27, 34, 4, -35 },
  { 3331, 21, 44, 24, 5, -43 },
  { 3447, 46, 47, 50, 3, -42 },
  { 3718, 33, 43, 33, -3, -43 },
  { 3896, 32, 43, 36, 3, -43 },
  { 4068, 33, 44, 36, 5, -43 },
  { 4250, 35, 43, 41, 3, -43 },
  { 4439, 30, 43, 32, 3, -43 },
  { 4601, 31, 43, 29, 3, -43 },
  { 4768, 35, 44, 41, 5, -43 },
  { 4961, 38, 43, 41, 3, -43 },
  { 5166, 20, 43, 17, 0, -43 },
  { 5274, 24, 54, 14, -10, -43 },
  { 5436, 35, 43, 33, 3, -43 },
  { 5625, 22, 43, 29, 3, -43 },
  { 5744, 46, 43, 49, 3, -43 },
  { 5992, 38, 43, 41, 3, -43 },
  { 6197, 36, 45, 43, 5, -44 },
  { 6400, 31, 43, 34, 3, -43 },
  { 6567, 36, 54, 43, 5, -44 },
  { 6810, 31, 43, 34, 3, -43 },
  { 6977, 30, 44, 30, 1, -43 },
  { 7142, 29, 43, 29, 6, -43 },
  { 7298, 37, 44, 41, 5, -43 },
  { 7502, 31, 43, 32, 6, -43 },
  { 7669, 47, 43, 50, 7, -43 },
  { 7922, 37, 43, 30, -3, -43 },
  { 8121, 29, 43, 29, 6, -43 },
  { 8277, 34, 43, 32, 0, -43 },
  { 8460, 23, 52, 18, -1, -43 },
  { 8610, 10, 43, 19, 6, -43 },
  { 8664, 22, 52, 18, -4, -43 },
  { 8807, 28, 26, 33, 3, -43 },
  { 8898, 23, 2, 23, -5, 6 },
  { 8904, 7, 10, 14, 9, -46 },
  { 8913, 28, 33, 33, 3, -32 },
  { 9029, 29, 47, 34, 2, -46 },
  { 9200, 25, 33, 27, 3, -32 },
  { 9304, 32, 47, 34, 3, -46 },
  { 9492, 24, 33, 30, 4, -32 },
  { 9591, 33, 60, 17, -8, -46 },
  { 9839, 30, 46, 34, 2, -32 },
  { 10012, 28, 46, 33, 2, -46 },
  { 10173, 12, 43, 13, 2, -43 },
  { 10238, 22, 57, 13, -8, -43 },
  { 10395, 27, 46, 27, 2, -46 },
  { 10551, 12, 46, 13, 2, -46 },
  { 10620, 45, 32, 51, 2, -32 },
  { 10800, 28, 32, 33, 2, -32 },
  { 10912, 28, 33, 34, 3, -32 },
  { 11028, 32, 46, 34, -1, -32 },
  { 11212, 29, 46, 34, 3, -32 },
  { 11379, 22, 32, 23, 2, -32 },
  { 11467, 23, 33, 26, 1, -32 },
  { 11562, 17, 41, 19, 3, -40 },
  { 11650, 28, 33, 33, 3, -32 },
  { 11766, 25, 32, 25, 3, -32 },
  { 11866, 39, 32, 40, 3, -32 },
  { 12022, 31, 32, 28, -2, -32 },
  { 12146, 35, 47, 25, -7, -32 },
  { 12352, 27, 32, 26, -1, -32 },
  { 12460, 22, 52, 20, 1, -43 },
  { 12603, 2, 60, 32, 17, -46 },
  { 12618, 22, 53, 20, -3, -43 },
  { 12764, 28, 6, 34, 4, -24 },
};

const GFXfont NotoSans_ExtraLightItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRALIGHTITALIC60PT7B_H_
