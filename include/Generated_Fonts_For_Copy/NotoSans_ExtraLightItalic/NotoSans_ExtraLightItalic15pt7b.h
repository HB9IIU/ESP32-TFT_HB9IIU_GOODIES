#ifndef _NOTOSANS_EXTRALIGHTITALIC15PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x02, 0x00, 0xB6, 0xD0, 0x11, 0x12, 0x12, 0xFB,
  0x24, 0x24, 0x24, 0xFF, 0x48, 0x48, 0x88, 0x08, 0x7D, 0x22, 0x85, 0x06,
  0x07, 0x12, 0x25, 0xF0, 0x81, 0x00, 0x30, 0x92, 0x28, 0x92, 0x28, 0x95,
  0xA5, 0x96, 0xA4, 0x51, 0x24, 0x49, 0x24, 0x38, 0x1C, 0x11, 0x08, 0x84,
  0xC2, 0x81, 0x83, 0x23, 0x12, 0x86, 0x43, 0x3E, 0x40, 0xF0, 0x12, 0x44,
  0x88, 0x88, 0x88, 0x88, 0x80, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0xC0,
  0x12, 0x47, 0xC8, 0xD0, 0x40, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00,
  0x29, 0x40, 0xE0, 0x80, 0x02, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x82, 0x00, 0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x85, 0x11, 0xC0,
  0x13, 0xD1, 0x12, 0x22, 0x24, 0x40, 0x1E, 0x21, 0x01, 0x01, 0x02, 0x02,
  0x0C, 0x10, 0x20, 0x40, 0xFC, 0x1E, 0x21, 0x01, 0x01, 0x02, 0x1C, 0x02,
  0x02, 0x02, 0x02, 0xFC, 0x01, 0x02, 0x06, 0x0A, 0x12, 0x22, 0x42, 0xFF,
  0x04, 0x04, 0x04, 0x3E, 0x41, 0x02, 0x07, 0x01, 0x81, 0x02, 0x04, 0x0B,
  0xE0, 0x1E, 0x41, 0x02, 0x0B, 0x98, 0xA0, 0xC1, 0x85, 0x09, 0xE0, 0xFC,
  0x10, 0x82, 0x10, 0x42, 0x08, 0x42, 0x08, 0x00, 0x1C, 0x45, 0x0A, 0x12,
  0x47, 0x11, 0x42, 0x85, 0x09, 0xE0, 0x3C, 0x85, 0x0C, 0x18, 0x28, 0xCE,
  0x82, 0x04, 0x13, 0xC0, 0x20, 0x00, 0x04, 0x10, 0x00, 0x00, 0x24, 0x48,
  0x02, 0x18, 0xC6, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x03, 0xF8, 0x80, 0xC0,
  0x70, 0x10, 0xC6, 0x30, 0x00, 0x70, 0x42, 0x10, 0x99, 0x08, 0x00, 0x20,
  0x0F, 0x82, 0x08, 0x80, 0xA3, 0x18, 0x93, 0x22, 0x64, 0x4D, 0x11, 0x95,
  0x51, 0x11, 0x00, 0x1F, 0x80, 0x02, 0x03, 0x01, 0x41, 0x20, 0x90, 0x88,
  0x7C, 0x42, 0x41, 0x20, 0x60, 0x20, 0x3E, 0x21, 0x41, 0x41, 0x42, 0x7C,
  0x82, 0x82, 0x82, 0x82, 0xFC, 0x0F, 0x98, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x0F, 0x80, 0x3C, 0x11, 0x90, 0x48, 0x14, 0x0A,
  0x06, 0x05, 0x02, 0x81, 0x43, 0x3E, 0x00, 0x3E, 0x41, 0x02, 0x04, 0x0F,
  0xA0, 0x40, 0x81, 0x03, 0xE0, 0x3E, 0x41, 0x02, 0x04, 0x0F, 0xA0, 0x40,
  0x81, 0x02, 0x00, 0x0F, 0x98, 0x10, 0x08, 0x08, 0x04, 0x32, 0x05, 0x02,
  0x81, 0x20, 0x8F, 0x80, 0x20, 0x90, 0x50, 0x28, 0x14, 0x13, 0xFA, 0x05,
  0x02, 0x81, 0x41, 0x20, 0x80, 0x38, 0x84, 0x42, 0x10, 0x84, 0x42, 0x38,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x1C,
  0x00, 0x21, 0x91, 0x11, 0x09, 0x05, 0x03, 0x81, 0x41, 0x10, 0x88, 0x42,
  0x21, 0x00, 0x21, 0x10, 0x84, 0x22, 0x10, 0x84, 0x3E, 0x20, 0x24, 0x05,
  0x81, 0xA8, 0x55, 0x0C, 0xA2, 0xA4, 0x94, 0x92, 0x94, 0x51, 0x12, 0x22,
  0x00, 0x20, 0x90, 0x54, 0x2A, 0x15, 0x12, 0x4A, 0x25, 0x0A, 0x85, 0x41,
  0x20, 0x80, 0x1F, 0x10, 0x50, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x20, 0x8F, 0x80, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0xBE, 0x40, 0x81, 0x02,
  0x00, 0x1F, 0x10, 0x50, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x20,
  0x8D, 0x81, 0x00, 0x40, 0x10, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0xAE, 0x44,
  0x89, 0x0A, 0x10, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x18, 0x04, 0x02, 0x02,
  0x04, 0xF8, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x0A, 0x05, 0x02, 0x81, 0x41,
  0x1F, 0x00, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA1, 0x81, 0x00,
  0x84, 0x18, 0x42, 0x8C, 0x28, 0xC4, 0x94, 0x49, 0x28, 0xA2, 0x8A, 0x30,
  0xC3, 0x0C, 0x20, 0x82, 0x00, 0x10, 0x44, 0x21, 0x10, 0x28, 0x0C, 0x01,
  0x00, 0xC0, 0x50, 0x22, 0x10, 0x88, 0x10, 0x81, 0x42, 0x44, 0x44, 0x48,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x3F, 0x80, 0x1C, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x42, 0x08, 0x20, 0xE0, 0x91, 0x24, 0x91, 0x24, 0x80, 0x1C, 0x10,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0xE0, 0x08, 0x30, 0xA1, 0x24,
  0x50, 0xA0, 0x80, 0xF8, 0x90, 0x3A, 0x8A, 0x14, 0x28, 0x50, 0xA2, 0x7C,
  0x20, 0x20, 0x20, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x3D,
  0x08, 0x20, 0x82, 0x08, 0x1E, 0x01, 0x01, 0x02, 0x3E, 0x42, 0x82, 0x82,
  0x84, 0x84, 0x8C, 0xF4, 0x39, 0x18, 0x7E, 0x82, 0x08, 0x1E, 0x07, 0x08,
  0x08, 0x1E, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0xC0, 0x1F, 0x21, 0x41, 0x41, 0x42, 0x42, 0x46, 0x7A, 0x04, 0x04, 0x88,
  0x70, 0x20, 0x40, 0x81, 0xF2, 0x24, 0x50, 0xA1, 0x42, 0x86, 0x08, 0x20,
  0x12, 0x92, 0x4A, 0x00, 0x08, 0x00, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42,
  0x13, 0x00, 0x20, 0x40, 0x81, 0x12, 0x49, 0x14, 0x38, 0x48, 0x92, 0x10,
  0x24, 0x92, 0x92, 0x4A, 0x00, 0x3E, 0xE2, 0x31, 0x22, 0x14, 0x21, 0x42,
  0x14, 0x22, 0x44, 0x28, 0x42, 0x3E, 0x21, 0x21, 0x42, 0x42, 0x42, 0x42,
  0x82, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0xA1, 0x3C, 0x3E, 0x21, 0x21, 0x41,
  0x41, 0x42, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x86, 0x0C, 0x18,
  0x50, 0xA3, 0x7A, 0x08, 0x10, 0x20, 0x40, 0x3C, 0x82, 0x10, 0x41, 0x04,
  0x20, 0x3D, 0x04, 0x08, 0x18, 0x20, 0xBE, 0x44, 0xF4, 0x88, 0x88, 0x8E,
  0x42, 0x86, 0x0C, 0x28, 0x50, 0xA2, 0x7A, 0x86, 0x28, 0xA4, 0x92, 0x8A,
  0x10, 0x88, 0xCC, 0x66, 0x55, 0x2A, 0x56, 0x33, 0x11, 0x08, 0x21, 0x12,
  0x14, 0x08, 0x18, 0x24, 0x24, 0xC2, 0x10, 0x88, 0x84, 0x42, 0x41, 0x20,
  0xA0, 0x20, 0x10, 0x08, 0x08, 0x08, 0x18, 0x00, 0x3E, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x7C, 0x0C, 0x41, 0x04, 0x20, 0x8C, 0x10, 0x41, 0x04, 0x10,
  0x60, 0xFF, 0xFE, 0x10, 0x20, 0x82, 0x08, 0x20, 0xC4, 0x10, 0x42, 0x08,
  0xE0, 0xFE,
};

const GFXglyph NotoSans_ExtraLightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 5, 2, -11 },
  { 8, 8, 11, 9, 1, -11 },
  { 19, 7, 12, 8, 1, -11 },
  { 30, 10, 11, 12, 1, -11 },
  { 44, 9, 11, 10, 1, -11 },
  { 57, 1, 4, 3, 2, -11 },
  { 58, 4, 13, 4, 1, -11 },
  { 65, 4, 13, 4, -1, -11 },
  { 72, 6, 6, 8, 2, -11 },
  { 77, 7, 7, 9, 1, -9 },
  { 84, 3, 4, 3, -1, -2 },
  { 86, 3, 1, 5, 1, -5 },
  { 87, 1, 1, 3, 0, -1 },
  { 88, 7, 11, 5, -1, -11 },
  { 98, 7, 11, 8, 1, -11 },
  { 108, 4, 11, 8, 2, -11 },
  { 114, 8, 11, 8, 0, -11 },
  { 125, 8, 11, 8, 0, -11 },
  { 136, 8, 11, 8, 0, -11 },
  { 147, 7, 11, 8, 1, -11 },
  { 157, 7, 11, 8, 1, -11 },
  { 167, 6, 11, 8, 2, -11 },
  { 176, 7, 11, 8, 1, -11 },
  { 186, 7, 11, 8, 1, -11 },
  { 196, 3, 8, 3, 0, -8 },
  { 199, 4, 10, 3, -1, -8 },
  { 204, 7, 7, 9, 1, -9 },
  { 211, 7, 3, 9, 1, -7 },
  { 214, 7, 7, 9, 1, -9 },
  { 221, 5, 11, 6, 1, -11 },
  { 228, 11, 12, 13, 1, -11 },
  { 245, 9, 11, 8, -1, -11 },
  { 258, 8, 11, 9, 1, -11 },
  { 269, 9, 11, 9, 1, -11 },
  { 282, 9, 11, 10, 1, -11 },
  { 295, 7, 11, 8, 1, -11 },
  { 305, 7, 11, 7, 1, -11 },
  { 315, 9, 11, 10, 1, -11 },
  { 328, 9, 11, 10, 1, -11 },
  { 341, 5, 11, 4, 0, -11 },
  { 348, 7, 14, 4, -3, -11 },
  { 361, 9, 11, 8, 1, -11 },
  { 374, 5, 11, 7, 1, -11 },
  { 381, 11, 11, 12, 1, -11 },
  { 397, 9, 11, 10, 1, -11 },
  { 410, 9, 11, 11, 1, -11 },
  { 423, 7, 11, 8, 1, -11 },
  { 433, 9, 14, 11, 1, -11 },
  { 449, 7, 11, 8, 1, -11 },
  { 459, 8, 11, 7, 0, -11 },
  { 470, 8, 11, 7, 1, -11 },
  { 481, 9, 11, 10, 1, -11 },
  { 494, 7, 11, 8, 2, -11 },
  { 504, 12, 11, 12, 2, -11 },
  { 521, 10, 11, 7, -1, -11 },
  { 535, 8, 11, 7, 1, -11 },
  { 546, 9, 11, 8, 0, -11 },
  { 559, 6, 13, 5, 0, -11 },
  { 569, 3, 11, 5, 1, -11 },
  { 574, 6, 13, 5, -1, -11 },
  { 584, 7, 7, 8, 1, -11 },
  { 591, 5, 1, 6, -1, 1 },
  { 592, 2, 2, 4, 2, -11 },
  { 593, 7, 8, 8, 1, -8 },
  { 600, 8, 11, 9, 0, -11 },
  { 611, 6, 8, 7, 1, -8 },
  { 617, 8, 11, 9, 1, -11 },
  { 628, 6, 8, 7, 1, -8 },
  { 634, 8, 15, 4, -2, -11 },
  { 649, 8, 12, 9, 0, -8 },
  { 661, 7, 11, 8, 0, -11 },
  { 671, 3, 11, 3, 0, -11 },
  { 676, 5, 15, 3, -2, -11 },
  { 686, 7, 11, 7, 0, -11 },
  { 696, 3, 11, 3, 0, -11 },
  { 701, 12, 8, 13, 0, -8 },
  { 713, 8, 8, 8, 0, -8 },
  { 721, 7, 8, 8, 1, -8 },
  { 728, 8, 12, 9, 0, -8 },
  { 740, 7, 12, 9, 1, -8 },
  { 751, 6, 8, 6, 0, -8 },
  { 757, 6, 8, 6, 0, -8 },
  { 763, 4, 10, 5, 1, -10 },
  { 768, 7, 8, 8, 1, -8 },
  { 775, 6, 8, 6, 1, -8 },
  { 781, 9, 8, 10, 1, -8 },
  { 790, 8, 8, 7, -1, -8 },
  { 798, 9, 12, 6, -2, -8 },
  { 812, 7, 8, 7, 0, -8 },
  { 819, 6, 13, 5, 0, -11 },
  { 829, 1, 15, 8, 4, -11 },
  { 831, 6, 13, 5, -1, -11 },
  { 841, 7, 1, 9, 1, -6 },
};

const GFXfont NotoSans_ExtraLightItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRALIGHTITALIC15PT7B_H_
