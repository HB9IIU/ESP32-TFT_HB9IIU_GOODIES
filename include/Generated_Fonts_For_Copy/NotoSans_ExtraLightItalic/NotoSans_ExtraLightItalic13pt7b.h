#ifndef _NOTOSANS_EXTRALIGHTITALIC13PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x76, 0x80, 0x0A, 0x12, 0x7B, 0x14, 0x24,
  0xFE, 0x24, 0x28, 0x48, 0x10, 0xF5, 0x24, 0x60, 0x42, 0x8A, 0xB1, 0x04,
  0x00, 0x71, 0x92, 0x94, 0x9B, 0xAD, 0x55, 0x29, 0x49, 0x46, 0x3C, 0x89,
  0x11, 0xC5, 0x12, 0x62, 0xC6, 0xF2, 0x68, 0x12, 0x44, 0x48, 0x88, 0x88,
  0x40, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x25, 0x16, 0xCA, 0x08, 0x20,
  0x82, 0x3F, 0x20, 0x80, 0x56, 0xF0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x80, 0x7D, 0x18, 0x61, 0x86, 0x18, 0xA2, 0xF0, 0x74, 0x92, 0x92,
  0x40, 0x3E, 0x04, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x3E, 0x04, 0x08,
  0x23, 0x80, 0x81, 0x02, 0xF8, 0x06, 0x14, 0x51, 0x22, 0x48, 0xBF, 0x84,
  0x08, 0x3E, 0x40, 0x83, 0xC0, 0x40, 0x81, 0x02, 0xF8, 0x3D, 0x04, 0x2C,
  0xCA, 0x18, 0x62, 0xF0, 0x7C, 0x10, 0x84, 0x10, 0x82, 0x10, 0x80, 0x7D,
  0x14, 0x4A, 0x52, 0x28, 0xA2, 0xF0, 0x7A, 0x18, 0x61, 0x89, 0xE0, 0x84,
  0xE0, 0x20, 0x00, 0x20, 0x10, 0x00, 0x02, 0x44, 0x80, 0x04, 0x66, 0x30,
  0x30, 0x30, 0xFC, 0x0F, 0xC0, 0x81, 0x81, 0x83, 0x33, 0x00, 0x70, 0x42,
  0x22, 0x22, 0x00, 0x80, 0x3F, 0x10, 0x28, 0xC6, 0x49, 0xA2, 0x69, 0x2A,
  0x4A, 0x6C, 0x80, 0x1F, 0x80, 0x04, 0x0A, 0x0A, 0x12, 0x12, 0x3E, 0x22,
  0x41, 0x81, 0x7C, 0x85, 0x0A, 0x2B, 0x90, 0xA1, 0x42, 0xF8, 0x3E, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x7C, 0x7C, 0x85, 0x0A, 0x18, 0x30, 0x60,
  0xC2, 0xF8, 0x7D, 0x04, 0x10, 0xBA, 0x08, 0x20, 0xF0, 0x7D, 0x04, 0x10,
  0x7A, 0x08, 0x20, 0x80, 0x3F, 0x40, 0x80, 0x80, 0x8E, 0x82, 0x82, 0x82,
  0x7C, 0x41, 0x41, 0x42, 0x42, 0xBE, 0x82, 0x82, 0x84, 0x84, 0x32, 0x22,
  0x24, 0x44, 0xC0, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x38, 0x46, 0x91,
  0x43, 0x06, 0x12, 0x24, 0x44, 0x88, 0x44, 0x44, 0x88, 0x88, 0xF0, 0x40,
  0xD8, 0x66, 0x19, 0x8A, 0xA2, 0xA5, 0x29, 0x92, 0x64, 0x91, 0x00, 0x41,
  0x61, 0x62, 0x52, 0x92, 0x8A, 0x8A, 0x84, 0x84, 0x3E, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x7C, 0x7D, 0x14, 0x51, 0xFA, 0x08, 0x20, 0x80,
  0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x6C, 0x10, 0x08, 0x7D,
  0x14, 0x51, 0x7A, 0x48, 0xA2, 0x88, 0x3E, 0x81, 0x01, 0x01, 0x80, 0x81,
  0x02, 0xF8, 0xFE, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x41, 0x41,
  0x41, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x83, 0x0A, 0x12, 0x44, 0x8A,
  0x14, 0x30, 0x40, 0x88, 0x66, 0x29, 0x8A, 0xA4, 0xA9, 0x31, 0x8C, 0x62,
  0x10, 0x84, 0x00, 0x31, 0x12, 0x14, 0x08, 0x08, 0x14, 0x24, 0x44, 0x82,
  0x86, 0x89, 0x22, 0x86, 0x04, 0x10, 0x20, 0x40, 0x3E, 0x08, 0x10, 0x41,
  0x04, 0x10, 0x20, 0xFC, 0x39, 0x10, 0x84, 0x21, 0x10, 0x84, 0x38, 0xA5,
  0x55, 0x40, 0x38, 0x42, 0x21, 0x08, 0x42, 0x21, 0x38, 0x10, 0xA4, 0x92,
  0x84, 0xF8, 0xB0, 0x76, 0x28, 0xA2, 0x8A, 0x6E, 0x80, 0x20, 0x40, 0x81,
  0xE2, 0x28, 0x50, 0xA1, 0x45, 0x70, 0x7C, 0x21, 0x08, 0x43, 0xC0, 0x02,
  0x04, 0x13, 0xE8, 0x50, 0xA2, 0x44, 0x89, 0xF0, 0x7C, 0x63, 0xE8, 0x43,
  0xC0, 0x06, 0x10, 0x20, 0xE1, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x0C,
  0x00, 0x3E, 0x85, 0x0A, 0x28, 0x50, 0x9F, 0x02, 0x09, 0xE0, 0x20, 0x82,
  0x0F, 0x25, 0x14, 0x51, 0x86, 0x10, 0x20, 0xA4, 0x94, 0x80, 0x08, 0x02,
  0x21, 0x08, 0x44, 0x21, 0x09, 0x80, 0x20, 0x82, 0x09, 0x49, 0x46, 0x14,
  0x8A, 0x20, 0x24, 0x94, 0x92, 0x90, 0x5D, 0xC8, 0x94, 0x45, 0x11, 0x44,
  0x61, 0x18, 0x84, 0x5C, 0x45, 0x0A, 0x24, 0x50, 0xA1, 0x00, 0x7A, 0x18,
  0x61, 0x86, 0x2F, 0x00, 0x5C, 0x45, 0x0A, 0x14, 0x28, 0xAE, 0x40, 0x81,
  0x00, 0x7E, 0x18, 0x62, 0x8A, 0x2F, 0x82, 0x10, 0x40, 0x59, 0x10, 0x84,
  0x42, 0x00, 0x3A, 0x10, 0x60, 0x87, 0xC0, 0x4B, 0xC9, 0x24, 0xE0, 0x86,
  0x18, 0x62, 0x8A, 0x6E, 0x80, 0x8C, 0x65, 0x4A, 0x61, 0x00, 0x91, 0x91,
  0xAA, 0xAA, 0xCC, 0x8C, 0x88, 0x44, 0xA3, 0x08, 0x31, 0x48, 0x80, 0x42,
  0x44, 0x91, 0x42, 0x86, 0x04, 0x10, 0x21, 0x80, 0x7C, 0x21, 0x08, 0x41,
  0x0F, 0x00, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF8, 0x18,
  0x44, 0x21, 0x04, 0x44, 0x21, 0x30, 0xFC,
};

const GFXglyph NotoSans_ExtraLightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 6, 11, 7, 1, -10 },
  { 25, 8, 9, 10, 1, -9 },
  { 34, 7, 9, 9, 1, -9 },
  { 42, 2, 3, 2, 1, -9 },
  { 43, 4, 11, 3, 0, -9 },
  { 49, 4, 11, 3, -1, -9 },
  { 55, 5, 6, 7, 2, -10 },
  { 59, 6, 6, 7, 1, -8 },
  { 64, 2, 4, 3, -1, -2 },
  { 65, 4, 1, 4, 0, -4 },
  { 66, 1, 1, 3, 0, -1 },
  { 67, 6, 9, 4, -1, -9 },
  { 74, 6, 9, 7, 1, -9 },
  { 81, 3, 9, 7, 2, -9 },
  { 85, 7, 9, 7, 0, -9 },
  { 93, 7, 9, 7, 0, -9 },
  { 101, 7, 9, 7, 0, -9 },
  { 109, 7, 9, 7, 0, -9 },
  { 117, 6, 9, 7, 1, -9 },
  { 124, 6, 9, 7, 1, -9 },
  { 131, 6, 9, 7, 1, -9 },
  { 138, 6, 9, 7, 1, -9 },
  { 145, 3, 7, 3, 0, -7 },
  { 148, 4, 9, 3, -1, -7 },
  { 153, 6, 6, 7, 1, -8 },
  { 158, 6, 3, 7, 1, -6 },
  { 161, 6, 6, 7, 1, -8 },
  { 166, 5, 9, 5, 1, -9 },
  { 172, 10, 10, 11, 1, -9 },
  { 185, 8, 9, 7, -1, -9 },
  { 194, 7, 9, 8, 1, -9 },
  { 202, 7, 9, 8, 1, -9 },
  { 210, 7, 9, 9, 1, -9 },
  { 218, 6, 9, 7, 1, -9 },
  { 225, 6, 9, 6, 1, -9 },
  { 232, 8, 9, 9, 1, -9 },
  { 241, 8, 9, 9, 1, -9 },
  { 250, 4, 9, 4, 0, -9 },
  { 255, 5, 11, 3, -2, -9 },
  { 262, 7, 9, 7, 1, -9 },
  { 270, 4, 9, 6, 1, -9 },
  { 275, 10, 9, 11, 1, -9 },
  { 287, 8, 9, 9, 1, -9 },
  { 296, 8, 9, 9, 1, -9 },
  { 305, 6, 9, 7, 1, -9 },
  { 312, 8, 11, 9, 1, -9 },
  { 323, 6, 9, 7, 1, -9 },
  { 330, 7, 9, 6, 0, -9 },
  { 338, 7, 9, 6, 1, -9 },
  { 346, 8, 9, 9, 1, -9 },
  { 355, 7, 9, 7, 1, -9 },
  { 363, 10, 9, 11, 2, -9 },
  { 375, 8, 9, 6, -1, -9 },
  { 384, 7, 9, 6, 1, -9 },
  { 392, 7, 9, 7, 0, -9 },
  { 400, 5, 11, 4, 0, -9 },
  { 407, 2, 9, 4, 1, -9 },
  { 410, 5, 11, 4, -1, -9 },
  { 417, 6, 5, 7, 1, -9 },
  { 421, 5, 1, 5, -1, 1 },
  { 422, 2, 2, 3, 2, -10 },
  { 423, 6, 7, 7, 1, -7 },
  { 429, 7, 10, 7, 0, -10 },
  { 438, 5, 7, 6, 1, -7 },
  { 443, 7, 10, 7, 1, -10 },
  { 452, 5, 7, 6, 1, -7 },
  { 457, 7, 13, 4, -2, -10 },
  { 469, 7, 10, 7, 0, -7 },
  { 478, 6, 10, 7, 0, -10 },
  { 486, 3, 9, 3, 0, -9 },
  { 490, 5, 12, 3, -2, -9 },
  { 498, 6, 10, 6, 0, -10 },
  { 506, 3, 10, 3, 0, -10 },
  { 510, 10, 7, 11, 0, -7 },
  { 519, 7, 7, 7, 0, -7 },
  { 526, 6, 7, 7, 1, -7 },
  { 532, 7, 10, 7, 0, -7 },
  { 541, 6, 10, 7, 1, -7 },
  { 549, 5, 7, 5, 0, -7 },
  { 554, 5, 7, 6, 0, -7 },
  { 559, 3, 9, 4, 1, -9 },
  { 563, 6, 7, 7, 1, -7 },
  { 569, 5, 7, 5, 1, -7 },
  { 574, 8, 7, 9, 1, -7 },
  { 581, 6, 7, 6, 0, -7 },
  { 587, 7, 10, 5, -1, -7 },
  { 596, 6, 7, 6, 0, -7 },
  { 602, 5, 11, 4, 0, -9 },
  { 609, 1, 13, 7, 3, -10 },
  { 611, 5, 11, 4, -1, -9 },
  { 618, 6, 1, 7, 1, -5 },
};

const GFXfont NotoSans_ExtraLightItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRALIGHTITALIC13PT7B_H_
