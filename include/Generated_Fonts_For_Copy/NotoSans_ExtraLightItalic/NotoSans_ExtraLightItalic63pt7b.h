#ifndef _NOTOSANS_EXTRALIGHTITALIC63PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x04, 0x00, 0x1C, 0x0E,
  0x30, 0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x0C, 0x06, 0x18,
  0x0C, 0x70, 0x38, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x04,
  0x30, 0x18, 0x60, 0x30, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x70, 0x01, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7C, 0x30, 0x78, 0x07,
  0x81, 0x80, 0x40, 0x70, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x03, 0xC6,
  0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x06, 0x7C, 0x00, 0x00, 0x30, 0xF0, 0x00,
  0x01, 0x83, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00,
  0x03, 0x00, 0xE0, 0x80, 0x18, 0x0E, 0x07, 0x00, 0xC1, 0xE0, 0x3F, 0xE6,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x03, 0xFF, 0x80,
  0x00, 0x18, 0x07, 0x81, 0xC0, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x70,
  0x00, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x01, 0x80, 0xE0, 0x00,
  0xE0, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x03,
  0x83, 0x83, 0xF8, 0xE0, 0x03, 0x07, 0x0F, 0xFE, 0xE0, 0x07, 0x06, 0x1E,
  0x0E, 0xE0, 0x06, 0x0C, 0x38, 0x07, 0x60, 0x0E, 0x1C, 0x30, 0x07, 0x70,
  0x1C, 0x38, 0x70, 0x03, 0x70, 0x38, 0x30, 0x60, 0x03, 0x3F, 0xF0, 0x60,
  0xE0, 0x03, 0x1F, 0xE0, 0xE0, 0xC0, 0x03, 0x07, 0x01, 0xC0, 0xC0, 0x03,
  0x00, 0x01, 0x81, 0xC0, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x18,
  0x03, 0x00, 0x03, 0x80, 0x38, 0x07, 0x00, 0x01, 0x80, 0x70, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x0C, 0x00, 0x00, 0xF7, 0xC0, 0x18, 0x00, 0x00, 0x7F,
  0x80, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC3, 0xC0, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x70, 0x00, 0x63, 0x80, 0x01, 0xC0, 0x07, 0x18, 0x00, 0x06, 0x00,
  0x31, 0xC0, 0x00, 0x38, 0x03, 0x8C, 0x00, 0x00, 0xE0, 0x38, 0xE0, 0x00,
  0x03, 0x01, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC1,
  0x80, 0x00, 0x01, 0xDC, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x00,
  0x3C, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0xE0,
  0x00, 0x01, 0xDC, 0x03, 0x80, 0x00, 0x3C, 0x70, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x7C, 0x00, 0xF8, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0x38, 0x03, 0xFF,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x63, 0x8E, 0x30,
  0xC3, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0xF0, 0x04, 0x00, 0x0F, 0x03, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE8, 0x1F, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE4, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x03, 0x00,
  0x0F, 0x00, 0xE0, 0x07, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x76, 0x01, 0xE6, 0x03, 0x86, 0x0F,
  0x0E, 0x3C, 0x0E, 0x78, 0x0C, 0xE0, 0x0C, 0x40, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x08, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x9F, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x02, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x3E, 0x00, 0x06, 0x0F, 0xFF, 0x00, 0x38, 0xFE, 0x3E, 0x00, 0xC7,
  0x80, 0x1C, 0x03, 0x38, 0x00, 0x38, 0x1D, 0x80, 0x00, 0x70, 0x7C, 0x00,
  0x00, 0xC1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x3E,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0D, 0x83, 0x80, 0x00, 0x6E,
  0x07, 0x00, 0x03, 0xB0, 0x0E, 0x00, 0x38, 0xC0, 0x1F, 0x0F, 0xC7, 0x00,
  0x3F, 0xFC, 0x1C, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x20,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xBC,
  0x00, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x3C, 0x10, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x06, 0x0E, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0x0C, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x1C, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0x18, 0x00, 0x78, 0x00, 0x60, 0x03, 0x38, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0x38, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x30, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x70, 0x03, 0x00, 0x01, 0xC0,
  0x07, 0x60, 0x03, 0x00, 0x01, 0x80, 0x07, 0x60, 0x07, 0x00, 0x01, 0x80,
  0x07, 0x60, 0x06, 0x00, 0x03, 0x80, 0x06, 0x60, 0x06, 0x00, 0x03, 0x80,
  0x06, 0x60, 0x06, 0x00, 0x03, 0x00, 0x0E, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0x0C, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0xE0, 0x0E, 0x00, 0x0F, 0x00,
  0x1C, 0x60, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x60, 0x06, 0x00, 0x1B, 0x00,
  0x30, 0x60, 0x06, 0x00, 0x3B, 0x00, 0x70, 0x60, 0x07, 0x00, 0x73, 0x00,
  0xE0, 0x60, 0x03, 0x81, 0xE3, 0x83, 0xC0, 0x70, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x30, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0x7C, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x30,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x60, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x01, 0xE0,
  0x18, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x04, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x7C, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x18,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x3E,
  0x00, 0x60, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x18, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x03,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xC7, 0x00, 0x00, 0xFF,
  0xFE, 0x38, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x17,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x10, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0x71, 0xF0,
  0x00, 0x00, 0x03, 0x1D, 0xC0, 0x00, 0x00, 0x19, 0x8E, 0x00, 0x00, 0x00,
  0xF8, 0x38, 0x00, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x76, 0x00, 0xEC,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0xEC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xCC, 0x00, 0xCE,
  0x00, 0x00, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x9C, 0x01, 0xC6,
  0x00, 0x00, 0x07, 0x1C, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x00, 0x0E, 0x18, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x03, 0x87,
  0x00, 0x00, 0x1C, 0x38, 0x03, 0x07, 0x00, 0x00, 0x38, 0x38, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x07, 0x03,
  0x00, 0x00, 0x60, 0x70, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x06, 0x03,
  0x80, 0x01, 0xC0, 0x60, 0x06, 0x03, 0x80, 0x01, 0x80, 0x60, 0x06, 0x01,
  0x80, 0x03, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x0E, 0x01,
  0x80, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x00,
  0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x18, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x70, 0x01, 0x80, 0x38, 0x00,
  0xE0, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x80, 0x30, 0x00,
  0x61, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x61, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x63, 0x80, 0x03, 0x00, 0x70, 0x00, 0x63, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x76, 0x00, 0x07, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x78, 0x00, 0x00,
  0x06, 0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x00, 0xCE, 0x00,
  0x00, 0x0C, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x00, 0xC7, 0x00, 0x00, 0x1C,
  0x01, 0xC3, 0x00, 0x00, 0x1C, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x01, 0x83,
  0x80, 0x00, 0x18, 0x01, 0x81, 0x80, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x03,
  0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x38, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x81, 0x80, 0x18, 0x00, 0x01, 0x83, 0x80, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x38, 0x00, 0x00, 0xC3, 0x00, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x30, 0x00,
  0x00, 0xE3, 0x00, 0x30, 0x00, 0x00, 0x67, 0x00, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x70, 0x00, 0x00, 0x36, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x60,
  0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x70, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xE0, 0x06,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xF8, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x60, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x01, 0xF0, 0x06, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x40, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x39, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x06, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0x00, 0x03,
  0x01, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0x80, 0x70, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x01, 0x80, 0x38, 0x01, 0x80,
  0x38, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x60,
  0x1C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x18,
  0x0E, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x01,
  0x83, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x60, 0x00,
  0x1C, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x30, 0x07,
  0xC1, 0xE1, 0x80, 0x3C, 0x01, 0xC6, 0x01, 0xC0, 0x03, 0x98, 0x0E, 0x00,
  0x06, 0x60, 0x70, 0x00, 0x0B, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x06, 0xC0,
  0x70, 0x00, 0x33, 0x01, 0xC0, 0x01, 0x9C, 0x03, 0x80, 0x1C, 0x60, 0x07,
  0x00, 0xE1, 0x80, 0x1F, 0xFF, 0x06, 0x00, 0x1F, 0xF0, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x1F,
  0xC0, 0x00, 0xC0, 0xFF, 0xE0, 0x01, 0x87, 0xC3, 0xE0, 0x07, 0x1C, 0x00,
  0xE0, 0x0E, 0x70, 0x00, 0xE0, 0x19, 0x80, 0x00, 0xC0, 0x36, 0x00, 0x01,
  0xC0, 0x6C, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x03, 0x81, 0xB0, 0x00,
  0x0E, 0x03, 0x30, 0x00, 0x3C, 0x06, 0x70, 0x00, 0xF0, 0x1C, 0x70, 0x07,
  0x80, 0x30, 0x7F, 0xFE, 0x00, 0x60, 0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xE0, 0x7C, 0x03,
  0xC0, 0x02, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0xE0, 0x00,
  0x7F, 0xF8, 0x30, 0x00, 0x7E, 0x0F, 0x0C, 0x00, 0x3C, 0x00, 0xE3, 0x00,
  0x1C, 0x00, 0x1D, 0xC0, 0x0E, 0x00, 0x03, 0x70, 0x07, 0x00, 0x00, 0x58,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01,
  0xE0, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0D,
  0x80, 0x18, 0x00, 0x07, 0x60, 0x07, 0x00, 0x01, 0x98, 0x01, 0xC0, 0x01,
  0xCE, 0x00, 0x38, 0x00, 0xE3, 0x00, 0x07, 0x00, 0xF0, 0xC0, 0x01, 0xFF,
  0xF0, 0x30, 0x00, 0x1F, 0xF8, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x07, 0x80, 0x3E, 0x00,
  0xE0, 0x3C, 0x00, 0x30, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1, 0x80, 0x03, 0xE1, 0xC0,
  0x1F, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x20, 0x3C, 0x00, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3C, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x03, 0x00, 0x3F, 0x07, 0x86, 0x00, 0x78, 0x01, 0xC6, 0x00, 0xE0,
  0x00, 0xE6, 0x01, 0xC0, 0x00, 0x66, 0x03, 0x80, 0x00, 0x2C, 0x07, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x0C, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x06, 0xC0, 0x30, 0x00, 0x0E, 0xC0, 0x38, 0x00,
  0x1D, 0xC0, 0x38, 0x00, 0x39, 0xC0, 0x1C, 0x00, 0x71, 0x80, 0x0E, 0x01,
  0xE1, 0x80, 0x0F, 0xFF, 0x83, 0x80, 0x03, 0xFF, 0x03, 0x80, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0xFC, 0x00, 0x30, 0x3F, 0xF8, 0x01, 0x87, 0xC1, 0xF0,
  0x1C, 0x70, 0x03, 0x80, 0xE7, 0x00, 0x0E, 0x06, 0x70, 0x00, 0x70, 0x36,
  0x00, 0x01, 0x81, 0xB0, 0x00, 0x0C, 0x1F, 0x00, 0x00, 0x60, 0xF0, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x20, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x02,
  0x0F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x20, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x30, 0x01,
  0xE0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x1E, 0x00, 0x00, 0x31, 0xF0,
  0x00, 0x03, 0x9D, 0xC0, 0x00, 0x19, 0xC6, 0x00, 0x00, 0xDC, 0x38, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0x87, 0x87,
  0xC0, 0x78, 0x7C, 0x03, 0x8E, 0x01, 0xC0, 0xE0, 0x1E, 0x03, 0x18, 0x00,
  0xE1, 0x80, 0x0E, 0x03, 0x30, 0x00, 0x63, 0x00, 0x06, 0x03, 0x60, 0x00,
  0x66, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0x6C, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x06, 0x07, 0xFF, 0x80, 0x18, 0x7E, 0x3F, 0x00, 0xE3, 0xC0, 0x1C,
  0x03, 0x1C, 0x00, 0x38, 0x0C, 0xE0, 0x00, 0xE0, 0x37, 0x00, 0x01, 0x80,
  0xD8, 0x00, 0x06, 0x07, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x60, 0x78,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x0F, 0xFE, 0x00, 0x03, 0x0F, 0x87,
  0xC0, 0x01, 0xC7, 0x00, 0x38, 0x00, 0x63, 0x80, 0x07, 0x00, 0x19, 0xC0,
  0x00, 0xC0, 0x06, 0xC0, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0xF8,
  0x00, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0xE0, 0x0D,
  0x80, 0x00, 0x70, 0x03, 0x30, 0x00, 0x3C, 0x00, 0xCE, 0x00, 0x1E, 0x00,
  0x31, 0xC0, 0x1E, 0x00, 0x1C, 0x3F, 0xFF, 0x00, 0x07, 0x07, 0xFF, 0x00,
  0x01, 0x80, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x0C, 0x01, 0xF8, 0x3C, 0x30, 0x07, 0x80, 0x1C, 0x60, 0x1C, 0x00, 0x1C,
  0xC0, 0x70, 0x00, 0x19, 0x81, 0xC0, 0x00, 0x16, 0x07, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x36, 0x03, 0x00, 0x00, 0xEC, 0x07, 0x00, 0x01, 0xB8, 0x0E, 0x00, 0x0E,
  0x70, 0x0E, 0x00, 0x38, 0xC0, 0x0E, 0x01, 0xE1, 0x80, 0x0F, 0xFF, 0x03,
  0x00, 0x0F, 0xFC, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x03, 0x03, 0xFC, 0x06, 0x1F, 0x98,
  0x1C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x01,
  0xF0, 0x3F, 0x03, 0x80, 0x03, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x80,
  0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xB0, 0x18, 0x00, 0x0C, 0xC0,
  0x70, 0x00, 0x73, 0x01, 0xC0, 0x03, 0x9C, 0x03, 0xC0, 0x38, 0x60, 0x07,
  0xFF, 0xC1, 0x80, 0x0F, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x00,
  0x03, 0x98, 0x00, 0x0F, 0x00, 0x01, 0xCC, 0x00, 0x0F, 0x80, 0x00, 0xC6,
  0x00, 0x06, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x60, 0x00, 0x61, 0x80, 0x03,
  0x30, 0x00, 0x70, 0xC0, 0x03, 0x98, 0x00, 0x30, 0x60, 0x01, 0x8E, 0x00,
  0x38, 0x30, 0x01, 0xC7, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x0C,
  0x00, 0xE0, 0xC0, 0x0C, 0x07, 0x00, 0x60, 0x60, 0x0E, 0x03, 0x80, 0x70,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0x70, 0x18, 0x06, 0x03, 0x80, 0x38, 0x1C, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x01, 0xC1, 0xC0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00,
  0x70, 0x60, 0x01, 0x87, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x00, 0x63, 0x80, 0x06, 0x38, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x19,
  0xC0, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00,
  0x6E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x41, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0B, 0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0xE3, 0xE8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraLightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 46, 14, 2, -45 },
  { 70, 15, 16, 21, 7, -45 },
  { 100, 38, 45, 39, 2, -45 },
  { 314, 29, 52, 35, 3, -48 },
  { 503, 40, 47, 49, 5, -46 },
  { 738, 37, 47, 43, 3, -46 },
  { 956, 6, 16, 11, 7, -45 },
  { 968, 18, 55, 16, 2, -45 },
  { 1092, 18, 55, 16, -4, -45 },
  { 1216, 26, 27, 34, 8, -48 },
  { 1304, 29, 29, 36, 5, -37 },
  { 1410, 9, 15, 12, -3, -7 },
  { 1427, 15, 2, 20, 2, -18 },
  { 1431, 4, 5, 14, 2, -4 },
  { 1434, 28, 45, 20, -3, -45 },
  { 1592, 29, 47, 35, 4, -46 },
  { 1763, 16, 45, 35, 10, -45 },
  { 1853, 31, 46, 35, 1, -46 },
  { 2032, 32, 47, 35, 1, -46 },
  { 2220, 32, 45, 35, 1, -45 },
  { 2400, 32, 46, 35, 2, -45 },
  { 2584, 30, 47, 35, 4, -46 },
  { 2761, 28, 45, 35, 7, -45 },
  { 2919, 31, 47, 35, 3, -46 },
  { 3102, 30, 47, 35, 3, -46 },
  { 3279, 10, 35, 14, 2, -34 },
  { 3323, 15, 42, 14, -3, -34 },
  { 3402, 29, 29, 36, 5, -37 },
  { 3508, 29, 15, 36, 5, -30 },
  { 3563, 29, 29, 36, 5, -37 },
  { 3669, 22, 47, 26, 5, -46 },
  { 3799, 48, 51, 53, 3, -45 },
  { 4105, 35, 45, 35, -3, -45 },
  { 4302, 34, 45, 38, 3, -45 },
  { 4494, 35, 47, 37, 5, -46 },
  { 4700, 37, 45, 43, 3, -45 },
  { 4909, 32, 45, 33, 3, -45 },
  { 5089, 32, 45, 31, 3, -45 },
  { 5269, 37, 47, 43, 5, -46 },
  { 5487, 40, 45, 43, 3, -45 },
  { 5712, 21, 45, 18, 0, -45 },
  { 5831, 26, 56, 15, -11, -45 },
  { 6013, 37, 45, 34, 3, -45 },
  { 6222, 23, 45, 31, 3, -45 },
  { 6352, 48, 45, 51, 3, -45 },
  { 6622, 40, 45, 43, 3, -45 },
  { 6847, 38, 47, 45, 5, -46 },
  { 7071, 32, 45, 35, 3, -45 },
  { 7251, 38, 57, 45, 5, -46 },
  { 7522, 32, 45, 36, 3, -45 },
  { 7702, 31, 47, 31, 1, -46 },
  { 7885, 30, 45, 31, 6, -45 },
  { 8054, 39, 46, 43, 5, -45 },
  { 8279, 33, 45, 34, 6, -45 },
  { 8465, 49, 45, 52, 8, -45 },
  { 8741, 40, 45, 31, -4, -45 },
  { 8966, 31, 45, 31, 6, -45 },
  { 9141, 37, 45, 34, -1, -45 },
  { 9350, 24, 55, 19, -1, -45 },
  { 9515, 10, 45, 20, 6, -45 },
  { 9572, 24, 55, 19, -5, -45 },
  { 9737, 29, 28, 35, 3, -45 },
  { 9839, 24, 2, 24, -5, 7 },
  { 9845, 8, 10, 15, 9, -48 },
  { 9855, 30, 35, 35, 3, -34 },
  { 9987, 31, 49, 36, 2, -48 },
  { 10177, 26, 35, 28, 3, -34 },
  { 10291, 34, 49, 36, 3, -48 },
  { 10500, 25, 35, 31, 4, -34 },
  { 10610, 34, 63, 17, -8, -48 },
  { 10878, 32, 49, 36, 2, -34 },
  { 11074, 29, 48, 35, 2, -48 },
  { 11248, 12, 46, 14, 2, -46 },
  { 11317, 23, 61, 14, -9, -46 },
  { 11493, 29, 48, 28, 2, -48 },
  { 11667, 13, 48, 14, 2, -48 },
  { 11745, 48, 34, 53, 2, -34 },
  { 11949, 30, 34, 35, 2, -34 },
  { 12077, 29, 35, 36, 3, -34 },
  { 12204, 34, 49, 36, -1, -34 },
  { 12413, 31, 49, 36, 3, -34 },
  { 12603, 23, 34, 24, 2, -34 },
  { 12701, 24, 35, 27, 1, -34 },
  { 12806, 18, 43, 20, 3, -42 },
  { 12903, 30, 34, 35, 3, -33 },
  { 13031, 27, 33, 27, 3, -33 },
  { 13143, 41, 33, 42, 3, -33 },
  { 13313, 32, 33, 29, -2, -33 },
  { 13445, 37, 48, 27, -7, -33 },
  { 13667, 29, 33, 28, -1, -33 },
  { 13787, 22, 55, 21, 2, -45 },
  { 13939, 2, 63, 34, 18, -48 },
  { 13955, 23, 55, 21, -3, -45 },
  { 14114, 29, 6, 36, 5, -25 },
};

const GFXfont NotoSans_ExtraLightItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRALIGHTITALIC63PT7B_H_
