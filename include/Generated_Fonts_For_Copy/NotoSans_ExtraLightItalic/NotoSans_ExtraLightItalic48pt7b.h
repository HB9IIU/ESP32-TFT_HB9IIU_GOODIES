#ifndef _NOTOSANS_EXTRALIGHTITALIC48PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x38, 0x00, 0x38, 0x73, 0x06, 0x30,
  0x63, 0x06, 0x20, 0x46, 0x0C, 0x60, 0xC6, 0x0C, 0x40, 0x84, 0x08, 0x40,
  0x8C, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x10, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x30,
  0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0x80, 0x1E, 0x6F, 0xC0, 0x70, 0x81, 0x01, 0x81, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20, 0x00,
  0xC0, 0x40, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x84, 0x00, 0x03,
  0x88, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0x3C, 0x00, 0x02, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x40, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06,
  0x00, 0x0C, 0x18, 0x20, 0x10, 0x70, 0x78, 0x27, 0x80, 0x7F, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xE0, 0xC1, 0x80, 0x03, 0x06, 0x02, 0x00, 0x18, 0x18, 0x0C, 0x00,
  0xC0, 0xC0, 0x30, 0x06, 0x02, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x10, 0x04, 0x00, 0xC0, 0xC0, 0x30,
  0x02, 0x06, 0x00, 0xC0, 0x18, 0x30, 0x03, 0x00, 0x60, 0x80, 0x0C, 0x01,
  0x86, 0x1F, 0x30, 0x0C, 0x31, 0xFE, 0xC0, 0x31, 0x8E, 0x0F, 0x01, 0x86,
  0x30, 0x34, 0x06, 0x31, 0x80, 0x58, 0x71, 0x84, 0x01, 0x3F, 0x8C, 0x30,
  0x04, 0x38, 0x30, 0xC0, 0x10, 0x01, 0x82, 0x00, 0x40, 0x0C, 0x18, 0x03,
  0x00, 0x60, 0x60, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0,
  0x60, 0x10, 0x02, 0x01, 0x00, 0x40, 0x18, 0x0C, 0x01, 0x00, 0x60, 0x60,
  0x04, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x08, 0x00, 0x60, 0x60, 0x60, 0x00,
  0xC3, 0x03, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x10,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x31, 0xC0, 0x30,
  0x03, 0x1C, 0x01, 0xC0, 0x19, 0xC0, 0x06, 0x01, 0x8C, 0x00, 0x18, 0x0C,
  0x60, 0x00, 0x60, 0xC6, 0x00, 0x03, 0x0C, 0x30, 0x00, 0x0C, 0xC1, 0x80,
  0x00, 0x3E, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xD8, 0x0C, 0x00, 0x0C, 0x60, 0x30, 0x01, 0xC3, 0x00, 0xF0, 0x78, 0x0C,
  0x03, 0xFF, 0x00, 0x30, 0x39, 0x8C, 0x62, 0x31, 0x8C, 0x42, 0x11, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x80, 0x20, 0x0E,
  0x02, 0x00, 0x70, 0x20, 0x01, 0xC6, 0x00, 0x07, 0x40, 0x10, 0x1F, 0xFF,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x20, 0x00, 0x63, 0x00, 0x1C, 0x10,
  0x03, 0x81, 0x80, 0x70, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x1C, 0x30, 0x61, 0x83, 0x0E, 0x18, 0x20, 0xC1, 0x06,
  0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x60, 0x0E, 0x03,
  0x00, 0x18, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00,
  0x18, 0x1C, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x78, 0x70, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x1F, 0x03, 0xE0, 0xE6, 0x1C, 0x67, 0x06, 0xE0, 0x68,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1E,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x06, 0x03, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x01, 0xC0, 0xFC, 0x0F, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x10,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x30,
  0x0C, 0x00, 0x20, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x0F, 0xFF, 0x80, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x80, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xF8, 0x1F, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0x08,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x1F, 0xC0, 0x18, 0xFF,
  0xE0, 0x67, 0x00, 0xE0, 0xD8, 0x00, 0xE1, 0xE0, 0x00, 0xC3, 0x80, 0x01,
  0x86, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x84,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x38,
  0x03, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x38,
  0x00, 0xC0, 0x60, 0x00, 0x73, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xE3, 0x80, 0x07, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x38, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x1F, 0x0F, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x81, 0xC0,
  0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x8C, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x30, 0x01, 0xB0, 0x38, 0x0E,
  0x60, 0x3F, 0xF0, 0x80, 0x1F, 0x83, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x01, 0xC1, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x07, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xE0, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x0E, 0x07, 0x84,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x06, 0x18, 0x00, 0xFF, 0xE0, 0x33, 0x00, 0x3C,
  0x1C, 0x03, 0x30, 0x07, 0x00, 0xC0, 0x36, 0x00, 0xC0, 0x0C, 0x03, 0x60,
  0x18, 0x00, 0xC0, 0x34, 0x01, 0x80, 0x08, 0x03, 0xC0, 0x30, 0x01, 0x80,
  0x3C, 0x02, 0x00, 0x18, 0x03, 0xC0, 0x60, 0x01, 0x00, 0x2C, 0x06, 0x00,
  0x30, 0x06, 0x80, 0x60, 0x03, 0x00, 0x68, 0x06, 0x00, 0x30, 0x06, 0x80,
  0x40, 0x06, 0x00, 0xC8, 0x06, 0x00, 0x60, 0x0C, 0xC0, 0x60, 0x0A, 0x01,
  0x8C, 0x06, 0x01, 0xB0, 0x30, 0xC0, 0x30, 0x33, 0x06, 0x0C, 0x03, 0xFE,
  0x1F, 0xC0, 0x40, 0x0F, 0x80, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x08, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x10, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x60, 0x3F, 0x80, 0x18, 0x00, 0x78,
  0x06, 0x00, 0x06, 0x01, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x03, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x1E,
  0x00, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x07, 0x06, 0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x01, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x10, 0x01, 0xE0, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1E, 0x01,
  0x80, 0x01, 0xC0, 0x0C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xCC, 0x00, 0x1F, 0xFC, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0x7C, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC3, 0x80, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x38,
  0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0xCF, 0x80, 0x00, 0x0D, 0x98, 0x00, 0x00,
  0xF0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0x38, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x34, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x16,
  0x00, 0x00, 0x1B, 0x01, 0xB0, 0x00, 0x00, 0x98, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x66, 0x00, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x06, 0x60, 0x31, 0x80,
  0x00, 0x63, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x0C, 0x60, 0x00, 0x30, 0x80,
  0x61, 0x00, 0x03, 0x0C, 0x02, 0x0C, 0x00, 0x18, 0x60, 0x30, 0x60, 0x01,
  0x83, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x60,
  0xC0, 0x0C, 0x0C, 0x02, 0x02, 0x00, 0x60, 0x60, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x10, 0x0C, 0x02, 0x01, 0x81, 0x80, 0x60, 0x30, 0x04, 0x18, 0x03, 0x01,
  0x80, 0x30, 0xC0, 0x10, 0x0C, 0x01, 0x8C, 0x01, 0x80, 0x60, 0x0C, 0x60,
  0x0C, 0x06, 0x00, 0x66, 0x00, 0x60, 0x30, 0x03, 0x60, 0x03, 0x01, 0x80,
  0x0B, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x60, 0x03, 0x80, 0x0C,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x30, 0x0B, 0x00, 0x00, 0x60, 0x16, 0x00,
  0x00, 0xC0, 0x66, 0x00, 0x03, 0x00, 0xCC, 0x00, 0x06, 0x01, 0x88, 0x00,
  0x0C, 0x03, 0x18, 0x00, 0x18, 0x0C, 0x30, 0x00, 0x30, 0x18, 0x30, 0x00,
  0xC0, 0x30, 0x60, 0x01, 0x80, 0x60, 0x60, 0x03, 0x00, 0xC0, 0xC0, 0x06,
  0x03, 0x01, 0x80, 0x08, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x80, 0xC0, 0x04, 0x06, 0x01,
  0x80, 0x0C, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x06, 0x00, 0x18, 0x30, 0x08,
  0x00, 0x30, 0x60, 0x30, 0x00, 0x31, 0x80, 0x60, 0x00, 0x63, 0x00, 0xC0,
  0x00, 0xC6, 0x01, 0x80, 0x00, 0xCC, 0x06, 0x00, 0x01, 0x90, 0x0C, 0x00,
  0x01, 0xE0, 0x18, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x40, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x03, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0xFE, 0x00, 0x60, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x78, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xC0, 0xFE, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00,
  0xE0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x30, 0x00, 0x38, 0x18,
  0x00, 0x38, 0x0C, 0x00, 0x78, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x1F, 0x01, 0xC0, 0x02, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x80,
  0x03, 0x80, 0xF8, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x01, 0x00,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x02, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x01, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x10, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x18, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x06,
  0x0C, 0x00, 0x81, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x03, 0x01, 0x00, 0x60,
  0x40, 0x18, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02,
  0x03, 0x00, 0xC0, 0xC0, 0x10, 0x18, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x08, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x03, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0xD8, 0x00,
  0x13, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x05, 0x80, 0x01,
  0xE0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x02, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C,
  0x08, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x01, 0x03, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x04, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xC1, 0x83, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x40,
  0x81, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x81, 0x02, 0x06,
  0x0C, 0x18, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x00, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x62,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x40, 0x03, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x60, 0x08, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x60,
  0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x00,
  0x8C, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC3, 0x86, 0x0C, 0x30, 0x60, 0x83, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0x0C, 0x07, 0x03, 0x18, 0x38, 0x03, 0x20, 0x60, 0x02, 0xC1, 0x80,
  0x07, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3,
  0x00, 0x03, 0x82, 0x00, 0x07, 0x06, 0x00, 0x1E, 0x0C, 0x00, 0x68, 0x18,
  0x01, 0x90, 0x18, 0x06, 0x60, 0x1C, 0x78, 0xC0, 0x1F, 0xC1, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x03, 0xE0, 0x03, 0x1F, 0xF8, 0x06,
  0x38, 0x1C, 0x06, 0x60, 0x0C, 0x06, 0xC0, 0x06, 0x07, 0x80, 0x06, 0x05,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x68, 0x00, 0x30, 0x6C,
  0x00, 0x60, 0x66, 0x01, 0xC0, 0x47, 0x87, 0x80, 0xC1, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xFC, 0x0E, 0x01, 0x87, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x10, 0x1E, 0x1E, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0,
  0x30, 0x03, 0xFF, 0x08, 0x01, 0xC0, 0x66, 0x01, 0xC0, 0x0D, 0x80, 0x60,
  0x01, 0x60, 0x30, 0x00, 0x78, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x10,
  0x00, 0x3C, 0x06, 0x00, 0x0A, 0x01, 0x80, 0x04, 0x80, 0x60, 0x03, 0x60,
  0x0C, 0x03, 0x98, 0x01, 0xC3, 0x86, 0x00, 0x3F, 0xC1, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xF0, 0x0E, 0x03, 0x03, 0x80, 0x30, 0xC0, 0x06, 0x30, 0x00,
  0xCE, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x39, 0x80, 0x0E,
  0x60, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0x80, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x08, 0x1E, 0x0F, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0xC0, 0x38,
  0x0C, 0x40, 0x70, 0x03, 0x60, 0x30, 0x00, 0xB0, 0x30, 0x00, 0x78, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0E, 0x04, 0x00, 0x0F, 0x03, 0x00, 0x05, 0x01, 0x80, 0x05,
  0x80, 0xC0, 0x06, 0xC0, 0x30, 0x0E, 0x60, 0x0E, 0x1C, 0x30, 0x03, 0xFC,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x20, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x0F, 0x80, 0x18,
  0x7F, 0xC0, 0x63, 0x81, 0xC0, 0xCC, 0x01, 0x81, 0xB0, 0x01, 0x83, 0xC0,
  0x03, 0x05, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x86, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x70, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x87, 0x00,
  0x3F, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x40,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x04, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x21, 0x80, 0x01, 0x8E, 0x00, 0x06, 0xEC, 0x00, 0x1F,
  0x30, 0x00, 0x70, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x10, 0xFF,
  0x81, 0xFF, 0x01, 0x8C, 0x0C, 0x1C, 0x1C, 0x0C, 0xC0, 0x31, 0x80, 0x60,
  0x68, 0x01, 0x98, 0x01, 0x82, 0xC0, 0x05, 0x80, 0x0C, 0x14, 0x00, 0x28,
  0x00, 0x61, 0xC0, 0x01, 0xC0, 0x03, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x60,
  0x00, 0xE0, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x00,
  0x61, 0x80, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x60, 0x00,
  0xC0, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x61,
  0x80, 0x01, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC0,
  0x00, 0x83, 0x00, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x61, 0x80,
  0x01, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x00,
  0x86, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x04, 0x3F, 0xF0,
  0x18, 0xE0, 0x70, 0x33, 0x00, 0x70, 0x6C, 0x00, 0x60, 0xF0, 0x00, 0xC1,
  0x40, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x60,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x06, 0x00, 0x18,
  0x0C, 0x01, 0xC0, 0x1C, 0x1E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x20, 0xFF, 0x80, 0x18, 0xE0, 0x70, 0x06, 0x60, 0x0C, 0x01, 0xB0,
  0x01, 0x80, 0x78, 0x00, 0x60, 0x14, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x38,
  0x00, 0x18, 0x0E, 0x00, 0x06, 0x06, 0x80, 0x03, 0x01, 0xB0, 0x01, 0x80,
  0x66, 0x01, 0xC0, 0x19, 0xE1, 0xE0, 0x04, 0x1F, 0xE0, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xC3, 0x01, 0xC0, 0x62, 0x07, 0x00, 0x36, 0x06, 0x00,
  0x16, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x40, 0x00, 0xF0, 0x60, 0x00,
  0xA0, 0x60, 0x01, 0x60, 0x60, 0x03, 0x60, 0x30, 0x0E, 0x60, 0x1C, 0x38,
  0x60, 0x0F, 0xF0, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0x87, 0xF0, 0x63, 0x80, 0x19, 0x80, 0x06, 0xC0,
  0x01, 0xE0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xF0, 0xE0, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x62, 0x00, 0x30, 0xF0, 0x38, 0x1F, 0xFC, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x1F,
  0xFF, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x07, 0x08, 0x0F, 0xE0, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x00, 0x86, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x8C, 0x00, 0x04, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0xF0, 0xC0, 0x06, 0xC3, 0x00, 0x32, 0x0E, 0x01, 0x88, 0x1C, 0x3C,
  0x60, 0x3F, 0xC1, 0x80, 0xC0, 0x00, 0x3B, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x04, 0x00,
  0x60, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0x40, 0xC0, 0x02, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x05,
  0x80, 0x00, 0x2C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x50, 0x01, 0xB0, 0x03, 0x40,
  0x06, 0xC0, 0x09, 0x00, 0x33, 0x00, 0x64, 0x00, 0xCC, 0x01, 0x18, 0x06,
  0x30, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C,
  0x04, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x81, 0x83, 0x03, 0x06,
  0x06, 0x0C, 0x0C, 0x10, 0x08, 0x60, 0x10, 0xC0, 0x21, 0x80, 0x42, 0x00,
  0x84, 0x01, 0x18, 0x03, 0x30, 0x04, 0xC0, 0x0C, 0xC0, 0x13, 0x00, 0x36,
  0x00, 0x48, 0x00, 0xD8, 0x01, 0x60, 0x03, 0xC0, 0x05, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80,
  0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x03, 0x80, 0x01, 0x81, 0x80, 0x00, 0x61, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0xE0,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x03, 0x00, 0x04, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x30,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0xF8, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xCF, 0xC0, 0x38, 0x03, 0xC3, 0xA0,
  0x03, 0xFC,
};

const GFXglyph NotoSans_ExtraLightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 34, 11, 1, -34 },
  { 44, 12, 12, 16, 5, -34 },
  { 62, 28, 34, 30, 2, -34 },
  { 181, 23, 39, 26, 2, -36 },
  { 294, 30, 36, 37, 4, -35 },
  { 429, 29, 35, 33, 2, -35 },
  { 556, 5, 12, 9, 5, -34 },
  { 564, 13, 42, 12, 2, -34 },
  { 633, 14, 42, 12, -3, -34 },
  { 707, 20, 20, 26, 6, -36 },
  { 757, 22, 22, 27, 4, -28 },
  { 818, 7, 12, 10, -2, -6 },
  { 829, 11, 2, 15, 2, -14 },
  { 832, 4, 3, 11, 1, -3 },
  { 834, 21, 34, 15, -2, -34 },
  { 924, 22, 35, 26, 3, -35 },
  { 1021, 12, 34, 26, 8, -34 },
  { 1072, 25, 35, 26, 0, -35 },
  { 1182, 24, 35, 26, 1, -35 },
  { 1287, 24, 34, 26, 1, -34 },
  { 1389, 24, 34, 26, 2, -34 },
  { 1491, 23, 35, 26, 3, -35 },
  { 1592, 22, 34, 26, 5, -34 },
  { 1686, 24, 35, 26, 2, -35 },
  { 1791, 23, 35, 26, 2, -35 },
  { 1892, 8, 26, 11, 1, -26 },
  { 1918, 11, 32, 11, -2, -26 },
  { 1962, 22, 22, 27, 4, -28 },
  { 2023, 22, 12, 27, 4, -23 },
  { 2056, 22, 22, 27, 4, -28 },
  { 2117, 17, 35, 20, 4, -35 },
  { 2192, 36, 38, 40, 3, -34 },
  { 2363, 26, 34, 26, -2, -34 },
  { 2474, 26, 34, 29, 2, -34 },
  { 2585, 26, 35, 28, 4, -35 },
  { 2699, 29, 34, 32, 2, -34 },
  { 2823, 25, 34, 25, 2, -34 },
  { 2930, 25, 34, 23, 2, -34 },
  { 3037, 28, 35, 33, 4, -35 },
  { 3160, 31, 34, 33, 2, -34 },
  { 3292, 16, 34, 14, 0, -34 },
  { 3360, 20, 43, 12, -8, -34 },
  { 3468, 28, 34, 26, 2, -34 },
  { 3587, 18, 34, 23, 2, -34 },
  { 3664, 37, 34, 39, 2, -34 },
  { 3822, 31, 34, 33, 2, -34 },
  { 3954, 29, 35, 34, 4, -35 },
  { 4081, 25, 34, 27, 2, -34 },
  { 4188, 29, 43, 34, 4, -35 },
  { 4344, 25, 34, 27, 2, -34 },
  { 4451, 24, 35, 24, 1, -35 },
  { 4556, 24, 34, 23, 4, -34 },
  { 4658, 29, 34, 33, 4, -34 },
  { 4782, 25, 34, 26, 5, -34 },
  { 4889, 37, 34, 40, 6, -34 },
  { 5047, 31, 34, 24, -3, -34 },
  { 5179, 23, 34, 24, 5, -34 },
  { 5277, 27, 34, 26, 0, -34 },
  { 5392, 18, 42, 14, 0, -34 },
  { 5487, 7, 34, 15, 5, -34 },
  { 5517, 18, 42, 14, -3, -34 },
  { 5612, 22, 22, 27, 2, -35 },
  { 5673, 18, 2, 18, -4, 5 },
  { 5678, 6, 8, 11, 7, -37 },
  { 5684, 23, 26, 26, 2, -26 },
  { 5759, 24, 36, 27, 1, -36 },
  { 5867, 19, 26, 22, 3, -26 },
  { 5929, 26, 36, 27, 2, -36 },
  { 6046, 19, 26, 24, 3, -26 },
  { 6108, 26, 49, 13, -6, -37 },
  { 6268, 25, 38, 27, 1, -26 },
  { 6387, 23, 36, 27, 1, -36 },
  { 6491, 10, 35, 10, 1, -35 },
  { 6535, 18, 47, 10, -7, -35 },
  { 6641, 22, 36, 22, 1, -36 },
  { 6740, 10, 36, 10, 1, -36 },
  { 6785, 37, 26, 41, 1, -26 },
  { 6906, 23, 26, 27, 1, -26 },
  { 6981, 22, 26, 27, 3, -26 },
  { 7053, 26, 37, 27, -1, -26 },
  { 7174, 24, 37, 27, 2, -26 },
  { 7285, 18, 26, 18, 1, -26 },
  { 7344, 18, 26, 20, 1, -26 },
  { 7403, 14, 32, 15, 2, -32 },
  { 7459, 22, 25, 27, 3, -25 },
  { 7528, 21, 25, 20, 2, -25 },
  { 7594, 30, 25, 32, 3, -25 },
  { 7688, 25, 25, 22, -2, -25 },
  { 7767, 28, 37, 20, -5, -25 },
  { 7897, 22, 25, 21, -1, -25 },
  { 7966, 18, 42, 16, 1, -34 },
  { 8061, 2, 48, 26, 13, -36 },
  { 8073, 17, 42, 16, -2, -34 },
  { 8163, 22, 4, 27, 4, -19 },
};

const GFXfont NotoSans_ExtraLightItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRALIGHTITALIC48PT7B_H_
