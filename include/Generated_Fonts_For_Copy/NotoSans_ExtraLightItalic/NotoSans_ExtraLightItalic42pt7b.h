#ifndef _NOTOSANS_EXTRALIGHTITALIC42PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x07, 0x00, 0x20,
  0xB0, 0xD8, 0x6C, 0x34, 0x12, 0x0B, 0x0D, 0x86, 0x82, 0x41, 0x20, 0x80,
  0x00, 0x08, 0x04, 0x00, 0x04, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x40,
  0x20, 0x00, 0x20, 0x10, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x08,
  0x04, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x0F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00,
  0x0C, 0x06, 0x00, 0x04, 0x02, 0x00, 0x02, 0x01, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x3C,
  0x8F, 0x07, 0x08, 0x20, 0xC0, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x80, 0x08,
  0x10, 0x00, 0x81, 0x00, 0x08, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x20, 0x00,
  0x3A, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x6E, 0x00, 0x04, 0x30,
  0x00, 0x41, 0x80, 0x04, 0x18, 0x00, 0xC0, 0x80, 0x0C, 0x18, 0x00, 0x81,
  0x80, 0x08, 0x10, 0x00, 0x83, 0x08, 0x18, 0xE0, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0xC0, 0x01, 0x86, 0x18, 0x00, 0xC3, 0x02, 0x00, 0x60, 0x80, 0xC0, 0x10,
  0x60, 0x30, 0x0C, 0x10, 0x0C, 0x06, 0x04, 0x03, 0x03, 0x03, 0x00, 0x80,
  0x80, 0xC0, 0x20, 0x60, 0x20, 0x08, 0x30, 0x08, 0x06, 0x18, 0x02, 0x01,
  0x84, 0x00, 0x80, 0x43, 0x1F, 0x20, 0x31, 0x8C, 0x68, 0x08, 0xC6, 0x0F,
  0x06, 0x23, 0x03, 0xC3, 0x18, 0x80, 0x5F, 0x8C, 0x60, 0x10, 0x06, 0x18,
  0x04, 0x01, 0x04, 0x03, 0x00, 0xC3, 0x00, 0xC0, 0x60, 0xC0, 0x30, 0x10,
  0x30, 0x08, 0x08, 0x0C, 0x02, 0x06, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x40,
  0x80, 0x30, 0x30, 0x60, 0x0C, 0x08, 0x30, 0x01, 0x8E, 0x18, 0x00, 0x3F,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x30, 0x70, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x06, 0x00, 0x10, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x40, 0x03, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x10, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x18, 0x01, 0x98, 0x06, 0x00,
  0x98, 0x01, 0x00, 0xCC, 0x00, 0xC0, 0xCC, 0x00, 0x30, 0x66, 0x00, 0x0C,
  0x63, 0x00, 0x02, 0x61, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x78, 0x30, 0x00, 0x6C, 0x0C, 0x00, 0xE3, 0x03, 0x81, 0xC0, 0xC0, 0xFF,
  0x80, 0x70, 0x2D, 0xB4, 0xB6, 0x92, 0x00, 0x00, 0x38, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x80, 0x40, 0x38, 0x10, 0x03, 0x84, 0x00, 0x33, 0x00, 0x03, 0x8F,
  0xC0, 0x3F, 0xC0, 0x3C, 0x00, 0x19, 0x00, 0x0C, 0x60, 0x06, 0x08, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C,
  0x30, 0xC6, 0x18, 0xC3, 0x08, 0x63, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x30, 0x70, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x24, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x34, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x58, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00,
  0x09, 0x00, 0x03, 0x20, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0xC1, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x87, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xC0, 0x70, 0x7C, 0x33, 0x38, 0x98, 0x2C, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0x83, 0x80, 0x70, 0x06, 0x02, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x0F,
  0x07, 0x01, 0xC0, 0x0C, 0x08, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x61, 0x00, 0x06, 0x0F, 0x01, 0xE0,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x01, 0x8C,
  0x00, 0x18, 0x60, 0x01, 0x82, 0x00, 0x18, 0x10, 0x01, 0x81, 0x80, 0x18,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x0C, 0x00, 0x10, 0x7F, 0xFF,
  0xFC, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0xBF, 0x80, 0x0F, 0xDF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x1C, 0x0E,
  0x03, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0x81, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x02, 0x00, 0x63,
  0xFE, 0x06, 0x60, 0x70, 0x58, 0x01, 0x8F, 0x00, 0x18, 0xE0, 0x00, 0x8C,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x08,
  0x80, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x60, 0x06,
  0x06, 0x00, 0xC0, 0x38, 0x38, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1C, 0x0E, 0x03, 0x00, 0x60, 0x20, 0x03, 0x06, 0x00, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x30, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x30, 0x1C, 0x01, 0x87, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x38, 0xC0, 0x0E, 0x07, 0x03, 0x80, 0x30, 0x30, 0x01, 0x86, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x18, 0x60, 0x01, 0x87, 0x00, 0x70, 0x38, 0x1E, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0xC0, 0x60, 0x06,
  0x0C, 0x00, 0x21, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x73, 0x00,
  0x06, 0x18, 0x00, 0xA1, 0x80, 0x1E, 0x0E, 0x06, 0x60, 0x7F, 0xC4, 0x00,
  0x40, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x80, 0xE0, 0x0F, 0xF8, 0x00, 0x04, 0x0C, 0x38, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x1C,
  0x38, 0x00, 0x00, 0x80, 0x30, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x70,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x02, 0x18, 0x01, 0xFE, 0x03, 0x30, 0x07,
  0x03, 0x03, 0x30, 0x0C, 0x02, 0x03, 0x20, 0x18, 0x02, 0x01, 0x60, 0x30,
  0x06, 0x03, 0x60, 0x20, 0x06, 0x03, 0x40, 0x60, 0x04, 0x03, 0x40, 0x40,
  0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x02, 0xC0, 0xC0, 0x08, 0x06, 0xC0, 0xC0,
  0x18, 0x06, 0xC0, 0xC0, 0x18, 0x04, 0xC0, 0xC0, 0x38, 0x0C, 0xC0, 0x40,
  0x68, 0x18, 0x40, 0x60, 0xCC, 0x30, 0x60, 0x3F, 0x87, 0xE0, 0x60, 0x04,
  0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x01, 0x80, 0x80, 0x03, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x10, 0x0F, 0xFF, 0xE0, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06, 0x18, 0x00, 0x04, 0x60, 0x00,
  0x08, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x30, 0x01, 0x80, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x08, 0x00,
  0x70, 0x60, 0x3F, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0x70, 0x18, 0x00, 0x60,
  0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x10, 0xC0,
  0x00, 0x42, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01,
  0x84, 0x00, 0x0C, 0x10, 0x00, 0xE0, 0xC0, 0x7F, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x02, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0xC0, 0x0E, 0x00, 0x40, 0x03, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00, 0x01, 0x06, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x02, 0x18, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x43, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x70, 0x08, 0x00, 0xF0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3C, 0x07,
  0xC0, 0x38, 0x00, 0x40, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFC, 0x40, 0x07, 0xFE, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x02, 0x00, 0xF0, 0x1F,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20,
  0x60, 0x00, 0x18, 0x10, 0x00, 0x06, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x08, 0x18, 0x00, 0x06, 0x04,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x08, 0x18, 0x00, 0x06, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x10, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x10, 0x60, 0x0F, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x81, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0x40, 0x03, 0x00, 0x60, 0x07, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x08, 0x06, 0x00, 0x04, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0x8E, 0x00, 0x00, 0xCF,
  0x00, 0x00, 0x6D, 0x80, 0x00, 0x3C, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0x80, 0x10, 0x00, 0x60, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x02, 0x80, 0x00,
  0x0E, 0x02, 0x80, 0x00, 0x1A, 0x06, 0x80, 0x00, 0x1E, 0x06, 0xC0, 0x00,
  0x36, 0x06, 0xC0, 0x00, 0x26, 0x04, 0xC0, 0x00, 0x64, 0x04, 0x40, 0x00,
  0xC4, 0x0C, 0x40, 0x00, 0xCC, 0x0C, 0x40, 0x01, 0x8C, 0x0C, 0x60, 0x01,
  0x0C, 0x08, 0x60, 0x03, 0x08, 0x18, 0x60, 0x06, 0x08, 0x18, 0x20, 0x06,
  0x18, 0x18, 0x20, 0x0C, 0x18, 0x10, 0x20, 0x08, 0x18, 0x10, 0x30, 0x18,
  0x10, 0x30, 0x30, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x60,
  0x30, 0x20, 0x10, 0x40, 0x20, 0x20, 0x10, 0xC0, 0x20, 0x60, 0x18, 0x80,
  0x60, 0x60, 0x19, 0x80, 0x60, 0x60, 0x1B, 0x00, 0x60, 0x40, 0x0B, 0x00,
  0x40, 0x40, 0x0E, 0x00, 0x40, 0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x38, 0x00, 0x0C, 0x0A,
  0x00, 0x03, 0x06, 0xC0, 0x00, 0xC1, 0xB0, 0x00, 0x20, 0x64, 0x00, 0x18,
  0x11, 0x80, 0x06, 0x04, 0x20, 0x01, 0x83, 0x0C, 0x00, 0x40, 0xC3, 0x00,
  0x10, 0x30, 0x60, 0x0C, 0x08, 0x18, 0x03, 0x06, 0x02, 0x00, 0xC1, 0x80,
  0xC0, 0x20, 0x60, 0x10, 0x08, 0x18, 0x06, 0x06, 0x04, 0x01, 0x81, 0x83,
  0x00, 0x30, 0x60, 0xC0, 0x0C, 0x10, 0x30, 0x01, 0x0C, 0x08, 0x00, 0x63,
  0x02, 0x00, 0x08, 0xC1, 0x80, 0x03, 0x30, 0x60, 0x00, 0xC8, 0x18, 0x00,
  0x12, 0x04, 0x00, 0x07, 0x81, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x18, 0x00,
  0xE0, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x03,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x30,
  0x07, 0x00, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x20, 0x60, 0x00,
  0x81, 0x00, 0x03, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x08, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x0E, 0x06, 0x00,
  0xE0, 0x1F, 0xFE, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x18,
  0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x70, 0x03, 0x80, 0x0F,
  0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x30,
  0x07, 0x00, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x20, 0x60, 0x00,
  0x81, 0x00, 0x03, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x08, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x1C, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x40, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60,
  0x03, 0x01, 0x80, 0x06, 0x04, 0x00, 0x18, 0x10, 0x00, 0x20, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xE0, 0x1E, 0x07, 0x03, 0x00, 0x10,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x08,
  0x00, 0x60, 0xE0, 0x3C, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x01, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x30,
  0x00, 0x02, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18,
  0x40, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x18, 0x00, 0x30, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x80, 0x01,
  0x86, 0x00, 0x04, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x06, 0x02,
  0x00, 0x30, 0x08, 0x00, 0xC0, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x0C, 0x02, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x01, 0x03, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x60, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xE0,
  0x00, 0xC0, 0x01, 0xB0, 0x00, 0x70, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x4C,
  0x00, 0x2C, 0x00, 0x66, 0x00, 0x36, 0x00, 0x23, 0x00, 0x13, 0x00, 0x31,
  0x80, 0x19, 0x80, 0x10, 0xC0, 0x08, 0xC0, 0x18, 0x20, 0x0C, 0x60, 0x0C,
  0x10, 0x04, 0x30, 0x0C, 0x08, 0x06, 0x08, 0x06, 0x04, 0x02, 0x04, 0x06,
  0x02, 0x03, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x00, 0x81, 0x80, 0x81,
  0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0xC0, 0x20, 0xC0, 0x18, 0x60, 0x18,
  0x40, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x01, 0x98, 0x01, 0x98, 0x00, 0xD8, 0x00, 0xC8, 0x00, 0x6C, 0x00,
  0x6C, 0x00, 0x34, 0x00, 0x34, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x08, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x04, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x04, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30,
  0x08, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x30, 0x30, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0x40, 0x00, 0x66, 0x00, 0x0C, 0x60,
  0x01, 0x82, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x04, 0x01,
  0x00, 0xC0, 0x18, 0x18, 0x01, 0x83, 0x00, 0x08, 0x30, 0x00, 0xC6, 0x00,
  0x0C, 0xC0, 0x00, 0x48, 0x00, 0x05, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xC1, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xC1, 0x83, 0x02,
  0x04, 0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x10,
  0x20, 0x60, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xD0,
  0x00, 0x1B, 0x00, 0x06, 0x20, 0x01, 0x84, 0x00, 0x30, 0xC0, 0x0C, 0x08,
  0x01, 0x01, 0x00, 0x60, 0x30, 0x18, 0x06, 0x02, 0x00, 0x40, 0xC0, 0x0C,
  0x30, 0x01, 0x84, 0x00, 0x11, 0x80, 0x03, 0x60, 0x00, 0x78, 0x00, 0x04,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xC3, 0x18, 0x61, 0x0C, 0x20, 0x00, 0x78,
  0x00, 0x1F, 0xE3, 0x07, 0x03, 0x20, 0xE0, 0x12, 0x0C, 0x00, 0xA1, 0x80,
  0x0E, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40,
  0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x05, 0x06, 0x00, 0xB0,
  0x60, 0x33, 0x03, 0x06, 0x20, 0x1F, 0xC2, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x30, 0x01, 0x0F,
  0xF0, 0x08, 0xC1, 0xC0, 0xC8, 0x03, 0x06, 0x80, 0x18, 0x38, 0x00, 0x41,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x80, 0x03, 0x1C, 0x00, 0x10, 0xE0, 0x01, 0x85, 0x80, 0x18,
  0x24, 0x01, 0x81, 0x38, 0x38, 0x18, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xC1, 0xE0, 0x21, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x3F, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0xE0,
  0x40, 0x1F, 0xE1, 0x01, 0xC0, 0xCC, 0x0E, 0x00, 0xB0, 0x70, 0x03, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x30,
  0x01, 0xE0, 0x60, 0x0D, 0x01, 0x80, 0x64, 0x03, 0x07, 0x10, 0x07, 0xF0,
  0xC0, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0xE0, 0xE0, 0xC0, 0x30, 0xC0, 0x08,
  0xC0, 0x04, 0xC0, 0x02, 0x60, 0x03, 0x20, 0x03, 0x30, 0x03, 0x18, 0x0F,
  0x0F, 0xFE, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x60,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x88, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x9C, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x40, 0xE0, 0x62, 0x0E,
  0x00, 0xB0, 0xE0, 0x07, 0x86, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0E, 0x18, 0x00, 0xF0, 0x60, 0x0D, 0x03, 0x00, 0xC8, 0x0C, 0x1C,
  0xC0, 0x3F, 0x86, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x02, 0x00, 0x60,
  0x1F, 0x3E, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x70, 0x04, 0x3F, 0xC0, 0x46, 0x06,
  0x0C, 0x80, 0x30, 0xD0, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00,
  0x31, 0x80, 0x03, 0x18, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x61, 0x00,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0x42, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x8C,
  0x00, 0x18, 0x03, 0x81, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x9C, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x82, 0x00,
  0x60, 0xC0, 0x18, 0x18, 0x0E, 0x03, 0x03, 0x00, 0x40, 0xC0, 0x08, 0x30,
  0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x3C, 0x00, 0x2C, 0x80,
  0x0F, 0x18, 0x01, 0xC1, 0x00, 0x30, 0x30, 0x04, 0x02, 0x01, 0x80, 0x60,
  0x30, 0x04, 0x06, 0x00, 0xC0, 0x80, 0x08, 0x10, 0x01, 0x86, 0x00, 0x18,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x78, 0x04, 0x3F, 0x81, 0xFE, 0x04, 0xC0, 0xC3, 0x06,
  0x0D, 0x80, 0xC4, 0x03, 0x0D, 0x00, 0x48, 0x03, 0x0A, 0x00, 0x70, 0x01,
  0x0C, 0x00, 0x70, 0x01, 0x0C, 0x00, 0x60, 0x03, 0x18, 0x00, 0x60, 0x03,
  0x18, 0x00, 0x40, 0x03, 0x18, 0x00, 0xC0, 0x02, 0x10, 0x00, 0xC0, 0x02,
  0x10, 0x00, 0xC0, 0x06, 0x30, 0x00, 0x80, 0x06, 0x30, 0x00, 0x80, 0x06,
  0x30, 0x01, 0x80, 0x04, 0x20, 0x01, 0x80, 0x04, 0x60, 0x01, 0x80, 0x0C,
  0x60, 0x01, 0x00, 0x0C, 0x60, 0x03, 0x00, 0x0C, 0x40, 0x03, 0x00, 0x08,
  0x40, 0x03, 0x00, 0x18, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x07, 0x00, 0x43,
  0xFC, 0x04, 0x60, 0x60, 0xD8, 0x03, 0x0D, 0x00, 0x30, 0xE0, 0x03, 0x0E,
  0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x18, 0x00, 0x21,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x04,
  0x20, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x40, 0x01,
  0x84, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1C,
  0x06, 0x07, 0x00, 0x61, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x09, 0x00,
  0x01, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02, 0xC0, 0x00, 0xC8, 0x00,
  0x11, 0x80, 0x06, 0x30, 0x01, 0x83, 0x00, 0x60, 0x38, 0x38, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x02, 0x1F, 0xE0, 0x04, 0x60, 0xE0, 0x19, 0x00,
  0x60, 0x34, 0x00, 0xC0, 0x70, 0x00, 0x80, 0xE0, 0x01, 0x81, 0x80, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C,
  0x00, 0x18, 0x38, 0x00, 0x20, 0x70, 0x00, 0xC0, 0xF0, 0x03, 0x01, 0x20,
  0x0C, 0x02, 0x70, 0x70, 0x0C, 0x3F, 0x80, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0xE1, 0x07, 0x03, 0x10, 0xE0, 0x0B, 0x1C, 0x00,
  0xF1, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x40, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x07, 0x86,
  0x00, 0xD8, 0x60, 0x19, 0x03, 0x07, 0x30, 0x1F, 0xC3, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x04, 0x3F, 0x04, 0xE0, 0x0D, 0x80, 0x0D, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x01,
  0xFF, 0xC1, 0x80, 0x61, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x88, 0x00, 0xC7, 0x81, 0xC0, 0xFF, 0x80, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0xFF, 0xF0, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x61, 0x07, 0xF0, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x21,
  0x80, 0x02, 0x10, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x04,
  0x20, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0x84, 0x00, 0x18, 0x40, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00,
  0x50, 0xC0, 0x09, 0x06, 0x01, 0xB0, 0x70, 0x63, 0x03, 0xFC, 0x20, 0xC0,
  0x00, 0xF0, 0x00, 0x6C, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x06, 0x18, 0x01,
  0x06, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x18, 0x08, 0x0C, 0x02, 0x03, 0x00,
  0x81, 0x80, 0x30, 0x40, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x13,
  0x00, 0x04, 0xC0, 0x01, 0x60, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x78, 0x01, 0xC0, 0x0B, 0x00, 0x38, 0x03, 0x20,
  0x0F, 0x00, 0x64, 0x01, 0x60, 0x18, 0x80, 0x64, 0x03, 0x10, 0x08, 0x80,
  0xC2, 0x03, 0x10, 0x18, 0x40, 0x42, 0x06, 0x08, 0x18, 0x40, 0xC1, 0x02,
  0x0C, 0x30, 0x30, 0xC1, 0x86, 0x06, 0x30, 0x30, 0x80, 0xC6, 0x06, 0x30,
  0x19, 0x80, 0xC4, 0x03, 0x30, 0x19, 0x80, 0x6C, 0x01, 0x20, 0x0D, 0x80,
  0x2C, 0x01, 0xA0, 0x05, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x38, 0x30, 0x01, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x10, 0x18, 0x00, 0xC1, 0x80, 0x02, 0x18, 0x00, 0x19,
  0x80, 0x00, 0x58, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x0D, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0x20, 0x00, 0xC1, 0x80, 0x0C, 0x04,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x06, 0x06, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x20, 0x01, 0x80,
  0x10, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x20, 0x00, 0x40, 0x30, 0x00, 0x20, 0x10, 0x00, 0x10, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x22, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x02,
  0x38, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x7C, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xC0, 0x0C, 0x00,
  0x00, 0x1F, 0x00, 0x2F, 0xF8, 0x07, 0x01, 0xE3, 0xC0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 30, 9, 1, -30 },
  { 35, 9, 11, 14, 5, -30 },
  { 48, 25, 30, 26, 1, -30 },
  { 142, 20, 34, 23, 2, -32 },
  { 227, 26, 31, 32, 4, -30 },
  { 328, 25, 30, 29, 2, -30 },
  { 422, 3, 11, 8, 5, -30 },
  { 427, 13, 37, 11, 1, -30 },
  { 488, 12, 37, 11, -3, -30 },
  { 544, 18, 18, 22, 5, -32 },
  { 585, 20, 20, 24, 3, -25 },
  { 635, 6, 10, 8, -2, -5 },
  { 643, 10, 1, 13, 2, -12 },
  { 645, 3, 3, 9, 1, -3 },
  { 647, 19, 30, 13, -2, -30 },
  { 719, 19, 30, 23, 3, -30 },
  { 791, 10, 30, 23, 7, -30 },
  { 829, 21, 30, 23, 0, -30 },
  { 908, 21, 30, 23, 1, -30 },
  { 987, 21, 30, 23, 1, -30 },
  { 1066, 21, 30, 23, 2, -30 },
  { 1145, 20, 30, 23, 3, -30 },
  { 1220, 20, 30, 23, 4, -30 },
  { 1295, 20, 30, 23, 2, -30 },
  { 1370, 20, 30, 23, 2, -30 },
  { 1445, 7, 23, 9, 1, -23 },
  { 1466, 10, 28, 9, -2, -23 },
  { 1501, 19, 19, 24, 3, -25 },
  { 1547, 19, 10, 24, 3, -20 },
  { 1571, 19, 19, 24, 3, -25 },
  { 1617, 15, 30, 17, 3, -30 },
  { 1674, 32, 34, 35, 2, -30 },
  { 1810, 23, 30, 23, -2, -30 },
  { 1897, 22, 30, 25, 2, -30 },
  { 1980, 24, 30, 25, 3, -30 },
  { 2070, 25, 30, 28, 2, -30 },
  { 2164, 21, 30, 22, 2, -30 },
  { 2243, 21, 30, 20, 2, -30 },
  { 2322, 25, 30, 29, 3, -30 },
  { 2416, 26, 30, 29, 2, -30 },
  { 2514, 14, 30, 12, 0, -30 },
  { 2567, 17, 37, 10, -7, -30 },
  { 2646, 25, 30, 23, 2, -30 },
  { 2740, 15, 30, 21, 2, -30 },
  { 2797, 32, 30, 34, 2, -30 },
  { 2917, 26, 30, 29, 2, -30 },
  { 3015, 26, 30, 30, 3, -30 },
  { 3113, 22, 30, 24, 2, -30 },
  { 3196, 26, 37, 30, 3, -30 },
  { 3317, 22, 30, 24, 2, -30 },
  { 3400, 20, 30, 21, 1, -30 },
  { 3475, 20, 30, 21, 4, -30 },
  { 3550, 25, 30, 29, 4, -30 },
  { 3644, 22, 30, 23, 4, -30 },
  { 3727, 33, 30, 35, 5, -30 },
  { 3851, 26, 30, 21, -2, -30 },
  { 3949, 20, 30, 21, 4, -30 },
  { 4024, 24, 30, 23, 0, -30 },
  { 4114, 16, 37, 13, 0, -30 },
  { 4188, 7, 30, 13, 4, -30 },
  { 4215, 16, 37, 13, -3, -30 },
  { 4289, 19, 18, 23, 2, -30 },
  { 4332, 17, 2, 16, -4, 4 },
  { 4337, 5, 7, 10, 6, -32 },
  { 4342, 20, 23, 23, 2, -23 },
  { 4400, 21, 32, 24, 1, -32 },
  { 4484, 17, 23, 19, 2, -23 },
  { 4533, 22, 32, 24, 2, -32 },
  { 4621, 17, 23, 21, 2, -23 },
  { 4670, 23, 42, 12, -5, -32 },
  { 4791, 21, 33, 24, 1, -23 },
  { 4878, 20, 32, 23, 1, -32 },
  { 4958, 9, 30, 9, 1, -30 },
  { 4992, 16, 40, 9, -6, -30 },
  { 5072, 19, 32, 19, 1, -32 },
  { 5148, 9, 32, 9, 1, -32 },
  { 5184, 32, 23, 36, 1, -23 },
  { 5276, 20, 23, 23, 1, -23 },
  { 5334, 19, 23, 24, 2, -23 },
  { 5389, 23, 33, 24, -1, -23 },
  { 5484, 20, 33, 24, 2, -23 },
  { 5567, 16, 23, 16, 1, -23 },
  { 5613, 17, 23, 18, 0, -23 },
  { 5662, 12, 28, 13, 2, -28 },
  { 5704, 20, 22, 23, 2, -22 },
  { 5759, 18, 22, 18, 2, -22 },
  { 5809, 27, 22, 28, 2, -22 },
  { 5884, 21, 22, 19, -1, -22 },
  { 5942, 25, 32, 18, -5, -22 },
  { 6042, 19, 22, 18, -1, -22 },
  { 6095, 15, 37, 14, 1, -30 },
  { 6165, 1, 42, 23, 12, -32 },
  { 6171, 15, 37, 14, -2, -30 },
  { 6241, 19, 4, 24, 3, -17 },
};

const GFXfont NotoSans_ExtraLightItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRALIGHTITALIC42PT7B_H_
