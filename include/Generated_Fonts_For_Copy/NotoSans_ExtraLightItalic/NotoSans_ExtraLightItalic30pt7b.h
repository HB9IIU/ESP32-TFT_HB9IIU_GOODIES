#ifndef _NOTOSANS_EXTRALIGHTITALIC30PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x00, 0x00, 0x30, 0xC0, 0x22, 0xC5, 0x0A, 0x24, 0x48, 0xA1, 0x00,
  0x00, 0x83, 0x00, 0x20, 0x80, 0x18, 0x20, 0x04, 0x08, 0x01, 0x04, 0x00,
  0x41, 0x03, 0xFF, 0xFC, 0x08, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00, 0x40,
  0x80, 0x10, 0x40, 0x04, 0x10, 0x3F, 0xFF, 0xC0, 0x82, 0x00, 0x20, 0x80,
  0x10, 0x20, 0x04, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0xFF, 0x0C, 0x44, 0x21, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x62, 0x00, 0xC8, 0x01, 0xC0, 0x01, 0xC0, 0x05,
  0xC0, 0x11, 0x00, 0x46, 0x02, 0x18, 0x08, 0x40, 0x21, 0x20, 0x88, 0xFF,
  0xC0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x46, 0x60,
  0x11, 0x84, 0x04, 0x20, 0x81, 0x0C, 0x10, 0x61, 0x02, 0x08, 0x20, 0x42,
  0x04, 0x08, 0x80, 0x83, 0x10, 0x10, 0x44, 0xF2, 0x09, 0x31, 0x42, 0x64,
  0x2C, 0x89, 0x06, 0x62, 0x20, 0xC0, 0x88, 0x10, 0x31, 0x02, 0x04, 0x20,
  0x41, 0x04, 0x08, 0x40, 0x82, 0x18, 0x10, 0x42, 0x02, 0x10, 0x80, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x67, 0x00, 0x20, 0x40, 0x18, 0x10, 0x04, 0x06,
  0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x20, 0x02, 0x30, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x32, 0x00, 0x10, 0x40, 0x48, 0x18, 0x34, 0x02, 0x09, 0x00,
  0x44, 0xC0, 0x1B, 0x20, 0x03, 0x8C, 0x00, 0xC1, 0x00, 0x68, 0x60, 0x63,
  0x0F, 0xF0, 0x60, 0x2D, 0x24, 0xA0, 0x03, 0x81, 0x01, 0x01, 0x00, 0x80,
  0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0x00,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80,
  0xC0, 0x40, 0x40, 0x40, 0x60, 0x00, 0x03, 0x00, 0x20, 0x02, 0x08, 0x20,
  0xC2, 0x03, 0x40, 0x0F, 0xF0, 0xC0, 0x12, 0x02, 0x20, 0xC1, 0x04, 0x10,
  0x01, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x3F, 0xFF, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x32, 0x24, 0x48, 0x80, 0xFE, 0xF0, 0x00, 0x18, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x18, 0xC0,
  0xC0, 0x86, 0x02, 0x30, 0x0C, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x05,
  0x00, 0x3C, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0xA0, 0x04,
  0x80, 0x12, 0x00, 0xC8, 0x02, 0x10, 0x10, 0x60, 0x80, 0xFC, 0x00, 0x06,
  0x34, 0xCE, 0x38, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x60, 0x81, 0x02, 0x00, 0x00, 0x70, 0x07, 0x18, 0x18, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xE0, 0x0E, 0x30, 0x60, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x1F, 0x80, 0x47, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x88, 0x06, 0x0F, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0A,
  0x00, 0x1A, 0x00, 0x36, 0x00, 0x64, 0x00, 0x44, 0x00, 0x84, 0x01, 0x0C,
  0x02, 0x08, 0x04, 0x08, 0x08, 0x08, 0x18, 0x08, 0x30, 0x18, 0x60, 0x10,
  0x7F, 0xFF, 0x80, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x17, 0xC0, 0x30, 0xE0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC4, 0x03, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0x10, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x1F, 0x85,
  0x83, 0x18, 0x04, 0xC0, 0x1B, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x12,
  0x00, 0x4C, 0x03, 0x10, 0x08, 0x60, 0xC0, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x06, 0x30, 0x10, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x84,
  0x02, 0x04, 0x08, 0x0C, 0x60, 0x07, 0x00, 0x36, 0x01, 0x83, 0x04, 0x03,
  0x10, 0x02, 0x20, 0x04, 0xC0, 0x09, 0x80, 0x11, 0x00, 0x22, 0x00, 0x82,
  0x02, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x0E, 0x30, 0x30, 0x30, 0xC0, 0x21,
  0x00, 0x46, 0x00, 0xC8, 0x00, 0x90, 0x03, 0x20, 0x06, 0x40, 0x08, 0x80,
  0x30, 0x80, 0xA1, 0x86, 0x40, 0xF1, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x18, 0x1F, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x0E, 0x0F, 0x30, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x0E, 0x01, 0x80, 0x60, 0x01, 0x02, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0x80, 0x00, 0x16, 0x03, 0xF0, 0x50, 0x30, 0x41, 0x41, 0x81,
  0x06, 0x0C, 0x04, 0x18, 0x20, 0x20, 0x60, 0x80, 0x81, 0x86, 0x02, 0x06,
  0x10, 0x18, 0x28, 0x40, 0x40, 0xA0, 0x82, 0x84, 0x83, 0x32, 0x62, 0x07,
  0x06, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x05,
  0x00, 0x06, 0xC0, 0x02, 0x20, 0x03, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00,
  0x82, 0x00, 0x81, 0x00, 0xC0, 0xC0, 0x40, 0x20, 0x7F, 0xF0, 0x20, 0x08,
  0x30, 0x04, 0x10, 0x02, 0x10, 0x01, 0x18, 0x00, 0xC8, 0x00, 0x2C, 0x00,
  0x1C, 0x00, 0x08, 0x07, 0xFE, 0x04, 0x03, 0x0C, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x18, 0x01, 0x18, 0x02, 0x10, 0x04, 0x1F, 0xF8, 0x10,
  0x38, 0x30, 0x04, 0x20, 0x06, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60,
  0x06, 0x40, 0x04, 0x40, 0x08, 0x40, 0x30, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0xE3, 0xC1, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0x01,
  0xC0, 0xC0, 0x18, 0x20, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x11, 0x80, 0x04,
  0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x03, 0x20,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0x80, 0x04, 0x60, 0x02, 0x10, 0x01,
  0x84, 0x01, 0x81, 0x01, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x1F, 0xF8, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x79,
  0xF0, 0x70, 0x04, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0xFE, 0xC0,
  0x01, 0x30, 0x00, 0x4C, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00,
  0x86, 0x00, 0x20, 0xC0, 0x08, 0x18, 0x06, 0x03, 0xFE, 0x00, 0x04, 0x00,
  0x20, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00, 0x30, 0x80, 0x04, 0x10, 0x00,
  0x86, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x83, 0xFF, 0xF0, 0x40, 0x02,
  0x18, 0x00, 0x42, 0x00, 0x18, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x60, 0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x20,
  0x0F, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0xFC, 0x00, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x04, 0x0F, 0x80, 0x04, 0x01, 0xC1, 0x00, 0xC0, 0xC0,
  0x60, 0x20, 0x30, 0x08, 0x18, 0x02, 0x08, 0x01, 0x84, 0x00, 0x42, 0x00,
  0x13, 0x00, 0x05, 0xC0, 0x01, 0xD8, 0x00, 0xC2, 0x00, 0x20, 0xC0, 0x08,
  0x10, 0x02, 0x06, 0x00, 0x80, 0x80, 0x60, 0x30, 0x10, 0x04, 0x04, 0x01,
  0x01, 0x00, 0x20, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0F, 0xFE, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x1C, 0x28, 0x00, 0x28, 0x50, 0x00, 0xA0, 0xA0,
  0x01, 0x41, 0x20, 0x04, 0x86, 0x40, 0x19, 0x08, 0x80, 0x26, 0x11, 0x00,
  0x88, 0x22, 0x01, 0x10, 0x44, 0x04, 0x21, 0x84, 0x18, 0x42, 0x08, 0x21,
  0x84, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x44, 0x08, 0x60, 0x98, 0x10,
  0x80, 0xA0, 0x61, 0x01, 0xC0, 0x82, 0x03, 0x01, 0x0C, 0x04, 0x02, 0x00,
  0x04, 0x00, 0x20, 0xC0, 0x04, 0x28, 0x00, 0x85, 0x80, 0x30, 0x90, 0x04,
  0x12, 0x00, 0x86, 0x20, 0x10, 0x84, 0x06, 0x10, 0x40, 0x82, 0x08, 0x10,
  0x41, 0x82, 0x18, 0x10, 0x42, 0x02, 0x18, 0x40, 0x22, 0x08, 0x04, 0x41,
  0x00, 0xC8, 0x60, 0x09, 0x08, 0x01, 0x61, 0x00, 0x18, 0x20, 0x03, 0x0C,
  0x00, 0x20, 0x00, 0x78, 0x00, 0xE3, 0x80, 0x60, 0x18, 0x20, 0x02, 0x10,
  0x00, 0xCC, 0x00, 0x12, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x09,
  0x00, 0x02, 0x40, 0x01, 0x90, 0x00, 0x46, 0x00, 0x20, 0xC0, 0x18, 0x18,
  0x1C, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x04, 0x06, 0x0C, 0x02, 0x08, 0x03,
  0x08, 0x01, 0x08, 0x01, 0x18, 0x03, 0x18, 0x02, 0x10, 0x02, 0x10, 0x04,
  0x10, 0x18, 0x3F, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0xE3, 0x80, 0x60, 0x18, 0x20, 0x02, 0x10, 0x00, 0xCC, 0x00, 0x12,
  0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01,
  0x90, 0x00, 0x46, 0x00, 0x20, 0xC0, 0x18, 0x18, 0x1C, 0x03, 0xFC, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x07,
  0xFC, 0x04, 0x06, 0x0C, 0x02, 0x08, 0x03, 0x08, 0x01, 0x08, 0x01, 0x18,
  0x03, 0x18, 0x02, 0x10, 0x06, 0x10, 0x0C, 0x1F, 0xF0, 0x3F, 0xC0, 0x20,
  0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x10, 0x40, 0x10, 0x40,
  0x18, 0x40, 0x08, 0xC0, 0x08, 0x00, 0xE0, 0x1C, 0xF0, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x80, 0xC3, 0xFE, 0x00, 0xFF, 0xFC, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x10, 0x00, 0xCC,
  0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x98, 0x00, 0x64, 0x00,
  0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0xCC, 0x00, 0x22, 0x00, 0x08,
  0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x10, 0x80, 0x0C, 0x20,
  0x02, 0x0C, 0x01, 0x81, 0x81, 0xC0, 0x3F, 0xC0, 0x00, 0x80, 0x03, 0x80,
  0x04, 0xC0, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x30, 0x40,
  0x20, 0x40, 0x60, 0x40, 0x40, 0x60, 0xC0, 0x20, 0x80, 0x21, 0x00, 0x21,
  0x00, 0x22, 0x00, 0x22, 0x00, 0x24, 0x00, 0x24, 0x00, 0x28, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0A, 0x01, 0xC0, 0x34,
  0x02, 0x80, 0x48, 0x0D, 0x00, 0x90, 0x12, 0x02, 0x20, 0x64, 0x04, 0x40,
  0x88, 0x10, 0x81, 0x18, 0x21, 0x04, 0x10, 0xC2, 0x08, 0x21, 0x04, 0x20,
  0x46, 0x08, 0x40, 0x88, 0x11, 0x01, 0x10, 0x22, 0x02, 0x40, 0x48, 0x04,
  0x80, 0xD0, 0x0A, 0x01, 0xC0, 0x14, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x40, 0x18, 0x04, 0x06, 0x00,
  0x80, 0x80, 0x18, 0x20, 0x01, 0x08, 0x00, 0x23, 0x00, 0x02, 0xC0, 0x00,
  0x50, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x19, 0x00, 0x06,
  0x20, 0x00, 0x86, 0x00, 0x20, 0x40, 0x08, 0x08, 0x02, 0x00, 0x80, 0xC0,
  0x10, 0x30, 0x03, 0x0C, 0x00, 0x20, 0x80, 0x0F, 0x00, 0x24, 0x01, 0x10,
  0x0C, 0x40, 0x20, 0x81, 0x02, 0x0C, 0x08, 0x60, 0x31, 0x00, 0x48, 0x01,
  0x60, 0x07, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x1F, 0x80, 0x84, 0x10, 0x84, 0x21, 0x08, 0x21, 0x08, 0x42,
  0x10, 0x42, 0x10, 0x84, 0x20, 0x80, 0x07, 0xE0, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x1F, 0x80, 0x00, 0x40, 0x03, 0x00, 0x0A, 0x00,
  0x48, 0x03, 0x20, 0x08, 0x40, 0x41, 0x01, 0x04, 0x08, 0x08, 0x40, 0x21,
  0x00, 0x88, 0x01, 0x40, 0x07, 0x00, 0x10, 0xFF, 0xF0, 0xC4, 0x22, 0x10,
  0x03, 0xE2, 0x18, 0x28, 0x60, 0x51, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x10,
  0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x33, 0x00, 0x42, 0x01, 0x84, 0x03,
  0x08, 0x0A, 0x18, 0x64, 0x1F, 0x90, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x7C, 0x12, 0x08, 0x50, 0x11,
  0x80, 0x4C, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05,
  0x00, 0x34, 0x00, 0x98, 0x06, 0xA0, 0x32, 0x41, 0x88, 0xFC, 0x00, 0x07,
  0xF1, 0x81, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x43, 0xF8, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x03, 0xE2, 0x0C, 0x12, 0x18, 0x0E, 0x30, 0x0C, 0x20, 0x04, 0x60,
  0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0x40,
  0x18, 0x40, 0x30, 0x40, 0x50, 0x60, 0x90, 0x3F, 0x10, 0x07, 0xC1, 0x82,
  0x30, 0x32, 0x01, 0x40, 0x34, 0x02, 0xC0, 0xCF, 0xF8, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x43, 0xF8, 0x00, 0x0F, 0x80,
  0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x07, 0xF0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x07, 0x80,
  0x00, 0x03, 0xE2, 0x18, 0x24, 0x60, 0x29, 0x80, 0x62, 0x00, 0x4C, 0x00,
  0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00, 0x62, 0x00, 0xC4,
  0x03, 0x08, 0x0A, 0x18, 0x24, 0x1F, 0x88, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x10, 0x30, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x7E, 0x12,
  0x08, 0x50, 0x11, 0x80, 0x4C, 0x01, 0x30, 0x04, 0x80, 0x32, 0x00, 0x88,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x90, 0x04, 0xC0, 0x12, 0x00, 0x48,
  0x03, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x04, 0x10, 0x43, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x30, 0x82, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x0F, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x03, 0x10, 0x10, 0x40, 0x81, 0x04, 0x0C, 0x20, 0x23, 0x00, 0x98, 0x02,
  0xE0, 0x0E, 0x80, 0x73, 0x01, 0x04, 0x04, 0x18, 0x10, 0x20, 0xC0, 0xC2,
  0x01, 0x08, 0x06, 0x00, 0x04, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41,
  0x0C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x00, 0x11, 0xF0,
  0xF8, 0x2C, 0x22, 0x08, 0x50, 0x28, 0x18, 0xC0, 0x60, 0x13, 0x00, 0xC0,
  0x66, 0x01, 0x00, 0xC8, 0x02, 0x01, 0x10, 0x08, 0x02, 0x20, 0x10, 0x04,
  0x80, 0x20, 0x19, 0x00, 0x40, 0x22, 0x01, 0x80, 0x44, 0x02, 0x00, 0x98,
  0x04, 0x01, 0x20, 0x08, 0x06, 0x40, 0x30, 0x08, 0x11, 0xF8, 0x48, 0x21,
  0x40, 0x46, 0x01, 0x30, 0x04, 0xC0, 0x12, 0x00, 0xC8, 0x02, 0x60, 0x09,
  0x80, 0x24, 0x00, 0x90, 0x06, 0x40, 0x13, 0x00, 0x48, 0x01, 0x20, 0x0C,
  0x07, 0xE0, 0xC1, 0x8C, 0x06, 0xC0, 0x14, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x28, 0x03, 0x60, 0x31, 0x83,
  0x07, 0xE0, 0x04, 0x7C, 0x04, 0x82, 0x05, 0x01, 0x06, 0x01, 0x0C, 0x01,
  0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x03,
  0x10, 0x02, 0x18, 0x06, 0x38, 0x0C, 0x24, 0x18, 0x23, 0xF0, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x03, 0xE2, 0x18, 0x24, 0x60, 0x29, 0x80, 0x62, 0x00, 0x4C, 0x00, 0x90,
  0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00, 0x62, 0x00, 0xC4, 0x03,
  0x08, 0x0A, 0x18, 0x24, 0x1F, 0x88, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x11, 0xE2, 0x40, 0x50,
  0x0C, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x0F, 0xE1, 0x81, 0x10, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x80, 0xC7, 0xF0, 0x10, 0x10, 0x10, 0x30, 0xFF, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xF8, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00,
  0x64, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x03, 0x20, 0x18, 0x80,
  0x62, 0x02, 0x8C, 0x12, 0x1F, 0x90, 0xC0, 0x0A, 0x00, 0x90, 0x0C, 0x80,
  0x44, 0x06, 0x20, 0x21, 0x82, 0x04, 0x10, 0x21, 0x01, 0x18, 0x08, 0x80,
  0x4C, 0x02, 0x40, 0x1C, 0x00, 0x60, 0x02, 0x00, 0x80, 0xC0, 0x70, 0x18,
  0x0A, 0x07, 0x01, 0x40, 0xA0, 0x48, 0x34, 0x09, 0x04, 0x82, 0x21, 0x90,
  0x44, 0x23, 0x10, 0x8C, 0x62, 0x11, 0x04, 0x82, 0x60, 0x90, 0x48, 0x16,
  0x0B, 0x02, 0x81, 0x40, 0x70, 0x28, 0x0C, 0x02, 0x01, 0x80, 0x08, 0x02,
  0x10, 0x08, 0x10, 0x20, 0x20, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x05, 0x00, 0x13, 0x00, 0x42, 0x01, 0x06, 0x06, 0x04,
  0x18, 0x0C, 0x60, 0x08, 0x0C, 0x00, 0x82, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x40, 0x40, 0x60, 0x30, 0x20, 0x08, 0x30, 0x04, 0x10, 0x02, 0x10, 0x01,
  0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x18, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x30, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x04, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x70, 0x20, 0x00, 0x3C, 0x07, 0x0E, 0x38,
  0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 21, 7, 1, -21 },
  { 17, 7, 7, 10, 3, -21 },
  { 24, 18, 21, 19, 1, -21 },
  { 72, 14, 25, 17, 1, -23 },
  { 116, 19, 22, 23, 3, -22 },
  { 169, 18, 22, 20, 1, -22 },
  { 219, 3, 7, 5, 3, -21 },
  { 222, 9, 26, 8, 1, -21 },
  { 252, 9, 26, 8, -2, -21 },
  { 282, 12, 13, 16, 4, -23 },
  { 302, 14, 14, 17, 2, -18 },
  { 327, 4, 7, 6, -1, -3 },
  { 331, 7, 1, 9, 1, -9 },
  { 332, 2, 2, 7, 1, -2 },
  { 333, 13, 21, 9, -1, -21 },
  { 368, 14, 22, 17, 2, -22 },
  { 407, 7, 21, 17, 5, -21 },
  { 426, 15, 22, 17, 0, -22 },
  { 468, 15, 22, 17, 1, -22 },
  { 510, 16, 22, 17, 0, -22 },
  { 554, 15, 21, 17, 1, -21 },
  { 594, 14, 22, 17, 2, -22 },
  { 633, 14, 21, 17, 3, -21 },
  { 670, 15, 22, 17, 1, -22 },
  { 712, 15, 22, 17, 1, -22 },
  { 754, 5, 16, 7, 1, -16 },
  { 764, 7, 20, 7, -1, -16 },
  { 782, 14, 14, 17, 2, -18 },
  { 807, 14, 7, 17, 2, -14 },
  { 820, 14, 14, 17, 2, -18 },
  { 845, 11, 22, 12, 2, -22 },
  { 876, 22, 24, 25, 2, -21 },
  { 942, 17, 21, 17, -2, -21 },
  { 987, 16, 21, 18, 1, -21 },
  { 1029, 17, 22, 18, 2, -22 },
  { 1076, 18, 21, 20, 1, -21 },
  { 1124, 16, 21, 16, 1, -21 },
  { 1166, 16, 21, 15, 1, -21 },
  { 1208, 18, 22, 21, 2, -22 },
  { 1258, 19, 21, 20, 1, -21 },
  { 1308, 10, 21, 9, 0, -21 },
  { 1335, 12, 26, 7, -5, -21 },
  { 1374, 18, 21, 16, 1, -21 },
  { 1422, 11, 21, 15, 1, -21 },
  { 1451, 23, 21, 24, 1, -21 },
  { 1512, 19, 21, 20, 1, -21 },
  { 1562, 18, 22, 22, 2, -22 },
  { 1612, 16, 21, 17, 1, -21 },
  { 1654, 18, 27, 22, 2, -22 },
  { 1715, 16, 21, 17, 1, -21 },
  { 1757, 14, 22, 15, 1, -22 },
  { 1796, 14, 21, 15, 3, -21 },
  { 1833, 18, 21, 21, 3, -21 },
  { 1881, 16, 21, 16, 3, -21 },
  { 1923, 23, 21, 25, 4, -21 },
  { 1984, 19, 21, 15, -2, -21 },
  { 2034, 14, 21, 15, 3, -21 },
  { 2071, 17, 21, 16, 0, -21 },
  { 2116, 11, 26, 9, 0, -21 },
  { 2152, 5, 21, 9, 3, -21 },
  { 2166, 11, 26, 9, -2, -21 },
  { 2202, 14, 14, 17, 1, -22 },
  { 2227, 12, 1, 11, -3, 3 },
  { 2229, 4, 5, 7, 4, -23 },
  { 2232, 15, 16, 17, 1, -16 },
  { 2262, 14, 23, 17, 1, -23 },
  { 2303, 12, 16, 14, 2, -16 },
  { 2327, 16, 23, 17, 1, -23 },
  { 2373, 12, 16, 15, 2, -16 },
  { 2397, 17, 30, 8, -4, -23 },
  { 2461, 15, 23, 17, 1, -16 },
  { 2505, 14, 23, 17, 1, -23 },
  { 2546, 6, 22, 7, 1, -22 },
  { 2563, 11, 29, 7, -4, -22 },
  { 2603, 14, 23, 14, 1, -23 },
  { 2644, 6, 23, 7, 1, -23 },
  { 2662, 23, 16, 25, 1, -16 },
  { 2708, 14, 16, 17, 1, -16 },
  { 2736, 13, 16, 17, 2, -16 },
  { 2762, 16, 23, 17, -1, -16 },
  { 2808, 15, 23, 17, 1, -16 },
  { 2852, 11, 16, 11, 1, -16 },
  { 2874, 12, 16, 13, 0, -16 },
  { 2898, 8, 20, 9, 2, -20 },
  { 2918, 14, 16, 17, 2, -16 },
  { 2946, 13, 16, 13, 1, -16 },
  { 2972, 19, 16, 20, 2, -16 },
  { 3010, 15, 16, 14, -1, -16 },
  { 3040, 17, 23, 13, -3, -16 },
  { 3089, 13, 16, 13, 0, -16 },
  { 3115, 11, 26, 10, 1, -21 },
  { 3151, 1, 30, 16, 8, -23 },
  { 3155, 10, 26, 10, -1, -21 },
  { 3188, 14, 3, 17, 2, -12 },
};

const GFXfont NotoSans_ExtraLightItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRALIGHTITALIC30PT7B_H_
