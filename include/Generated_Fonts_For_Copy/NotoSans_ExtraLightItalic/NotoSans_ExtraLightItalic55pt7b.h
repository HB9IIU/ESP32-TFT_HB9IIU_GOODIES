#ifndef _NOTOSANS_EXTRALIGHTITALIC55PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x02, 0x00, 0x18, 0x39, 0xC1, 0xCC,
  0x0C, 0x60, 0x63, 0x03, 0x18, 0x19, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03,
  0x10, 0x11, 0x81, 0x8C, 0x0C, 0x60, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFE, 0x01, 0xE3,
  0x0F, 0x01, 0xC1, 0x80, 0x81, 0x80, 0xC0, 0x01, 0xC0, 0x40, 0x00, 0xC0,
  0x60, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x04, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x78, 0xC0, 0x00, 0x1F, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x08, 0xF0, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x08,
  0x0E, 0x10, 0x0C, 0x0E, 0x0E, 0x06, 0x1E, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x80, 0xFF, 0x00, 0x00, 0xC0, 0xE0, 0xC0, 0x00, 0x60, 0x30, 0x18,
  0x00, 0x38, 0x18, 0x06, 0x00, 0x0C, 0x0E, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x60, 0x03, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0xC0, 0x06, 0x03, 0x00, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x60, 0xE0,
  0x03, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x0C, 0x18, 0x3E, 0x30, 0x03, 0x0C,
  0x3F, 0xEC, 0x01, 0x87, 0x1C, 0x1B, 0x00, 0x61, 0x8E, 0x03, 0xC0, 0x30,
  0xC3, 0x00, 0xF8, 0x18, 0x61, 0x80, 0x37, 0x0E, 0x38, 0x60, 0x0C, 0xFE,
  0x0C, 0x30, 0x03, 0x0F, 0x06, 0x0C, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x30,
  0x00, 0xC1, 0xC0, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x30, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x18, 0x01, 0x80, 0xE0, 0x06, 0x00, 0xE0, 0x30, 0x01,
  0x80, 0x30, 0x18, 0x00, 0x60, 0x1C, 0x0C, 0x00, 0x18, 0x06, 0x07, 0x00,
  0x07, 0x03, 0x01, 0x80, 0x00, 0xE3, 0x80, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00, 0x18,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x06, 0x1C, 0x01, 0xC0, 0x06, 0x1C, 0x00, 0x60, 0x03, 0x1C,
  0x00, 0x18, 0x03, 0x0C, 0x00, 0x0E, 0x01, 0x8C, 0x00, 0x03, 0x01, 0x86,
  0x00, 0x00, 0xC1, 0xC3, 0x00, 0x00, 0x71, 0xC3, 0x80, 0x00, 0x1C, 0xC1,
  0xC0, 0x00, 0x06, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x01, 0xCC, 0x03, 0x80, 0x03, 0xC7,
  0x01, 0xE0, 0x07, 0x81, 0xC0, 0x3E, 0x3F, 0x80, 0x60, 0x0F, 0xFE, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x00, 0x00, 0x19, 0xCC, 0x63, 0x19, 0x8C, 0x63,
  0x11, 0x8C, 0x60, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x06, 0x00, 0x78,
  0x0C, 0x00, 0x38, 0x10, 0x00, 0x1C, 0x20, 0x00, 0x0E, 0xC0, 0x18, 0x07,
  0xBF, 0xF0, 0x07, 0xFF, 0xC0, 0x1A, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x08, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x80, 0x30,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x06, 0x0E, 0x0C, 0x1C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x5F, 0xF4, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x01, 0xC0,
  0x18, 0x00, 0x70, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x38, 0x00, 0x18,
  0x0C, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x0F, 0x80, 0xF6, 0x07, 0x18, 0x78, 0xE3, 0x83, 0x38, 0x0C, 0xC0, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x04,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x80, 0x7F, 0x87, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x70, 0x07,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x08, 0x00, 0x07, 0x00,
  0xE0, 0x01, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x0C,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x7F, 0xC0, 0x0C, 0x7F, 0xFC,
  0x06, 0x38, 0x07, 0x81, 0x98, 0x00, 0x70, 0x6C, 0x00, 0x0C, 0x3E, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xC1, 0xF0, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0x70, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0x83, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x78, 0x60, 0x00,
  0x1E, 0x1C, 0x00, 0x1F, 0x83, 0x80, 0x0E, 0xC0, 0x78, 0x0F, 0x30, 0x0F,
  0xFF, 0x0C, 0x00, 0xFE, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x9F, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xC1, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x38, 0x1C, 0x0E, 0x02, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x3F,
  0x07, 0x81, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x1F, 0xC0, 0x06, 0x1C, 0x00, 0x3F, 0xFE, 0x01, 0x86, 0x00, 0x3C,
  0x03, 0x80, 0x63, 0x80, 0x1C, 0x00, 0xC0, 0x18, 0xC0, 0x0E, 0x00, 0x30,
  0x03, 0x30, 0x07, 0x00, 0x0C, 0x00, 0xD8, 0x01, 0x80, 0x06, 0x00, 0x36,
  0x00, 0xC0, 0x01, 0x80, 0x19, 0x80, 0x30, 0x00, 0x60, 0x06, 0xE0, 0x18,
  0x00, 0x18, 0x01, 0xB0, 0x06, 0x00, 0x0C, 0x00, 0x6C, 0x01, 0x80, 0x03,
  0x00, 0x1B, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0xC0, 0x38, 0x00, 0x70, 0x03,
  0x30, 0x0C, 0x00, 0x18, 0x00, 0xCC, 0x03, 0x00, 0x0E, 0x00, 0x63, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0xC0, 0x18, 0x01, 0xA0, 0x0C, 0x30, 0x06, 0x00,
  0xCC, 0x06, 0x0E, 0x00, 0xC0, 0xE3, 0x07, 0x01, 0x80, 0x3F, 0xF0, 0xFF,
  0x80, 0x60, 0x03, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x78, 0x03,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x18, 0x01, 0xF8,
  0x00, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x0F, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x00,
  0x02, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x7F, 0x3F, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x00, 0xF0,
  0x01, 0x80, 0x00, 0x78, 0x01, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0xC0, 0x00, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x30,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0C, 0x3E,
  0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x01,
  0x80, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x0C, 0x7C, 0x00, 0x00, 0x0C, 0xEC, 0x00, 0x00, 0x0D,
  0x8E, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x01, 0xB0, 0x00, 0x00, 0x1F, 0x80,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x3B, 0x00, 0x00, 0x03, 0x30, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0xC6, 0x00, 0x00,
  0x39, 0xC0, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x1C, 0x60, 0x00, 0x06, 0x18,
  0x06, 0x18, 0x00, 0x01, 0x86, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x61,
  0x80, 0x00, 0x70, 0xC0, 0x18, 0x30, 0x00, 0x18, 0x30, 0x0E, 0x0C, 0x00,
  0x0E, 0x0C, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0xC0, 0x30, 0x30, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x38, 0x03, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0x30, 0x03, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x07, 0x00,
  0x30, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x70, 0x01, 0x80, 0x60, 0x03, 0x18,
  0x00, 0xE0, 0x18, 0x00, 0x6C, 0x00, 0x30, 0x06, 0x00, 0x1B, 0x00, 0x0C,
  0x03, 0x80, 0x07, 0x80, 0x03, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x0C, 0x07,
  0x80, 0x00, 0x07, 0x01, 0xB0, 0x00, 0x01, 0x80, 0x6C, 0x00, 0x00, 0x60,
  0x3B, 0x80, 0x00, 0x18, 0x0C, 0x60, 0x00, 0x06, 0x03, 0x18, 0x00, 0x03,
  0x00, 0xC3, 0x00, 0x00, 0xC0, 0x30, 0xC0, 0x00, 0x30, 0x1C, 0x18, 0x00,
  0x0C, 0x06, 0x06, 0x00, 0x07, 0x01, 0x81, 0xC0, 0x01, 0x80, 0x60, 0x30,
  0x00, 0x60, 0x18, 0x0C, 0x00, 0x18, 0x0E, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x60, 0x03, 0x80, 0xC0, 0x1C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xE0, 0x0C, 0x06, 0x00, 0x18, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x60, 0x18, 0x00, 0x30, 0x18, 0x0E, 0x00, 0x0E, 0x06,
  0x03, 0x00, 0x01, 0x83, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x30, 0x00, 0x0C,
  0x30, 0x0C, 0x00, 0x03, 0x0C, 0x07, 0x00, 0x00, 0xE3, 0x01, 0x80, 0x00,
  0x19, 0xC0, 0x60, 0x00, 0x07, 0x60, 0x18, 0x00, 0x00, 0xD8, 0x06, 0x00,
  0x00, 0x36, 0x03, 0x80, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x30,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x00, 0xC0,
  0x01, 0xE0, 0x0C, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x18, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x0F, 0x00, 0xC0, 0x0F, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x07, 0x81, 0xC0,
  0x03, 0xC0, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0x40, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x03,
  0x00, 0x30, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x3B, 0x00, 0x00, 0x70, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x30,
  0x00, 0x19, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC6, 0x00, 0x0E, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x18,
  0x00, 0x70, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x81, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x06,
  0x00, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x1C, 0x01,
  0x80, 0xC0, 0x1C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x01,
  0x80, 0xE0, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x07,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x87,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x38, 0x00,
  0x31, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x19, 0xC0, 0x00, 0xCE,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0x38, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x08, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x04, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x0E, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x02,
  0x06, 0x00, 0x07, 0x00, 0x40, 0x1F, 0xF8, 0x20, 0x0F, 0x0F, 0x18, 0x0F,
  0x00, 0xE6, 0x07, 0x00, 0x19, 0x83, 0x80, 0x03, 0x60, 0xC0, 0x00, 0xF0,
  0x70, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x0C, 0x00, 0x07, 0x83, 0x00, 0x01, 0x60, 0xE0, 0x00, 0xD8, 0x18, 0x00,
  0x6C, 0x07, 0x00, 0x33, 0x00, 0xE0, 0x38, 0xC0, 0x3E, 0x7C, 0x30, 0x03,
  0xFC, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x70,
  0x00, 0xC1, 0xFF, 0x00, 0x31, 0xE1, 0xF0, 0x18, 0xE0, 0x1C, 0x06, 0x60,
  0x03, 0x81, 0xB0, 0x00, 0x70, 0x78, 0x00, 0x0C, 0x34, 0x00, 0x03, 0x0F,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x0C, 0x1A, 0x00, 0x07, 0x0C, 0xC0, 0x03,
  0x83, 0x18, 0x03, 0xC0, 0xC3, 0xC7, 0xC0, 0x30, 0x7F, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0x83, 0xC0, 0xF0,
  0x01, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x0F, 0xCF, 0xC0, 0x1F, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x0C, 0x00, 0x3F, 0xF0, 0x60, 0x03, 0xC1, 0xE3, 0x00, 0x78,
  0x03, 0x18, 0x07, 0x00, 0x0C, 0xC0, 0x70, 0x00, 0x3C, 0x03, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0F, 0x01, 0x80,
  0x00, 0xD8, 0x0E, 0x00, 0x0D, 0x80, 0x30, 0x00, 0xEC, 0x01, 0xC0, 0x0E,
  0x60, 0x07, 0x00, 0xE3, 0x00, 0x3E, 0x3C, 0x18, 0x00, 0x7F, 0xC1, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0x87,
  0x80, 0x70, 0x06, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x30, 0xE0, 0x00, 0xC7,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x73, 0x00, 0x01, 0x9C, 0x00,
  0x0E, 0x60, 0x00, 0xF1, 0x80, 0x1F, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x0F, 0x87, 0xC0,
  0x0F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0x81, 0x00, 0x3C, 0x1E, 0x30, 0x0F, 0x00, 0x63, 0x01,
  0xC0, 0x03, 0x30, 0x38, 0x00, 0x1A, 0x03, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x0F, 0x03, 0x00, 0x01, 0xB0, 0x38, 0x00, 0x36,
  0x01, 0x80, 0x07, 0x60, 0x1C, 0x00, 0xE6, 0x00, 0xE0, 0x1C, 0x60, 0x0F,
  0x8F, 0x0E, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x08, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x07, 0x00, 0x18, 0x3F, 0xF0,
  0x0C, 0x7C, 0x3C, 0x0C, 0x70, 0x07, 0x06, 0x60, 0x01, 0x83, 0x60, 0x00,
  0xC1, 0xE0, 0x00, 0x61, 0xB0, 0x00, 0x30, 0xF0, 0x00, 0x18, 0x70, 0x00,
  0x0C, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x31, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x08,
  0x18, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x38,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x38,
  0x00, 0x60, 0x38, 0x00, 0x30, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x3C, 0x00, 0x03, 0x36, 0x00, 0x01, 0xB1,
  0x80, 0x01, 0xB0, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x38, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x01, 0x87,
  0xFC, 0x01, 0xFF, 0x00, 0x87, 0x8F, 0x03, 0xC3, 0xC0, 0xC6, 0x01, 0xC3,
  0x80, 0x70, 0x66, 0x00, 0x63, 0x80, 0x18, 0x36, 0x00, 0x33, 0x00, 0x0C,
  0x1E, 0x00, 0x0D, 0x80, 0x06, 0x1A, 0x00, 0x07, 0x80, 0x03, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0x87, 0x00, 0x03, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x00, 0x01, 0x86, 0x00, 0x03, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x80, 0x00, 0x61, 0x80, 0x00, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x60, 0x00, 0x38, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xC1, 0xFF, 0x80, 0x61, 0xF1,
  0xF0, 0x18, 0xE0, 0x0E, 0x06, 0x70, 0x03, 0x81, 0xB0, 0x00, 0x60, 0x78,
  0x00, 0x18, 0x36, 0x00, 0x07, 0x0F, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60,
  0xE0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x70, 0x00, 0x60, 0x70, 0x00, 0x38,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x3C, 0x00, 0xF8, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x07,
  0xFC, 0x00, 0x10, 0xF0, 0xF8, 0x01, 0x8E, 0x01, 0xC0, 0x0C, 0xC0, 0x07,
  0x00, 0x6C, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x60, 0x34, 0x00, 0x03, 0x01,
  0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01,
  0x80, 0x68, 0x00, 0x1C, 0x07, 0x60, 0x01, 0xC0, 0x31, 0x80, 0x3C, 0x01,
  0x87, 0x8F, 0x80, 0x0C, 0x1F, 0xF8, 0x00, 0x60, 0x08, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8,
  0x10, 0x0F, 0x07, 0x8C, 0x0F, 0x00, 0x63, 0x07, 0x00, 0x0C, 0xC3, 0x80,
  0x01, 0xA0, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x03, 0xC3, 0x00, 0x01, 0xB0,
  0xE0, 0x00, 0xD8, 0x18, 0x00, 0x76, 0x07, 0x00, 0x39, 0x80, 0xE0, 0x1C,
  0x60, 0x3E, 0x3C, 0x38, 0x03, 0xFE, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x7F, 0x02, 0x1F, 0x30, 0x63, 0x80,
  0x06, 0x60, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0xF0,
  0x3E, 0x0E, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x20, 0x00, 0xE1, 0x80, 0x0E, 0x0F, 0xC3, 0xE0, 0x1F, 0xFE, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x01, 0xFF, 0xFE, 0xFF, 0xFE, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x79,
  0xC0, 0x3F, 0xC0, 0x04, 0x00, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x03, 0x60, 0xE0,
  0x01, 0x98, 0x18, 0x00, 0xCC, 0x07, 0x00, 0xE3, 0x00, 0xF9, 0xF0, 0xC0,
  0x1F, 0xF0, 0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x66, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x0C, 0x00, 0x0E,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01,
  0x80, 0x0E, 0x03, 0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C,
  0x03, 0x80, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x00, 0xC0,
  0xC0, 0x00, 0xC3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00,
  0xEC, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x07, 0x30, 0x01, 0x98,
  0x00, 0xC7, 0x00, 0x33, 0x00, 0x18, 0x60, 0x0C, 0x60, 0x06, 0x0C, 0x01,
  0x86, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C,
  0x03, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x06,
  0x0C, 0x01, 0x86, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x06, 0x30,
  0x01, 0x9C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x03,
  0x30, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x60,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xFC, 0x00, 0x78,
  0x0F, 0x80, 0x78, 0x01, 0xFF, 0xE8, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 40, 12, 2, -39 },
  { 56, 13, 14, 18, 6, -39 },
  { 79, 33, 39, 34, 2, -39 },
  { 240, 25, 45, 30, 3, -42 },
  { 381, 34, 41, 42, 5, -40 },
  { 556, 33, 41, 37, 2, -40 },
  { 726, 5, 14, 10, 6, -39 },
  { 735, 16, 48, 14, 2, -39 },
  { 831, 16, 48, 14, -4, -39 },
  { 927, 23, 24, 29, 7, -42 },
  { 996, 25, 25, 31, 4, -32 },
  { 1075, 8, 13, 11, -2, -6 },
  { 1088, 13, 2, 17, 2, -16 },
  { 1092, 3, 5, 12, 2, -4 },
  { 1094, 24, 39, 17, -2, -39 },
  { 1211, 25, 41, 30, 4, -40 },
  { 1340, 14, 39, 30, 9, -39 },
  { 1409, 28, 40, 30, 0, -40 },
  { 1549, 28, 41, 30, 1, -40 },
  { 1693, 28, 39, 30, 1, -39 },
  { 1830, 28, 40, 30, 2, -39 },
  { 1970, 26, 41, 30, 4, -40 },
  { 2104, 25, 39, 30, 6, -39 },
  { 2226, 26, 41, 30, 3, -40 },
  { 2360, 26, 41, 30, 3, -40 },
  { 2494, 9, 30, 12, 2, -29 },
  { 2528, 14, 36, 12, -3, -29 },
  { 2591, 25, 25, 31, 4, -32 },
  { 2670, 25, 13, 31, 4, -26 },
  { 2711, 25, 25, 31, 4, -32 },
  { 2790, 20, 41, 22, 4, -40 },
  { 2893, 42, 44, 46, 3, -39 },
  { 3124, 31, 39, 30, -3, -39 },
  { 3276, 29, 39, 33, 3, -39 },
  { 3418, 30, 41, 33, 5, -40 },
  { 3572, 32, 39, 37, 3, -39 },
  { 3728, 28, 39, 29, 3, -39 },
  { 3865, 28, 39, 27, 3, -39 },
  { 4002, 32, 41, 38, 5, -40 },
  { 4166, 34, 39, 37, 3, -39 },
  { 4332, 18, 39, 16, 0, -39 },
  { 4420, 22, 49, 13, -9, -39 },
  { 4555, 32, 39, 30, 3, -39 },
  { 4711, 20, 39, 27, 3, -39 },
  { 4809, 42, 39, 45, 3, -39 },
  { 5014, 34, 39, 37, 3, -39 },
  { 5180, 32, 41, 39, 5, -40 },
  { 5344, 28, 39, 31, 3, -39 },
  { 5481, 32, 49, 39, 5, -40 },
  { 5677, 28, 39, 31, 3, -39 },
  { 5814, 27, 41, 27, 1, -40 },
  { 5953, 27, 39, 27, 5, -39 },
  { 6085, 33, 40, 38, 5, -39 },
  { 6250, 28, 39, 30, 6, -39 },
  { 6387, 43, 39, 46, 7, -39 },
  { 6597, 35, 39, 27, -3, -39 },
  { 6768, 27, 39, 27, 5, -39 },
  { 6900, 31, 39, 30, 0, -39 },
  { 7052, 21, 48, 17, -1, -39 },
  { 7178, 9, 39, 17, 5, -39 },
  { 7222, 21, 48, 17, -4, -39 },
  { 7348, 25, 25, 30, 3, -40 },
  { 7427, 21, 2, 21, -5, 6 },
  { 7433, 7, 9, 13, 8, -42 },
  { 7441, 26, 31, 30, 3, -30 },
  { 7542, 26, 43, 31, 2, -42 },
  { 7682, 22, 31, 25, 3, -30 },
  { 7768, 29, 43, 31, 3, -42 },
  { 7924, 22, 31, 27, 3, -30 },
  { 8010, 30, 55, 15, -7, -42 },
  { 8217, 28, 43, 31, 1, -30 },
  { 8368, 25, 42, 31, 2, -42 },
  { 8500, 11, 40, 12, 2, -40 },
  { 8555, 21, 53, 12, -8, -40 },
  { 8695, 25, 42, 25, 2, -42 },
  { 8827, 11, 42, 12, 2, -42 },
  { 8885, 41, 30, 47, 2, -30 },
  { 9039, 26, 30, 31, 2, -30 },
  { 9137, 25, 31, 31, 3, -30 },
  { 9234, 29, 43, 31, -1, -30 },
  { 9390, 26, 43, 31, 3, -30 },
  { 9530, 20, 30, 21, 2, -30 },
  { 9605, 21, 31, 23, 1, -30 },
  { 9687, 16, 37, 17, 3, -36 },
  { 9761, 26, 30, 31, 3, -29 },
  { 9859, 23, 29, 23, 3, -29 },
  { 9943, 35, 29, 37, 3, -29 },
  { 10070, 28, 29, 25, -2, -29 },
  { 10172, 32, 42, 23, -6, -29 },
  { 10340, 25, 29, 24, -1, -29 },
  { 10431, 20, 48, 18, 1, -39 },
  { 10551, 2, 55, 30, 15, -42 },
  { 10565, 20, 48, 18, -3, -39 },
  { 10685, 25, 5, 31, 4, -22 },
};

const GFXfont NotoSans_ExtraLightItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRALIGHTITALIC55PT7B_H_
