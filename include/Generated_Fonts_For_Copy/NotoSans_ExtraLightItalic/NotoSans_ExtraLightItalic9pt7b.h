#ifndef _NOTOSANS_EXTRALIGHTITALIC9PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x29, 0xF2, 0xBE, 0x51, 0x40, 0x13, 0xD8, 0x43,
  0x1B, 0x88, 0x45, 0x6D, 0xFA, 0xAE, 0x60, 0x10, 0xA2, 0x8C, 0xD6, 0x2F,
  0x80, 0xC0, 0x6A, 0x49, 0x20, 0x24, 0x92, 0x70, 0x2A, 0x5A, 0x4F, 0x44,
  0xC0, 0xC0, 0x80, 0x32, 0x44, 0x88, 0x69, 0x99, 0x9A, 0xE0, 0xE5, 0x24,
  0x80, 0x32, 0x42, 0x22, 0x23, 0xC0, 0x32, 0x42, 0x61, 0x07, 0xC0, 0x19,
  0x55, 0x27, 0x88, 0x7A, 0x1C, 0x10, 0xF8, 0x34, 0x8E, 0x99, 0xE0, 0xF2,
  0x24, 0x48, 0x32, 0x52, 0x6D, 0x47, 0xC0, 0x32, 0x52, 0x93, 0x8B, 0x80,
  0x40, 0x80, 0x40, 0xA0, 0x78, 0x43, 0xFF, 0xC3, 0x68, 0xC4, 0xA8, 0x20,
  0x3E, 0xB6, 0x9D, 0x5B, 0xE8, 0x0E, 0x00, 0x11, 0x94, 0xE8, 0xC4, 0x7A,
  0x5C, 0x98, 0xF8, 0x3A, 0x21, 0x08, 0x43, 0xC0, 0x7D, 0x14, 0x51, 0x8B,
  0xC0, 0x7A, 0x1C, 0x88, 0x78, 0x7A, 0x1C, 0x88, 0x40, 0x3A, 0x21, 0x2A,
  0xC7, 0xC0, 0x45, 0x17, 0x91, 0x8A, 0x20, 0x69, 0x25, 0x80, 0x11, 0x11,
  0x22, 0x2C, 0x4D, 0x46, 0x14, 0x92, 0x40, 0x44, 0x44, 0x8F, 0x42, 0xCD,
  0x9B, 0x5A, 0xB2, 0x80, 0x45, 0x95, 0x55, 0x9A, 0x20, 0x36, 0x63, 0x18,
  0xC7, 0xC0, 0x7A, 0x52, 0xE8, 0x40, 0x36, 0x63, 0x18, 0xC7, 0x44, 0x10,
  0x7A, 0x52, 0xE9, 0x48, 0x3A, 0x10, 0x41, 0x0B, 0xC0, 0xF4, 0x44, 0x48,
  0x8C, 0x63, 0x19, 0x78, 0x9C, 0xA9, 0x4C, 0x40, 0x93, 0x66, 0xD6, 0xA9,
  0x91, 0x00, 0x24, 0xA1, 0x0C, 0x4B, 0x20, 0x9A, 0xC4, 0x48, 0x78, 0x88,
  0x84, 0x78, 0x69, 0x49, 0x30, 0xFC, 0x31, 0x22, 0x22, 0xE0, 0x32, 0x93,
  0x10, 0xF0, 0xC0, 0x3A, 0x63, 0x2F, 0x00, 0x42, 0x1C, 0x98, 0xC7, 0xC0,
  0x34, 0x88, 0x70, 0x08, 0x4E, 0x98, 0xCB, 0xC0, 0x77, 0x4E, 0x19, 0x1C,
  0x42, 0x21, 0x08, 0xC0, 0x3A, 0x63, 0x2F, 0x0B, 0x80, 0x44, 0x75, 0x99,
  0x90, 0x45, 0xA8, 0x20, 0x94, 0x92, 0xC0, 0x44, 0x56, 0xCA, 0x90, 0x55,
  0xA8, 0x76, 0x96, 0x4C, 0x99, 0x20, 0x72, 0x63, 0x29, 0x00, 0x32, 0x63,
  0x17, 0x00, 0x72, 0x63, 0x1F, 0x42, 0x00, 0x3A, 0x63, 0x2F, 0x08, 0x40,
  0x74, 0x88, 0x80, 0x78, 0x42, 0xE0, 0x5D, 0x49, 0x80, 0x4A, 0x63, 0x2F,
  0x00, 0x99, 0xA4, 0x40, 0x96, 0x5B, 0x72, 0x90, 0x56, 0x26, 0xA0, 0x4A,
  0x54, 0x42, 0x13, 0x00, 0x72, 0x44, 0xE0, 0x29, 0x45, 0x30, 0xFF, 0x80,
  0x65, 0x14, 0xA0, 0xF0,
};

const GFXglyph NotoSans_ExtraLightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 6, 6, 6, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 5, 7, 7, 1, -7 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 1, 2, 2, 1, -6 },
  { 26, 3, 7, 2, 0, -6 },
  { 29, 3, 7, 2, -1, -6 },
  { 32, 4, 4, 5, 1, -7 },
  { 34, 4, 4, 5, 1, -5 },
  { 36, 1, 2, 2, 0, -1 },
  { 37, 2, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 0, -1 },
  { 39, 4, 6, 3, 0, -6 },
  { 42, 4, 7, 5, 1, -7 },
  { 46, 3, 6, 5, 1, -6 },
  { 49, 5, 7, 5, 0, -7 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 5, 6, 5, 0, -6 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 4, 7, 5, 1, -7 },
  { 71, 4, 6, 5, 1, -6 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 2, 5, 2, 0, -5 },
  { 86, 2, 6, 2, 0, -5 },
  { 88, 4, 4, 5, 1, -5 },
  { 90, 4, 2, 5, 1, -4 },
  { 91, 4, 4, 5, 1, -5 },
  { 93, 3, 7, 4, 1, -7 },
  { 96, 7, 7, 8, 0, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 7, 5, 1, -7 },
  { 116, 6, 6, 6, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 6, 4, 0, -6 },
  { 129, 5, 7, 6, 1, -7 },
  { 134, 6, 6, 6, 0, -6 },
  { 139, 3, 6, 3, 0, -6 },
  { 142, 4, 8, 2, -2, -6 },
  { 146, 6, 6, 5, 0, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 7, 6, 7, 0, -6 },
  { 160, 6, 6, 6, 0, -6 },
  { 165, 5, 7, 6, 1, -7 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 9, 6, 1, -7 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 5, 7, 4, 0, -7 },
  { 189, 4, 6, 4, 1, -6 },
  { 192, 5, 6, 6, 1, -6 },
  { 196, 5, 6, 5, 1, -6 },
  { 200, 7, 6, 7, 1, -6 },
  { 206, 6, 6, 4, -1, -6 },
  { 211, 4, 6, 4, 1, -6 },
  { 214, 5, 6, 5, 0, -6 },
  { 218, 3, 7, 3, 0, -6 },
  { 221, 1, 6, 3, 1, -6 },
  { 222, 4, 7, 3, -1, -6 },
  { 226, 5, 4, 5, 0, -6 },
  { 229, 4, 1, 3, -1, 1 },
  { 230, 1, 2, 2, 1, -7 },
  { 231, 5, 5, 5, 0, -5 },
  { 235, 5, 7, 5, 0, -7 },
  { 240, 4, 5, 4, 0, -5 },
  { 243, 5, 7, 5, 0, -7 },
  { 248, 3, 5, 4, 1, -5 },
  { 250, 5, 9, 2, -1, -7 },
  { 256, 5, 7, 5, 0, -5 },
  { 261, 4, 7, 5, 0, -7 },
  { 265, 2, 7, 2, 0, -7 },
  { 267, 3, 9, 2, -1, -7 },
  { 271, 4, 7, 4, 0, -7 },
  { 275, 2, 7, 2, 0, -7 },
  { 277, 7, 5, 8, 0, -5 },
  { 282, 5, 5, 5, 0, -5 },
  { 286, 5, 5, 5, 0, -5 },
  { 290, 5, 7, 5, 0, -5 },
  { 295, 5, 7, 5, 0, -5 },
  { 300, 4, 5, 3, 0, -5 },
  { 303, 4, 5, 4, 0, -5 },
  { 306, 3, 6, 3, 0, -6 },
  { 309, 5, 5, 5, 0, -5 },
  { 313, 4, 5, 4, 0, -5 },
  { 316, 6, 5, 6, 0, -5 },
  { 320, 4, 5, 4, 0, -5 },
  { 323, 5, 7, 4, -1, -5 },
  { 328, 4, 5, 4, 0, -5 },
  { 331, 3, 7, 3, 0, -6 },
  { 334, 1, 9, 5, 2, -7 },
  { 336, 3, 7, 3, 0, -6 },
  { 339, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_ExtraLightItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRALIGHTITALIC9PT7B_H_
