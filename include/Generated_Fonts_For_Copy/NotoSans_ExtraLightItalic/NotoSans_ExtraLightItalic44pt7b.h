#ifndef _NOTOSANS_EXTRALIGHTITALIC44PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x80,
  0x30, 0xC8, 0x36, 0x09, 0x82, 0x61, 0x90, 0x64, 0x13, 0x04, 0xC1, 0x20,
  0xC8, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x18,
  0x00, 0x04, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x18, 0x00, 0x04,
  0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x18, 0x03, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x80, 0x30, 0x08, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x30, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x60, 0x07, 0xFF, 0xFF,
  0xF1, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x06,
  0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x01, 0x80,
  0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0x81, 0xE2, 0x18, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x08, 0x00, 0x60,
  0x40, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x08, 0x00,
  0x18, 0x40, 0x00, 0x76, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0B,
  0xC0, 0x00, 0x47, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x01, 0x03, 0x00,
  0x08, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x06,
  0x0C, 0x08, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x0C, 0x18, 0x30, 0x01, 0x83, 0x03, 0x00, 0x30,
  0x30, 0x10, 0x02, 0x06, 0x01, 0x00, 0x60, 0x60, 0x10, 0x0C, 0x04, 0x01,
  0x01, 0x80, 0xC0, 0x10, 0x10, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x60,
  0x08, 0x03, 0x0C, 0x00, 0x80, 0x20, 0x80, 0x08, 0x06, 0x18, 0xFC, 0x80,
  0x63, 0x1C, 0xE8, 0x04, 0x63, 0x06, 0xC0, 0xC4, 0x60, 0x2C, 0x18, 0xC6,
  0x03, 0x7F, 0x18, 0xC0, 0x33, 0xC3, 0x0C, 0x03, 0x00, 0x20, 0x80, 0x20,
  0x06, 0x18, 0x02, 0x00, 0xC1, 0x80, 0x20, 0x18, 0x18, 0x06, 0x01, 0x81,
  0x80, 0x60, 0x30, 0x18, 0x04, 0x06, 0x01, 0x80, 0xC0, 0x40, 0x18, 0x0C,
  0x0C, 0x01, 0x81, 0x81, 0x80, 0x18, 0x18, 0x30, 0x00, 0xC3, 0x06, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00, 0x10, 0x00,
  0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x1B, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x98,
  0x00, 0x03, 0x82, 0x00, 0x31, 0x80, 0xC0, 0x0C, 0xC0, 0x18, 0x06, 0x60,
  0x03, 0x01, 0x98, 0x00, 0xC0, 0xCC, 0x00, 0x18, 0x23, 0x00, 0x03, 0x18,
  0xC0, 0x00, 0x6C, 0x30, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01,
  0xE0, 0x60, 0x01, 0xC8, 0x1C, 0x00, 0xE3, 0x03, 0xC1, 0xE0, 0x60, 0x7F,
  0xE0, 0x0C, 0x32, 0x66, 0x64, 0x4C, 0xC8, 0x80, 0x00, 0x38, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x04, 0x06, 0x01,
  0xE0, 0xC0, 0x0E, 0x10, 0x00, 0x32, 0x00, 0x01, 0xCF, 0xE0, 0x1F, 0xE0,
  0x07, 0x00, 0x01, 0x90, 0x00, 0x62, 0x00, 0x38, 0x60, 0x0E, 0x04, 0x03,
  0x80, 0xC0, 0x20, 0x18, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0xC3, 0x08, 0x61, 0x0C, 0x00,
  0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x20,
  0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x03,
  0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x07,
  0x00, 0xC0, 0x38, 0x38, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x3C, 0x1D, 0x86,
  0x23, 0x8C, 0xC1, 0xB0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x0E, 0x01, 0x80, 0x60,
  0x03, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80,
  0x1C, 0x03, 0x81, 0xC0, 0x06, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC2, 0x00, 0x0E, 0x0F, 0x80, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x02, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0x40, 0x00, 0x31, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x60, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x03, 0x01,
  0x80, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x01,
  0x80, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x81, 0x80, 0x06, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x01, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x09,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x80, 0x07, 0x03, 0xC0, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0xFF, 0x01, 0x9C, 0x1E, 0x0D, 0x80, 0x30, 0x58, 0x00,
  0xC3, 0x80, 0x06, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x60, 0x80, 0x03, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00, 0x70,
  0x70, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x30, 0x30, 0x01, 0x83,
  0x00, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x0C, 0x06, 0x00, 0xE0, 0x30, 0x0E, 0x00, 0xE1, 0xC0, 0x03,
  0xB8, 0x00, 0x0F, 0x00, 0x01, 0xEE, 0x00, 0x38, 0x38, 0x07, 0x00, 0x60,
  0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x11, 0x80, 0x01, 0x86,
  0x00, 0x18, 0x18, 0x01, 0xC0, 0x70, 0x38, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x60, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x03, 0x06,
  0x00, 0x08, 0x20, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0,
  0x00, 0xE3, 0x00, 0x0E, 0x18, 0x00, 0xF0, 0x60, 0x1D, 0x81, 0xFF, 0x88,
  0x03, 0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x03, 0x03, 0xC0, 0x1F, 0xF8, 0x00, 0x02, 0x07,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xE1, 0x80, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x3F, 0xE0, 0x21, 0x00, 0x38,
  0x38, 0x08, 0xC0, 0x38, 0x06, 0x03, 0x30, 0x0C, 0x01, 0x00, 0xD8, 0x06,
  0x00, 0xC0, 0x36, 0x03, 0x00, 0x30, 0x0D, 0x80, 0x80, 0x0C, 0x02, 0x40,
  0x60, 0x02, 0x00, 0x90, 0x18, 0x01, 0x80, 0x6C, 0x06, 0x00, 0x60, 0x1B,
  0x01, 0x00, 0x10, 0x04, 0xC0, 0x40, 0x0C, 0x03, 0x30, 0x10, 0x03, 0x00,
  0xC4, 0x06, 0x01, 0x40, 0x61, 0x01, 0x80, 0xD0, 0x30, 0x60, 0x30, 0xE6,
  0x38, 0x18, 0x07, 0xE0, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x02, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0x90, 0x00, 0x03, 0x10, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x08, 0x00,
  0x30, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x01, 0xFF, 0xF0, 0x03,
  0x00, 0x3C, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x03, 0x00, 0x02, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x04,
  0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x0C,
  0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x18, 0x03, 0xC0, 0x18, 0x00, 0x70, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x30,
  0x00, 0x08, 0x30, 0x00, 0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x40, 0x01, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0xF0, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x3E, 0x00,
  0x30, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80,
  0x40, 0x07, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0x10, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x07, 0xFE, 0x60, 0x03, 0xFF, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x23, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x3C, 0x0F, 0xC0, 0x07,
  0xFF, 0x80, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x10, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x3F, 0xC0, 0x07, 0x80, 0x00, 0x01, 0x80, 0x01, 0xC0, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x9B, 0x00, 0x00, 0x6C, 0xC0, 0x00, 0x1E, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x16, 0x02, 0xC0, 0x00, 0x0D, 0x81, 0x90,
  0x00, 0x06, 0x40, 0x64, 0x00, 0x01, 0xB0, 0x19, 0x80, 0x00, 0xCC, 0x06,
  0x60, 0x00, 0x23, 0x01, 0x18, 0x00, 0x18, 0xC0, 0xC6, 0x00, 0x0C, 0x20,
  0x30, 0x80, 0x03, 0x18, 0x0C, 0x20, 0x01, 0x86, 0x03, 0x0C, 0x00, 0x61,
  0x80, 0x83, 0x00, 0x30, 0x60, 0x60, 0xC0, 0x08, 0x10, 0x18, 0x30, 0x06,
  0x0C, 0x06, 0x04, 0x03, 0x03, 0x01, 0x01, 0x00, 0xC0, 0xC0, 0x40, 0x60,
  0x60, 0x20, 0x30, 0x18, 0x10, 0x18, 0x0C, 0x06, 0x0C, 0x06, 0x03, 0x01,
  0x86, 0x01, 0x80, 0x80, 0x21, 0x80, 0x60, 0x60, 0x08, 0xC0, 0x10, 0x18,
  0x03, 0x20, 0x0C, 0x06, 0x00, 0xD8, 0x03, 0x01, 0x80, 0x34, 0x00, 0xC0,
  0x40, 0x0F, 0x00, 0x30, 0x30, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x02, 0x03, 0x80, 0x00, 0x20,
  0x3C, 0x00, 0x06, 0x02, 0x40, 0x00, 0x60, 0x66, 0x00, 0x06, 0x06, 0x60,
  0x00, 0x40, 0x63, 0x00, 0x0C, 0x06, 0x30, 0x00, 0xC0, 0x41, 0x00, 0x0C,
  0x0C, 0x18, 0x00, 0xC0, 0xC1, 0x80, 0x08, 0x0C, 0x0C, 0x01, 0x80, 0xC0,
  0xC0, 0x18, 0x08, 0x04, 0x01, 0x81, 0x80, 0x60, 0x10, 0x18, 0x02, 0x01,
  0x01, 0x80, 0x30, 0x30, 0x10, 0x03, 0x03, 0x01, 0x00, 0x18, 0x30, 0x30,
  0x01, 0x82, 0x03, 0x00, 0x08, 0x60, 0x30, 0x00, 0xC6, 0x02, 0x00, 0x0C,
  0x60, 0x60, 0x00, 0x66, 0x06, 0x00, 0x06, 0x40, 0x60, 0x00, 0x3C, 0x06,
  0x00, 0x03, 0xC0, 0x40, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x18, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x07, 0x00, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x06, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x08, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x81,
  0x80, 0x03, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xE0, 0x06, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x08, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01,
  0x81, 0x80, 0x06, 0x02, 0x00, 0x18, 0x0C, 0x03, 0xE0, 0x1F, 0xFE, 0x00,
  0x30, 0x08, 0x00, 0x60, 0x18, 0x00, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x70,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x40, 0x03, 0x83,
  0xC0, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x10, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x30, 0x01,
  0xC0, 0x07, 0x83, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01,
  0x8C, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x01, 0x81, 0x00, 0x06, 0x06,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x20, 0x18, 0x00, 0x80, 0x40, 0x02, 0x03, 0x00,
  0x0C, 0x08, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x60, 0x00, 0x11, 0x80, 0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x05, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x02, 0x20,
  0x00, 0xB0, 0x00, 0xC4, 0x00, 0x36, 0x00, 0x10, 0x80, 0x06, 0xC0, 0x06,
  0x10, 0x01, 0x98, 0x00, 0xC2, 0x00, 0x33, 0x00, 0x30, 0x40, 0x0C, 0x60,
  0x06, 0x08, 0x01, 0x8C, 0x01, 0x81, 0x00, 0x60, 0x80, 0x30, 0x30, 0x0C,
  0x10, 0x0C, 0x06, 0x03, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x40, 0x20, 0x18,
  0x08, 0x08, 0x0C, 0x03, 0x03, 0x01, 0x01, 0x00, 0x60, 0x40, 0x20, 0x60,
  0x0C, 0x18, 0x06, 0x0C, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18,
  0x60, 0x06, 0x10, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x0C, 0x40, 0x03, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x32, 0x00, 0x05,
  0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x10, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18,
  0x02, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x01, 0x80, 0x38, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x18, 0x20, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x04, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x02, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x81,
  0x03, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x81, 0x02, 0x06, 0x0C,
  0x18, 0x10, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x08, 0x18, 0x30, 0x60,
  0x40, 0x80, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xA0, 0x00, 0x33, 0x00, 0x02, 0x30, 0x00, 0x61, 0x00,
  0x0C, 0x18, 0x00, 0x81, 0x80, 0x18, 0x08, 0x03, 0x00, 0x80, 0x20, 0x0C,
  0x06, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00,
  0x22, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xC1,
  0x86, 0x0C, 0x10, 0x60, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0xC0, 0xE0,
  0x64, 0x0C, 0x01, 0x20, 0xC0, 0x0D, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC6,
  0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC4, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xA0, 0x80, 0x0F, 0x06, 0x00, 0xD8,
  0x38, 0x0C, 0x80, 0xE1, 0xC4, 0x03, 0xF8, 0x60, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x1E, 0x00,
  0x63, 0xFE, 0x01, 0x98, 0x1C, 0x04, 0xC0, 0x38, 0x36, 0x00, 0x60, 0xF0,
  0x00, 0x83, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x18, 0x70, 0x00, 0xE1, 0xA0, 0x03, 0x04, 0xC0, 0x38, 0x11, 0x83, 0xC0,
  0xC3, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x38, 0x04, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x3C, 0x0C, 0x01, 0xFF, 0x08, 0x03, 0x81, 0x98, 0x06, 0x00, 0xD8,
  0x0C, 0x00, 0x58, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20,
  0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0x40, 0x02, 0xC0,
  0x60, 0x04, 0x80, 0x70, 0x18, 0x80, 0x38, 0x71, 0x80, 0x1F, 0xE1, 0x80,
  0x00, 0x7C, 0x00, 0xFF, 0x01, 0xC0, 0xC1, 0xC0, 0x31, 0x80, 0x19, 0x80,
  0x04, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x20, 0x03, 0xB0, 0x07, 0x1F,
  0xFF, 0x0F, 0xF8, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x10, 0xF0,
  0x70, 0x1F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1E, 0x02, 0x01, 0xFF, 0x08,
  0x07, 0x03, 0x10, 0x18, 0x03, 0x60, 0x60, 0x02, 0xC1, 0x80, 0x03, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x07,
  0x81, 0x00, 0x0B, 0x03, 0x00, 0x24, 0x07, 0x01, 0x98, 0x07, 0x0E, 0x30,
  0x07, 0xF8, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x40,
  0x06, 0x00, 0xE0, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x3C, 0x01, 0x87, 0xF8, 0x0C, 0xE0, 0xE0, 0x4C, 0x01, 0x86, 0xC0, 0x0C,
  0x3C, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00,
  0x04, 0x30, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6,
  0x00, 0x04, 0x30, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00,
  0xC6, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18, 0xC0,
  0x00, 0xC0, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0xFC, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x70, 0x60, 0x0E, 0x04, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0x83,
  0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0x36, 0x00, 0x16,
  0x60, 0x03, 0xC3, 0x00, 0x38, 0x30, 0x03, 0x01, 0x80, 0x20, 0x18, 0x02,
  0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x30,
  0xC0, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0x8F, 0xF0,
  0x3F, 0xC0, 0x46, 0x0E, 0x18, 0x38, 0x13, 0x01, 0x8C, 0x06, 0x05, 0x00,
  0x24, 0x00, 0xC3, 0xC0, 0x0B, 0x00, 0x30, 0xE0, 0x02, 0x80, 0x0C, 0x30,
  0x00, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0x86, 0x00, 0x08, 0x00, 0x21,
  0x80, 0x06, 0x00, 0x18, 0x60, 0x01, 0x80, 0x06, 0x18, 0x00, 0x60, 0x01,
  0x84, 0x00, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x00, 0x10, 0xC0, 0x03, 0x00,
  0x0C, 0x30, 0x00, 0xC0, 0x03, 0x08, 0x00, 0x20, 0x00, 0xC2, 0x00, 0x08,
  0x00, 0x21, 0x80, 0x06, 0x00, 0x18, 0x60, 0x01, 0x80, 0x06, 0x18, 0x00,
  0x60, 0x01, 0x84, 0x00, 0x10, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x07, 0x80, 0x31, 0xFF, 0x01, 0x1C, 0x1C, 0x09, 0x80, 0x30, 0xD8, 0x01,
  0x87, 0x80, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18,
  0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18,
  0x00, 0x18, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x60, 0x06,
  0x0C, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x01, 0x20, 0x00,
  0x16, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x40,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0x83, 0x00, 0x70, 0x1C, 0x1E, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x01, 0x87, 0xF8, 0x01, 0x1C, 0x1C, 0x01,
  0x30, 0x0E, 0x01, 0x60, 0x06, 0x03, 0xC0, 0x02, 0x03, 0x80, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x1A, 0x00, 0x30, 0x1B, 0x00, 0xE0, 0x11, 0x83, 0xC0, 0x30,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x04, 0x07,
  0xFC, 0x20, 0x38, 0x18, 0x81, 0x80, 0x36, 0x0C, 0x00, 0x58, 0x60, 0x00,
  0xE1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x3C,
  0x10, 0x00, 0xB0, 0x60, 0x04, 0x81, 0xC0, 0x66, 0x03, 0x87, 0x18, 0x07,
  0xF8, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x03, 0x1F, 0xC1, 0x18,
  0x00, 0x98, 0x00, 0x58, 0x00, 0x78, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xF0, 0x70, 0x18, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x20, 0x03, 0x0F, 0x03,
  0x80, 0xFF, 0xC0, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x01, 0xFF, 0xF1, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC2,
  0x03, 0xF0, 0x00, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x04, 0x30,
  0x00, 0x21, 0x80, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x38, 0xC0, 0x01, 0x86,
  0x00, 0x14, 0x30, 0x01, 0xE0, 0x80, 0x1B, 0x06, 0x01, 0x98, 0x18, 0x38,
  0x80, 0x7F, 0x04, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x19, 0x00, 0x06, 0x20,
  0x00, 0xC6, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x01, 0x83, 0x00, 0x60, 0x60,
  0x0C, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x18, 0x03, 0x02, 0x00, 0x60,
  0xC0, 0x0C, 0x30, 0x00, 0x86, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0x6C,
  0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x3A, 0x00, 0x30, 0x01, 0x90, 0x03, 0xC0, 0x08, 0x80, 0x16,
  0x00, 0xC4, 0x01, 0xB0, 0x04, 0x20, 0x09, 0x80, 0x61, 0x00, 0xCC, 0x02,
  0x0C, 0x04, 0x60, 0x30, 0x60, 0x61, 0x01, 0x83, 0x02, 0x08, 0x18, 0x18,
  0x30, 0x40, 0xC0, 0xC1, 0x02, 0x0C, 0x06, 0x18, 0x18, 0x60, 0x30, 0x80,
  0xC6, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0x40, 0x33, 0x00, 0x66, 0x01, 0x98,
  0x03, 0x20, 0x0C, 0x80, 0x1B, 0x00, 0x6C, 0x00, 0x50, 0x01, 0x40, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x02, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0x36,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x30, 0x04, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x08, 0x06,
  0x00, 0x18, 0x38, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00,
  0x60, 0x08, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x86, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x78, 0x1E, 0x0D, 0x00, 0x3F,
  0xC0, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 31, 10, 1, -31 },
  { 36, 10, 11, 14, 5, -31 },
  { 50, 27, 31, 27, 1, -31 },
  { 155, 21, 36, 24, 2, -33 },
  { 250, 28, 33, 34, 4, -32 },
  { 366, 26, 32, 30, 2, -32 },
  { 470, 4, 11, 8, 5, -31 },
  { 476, 13, 38, 11, 1, -31 },
  { 538, 13, 38, 11, -3, -31 },
  { 600, 19, 18, 24, 5, -33 },
  { 643, 21, 21, 25, 3, -26 },
  { 699, 6, 11, 9, -2, -5 },
  { 708, 10, 2, 14, 2, -13 },
  { 711, 3, 3, 10, 1, -3 },
  { 713, 20, 31, 14, -2, -31 },
  { 791, 20, 32, 24, 3, -32 },
  { 871, 11, 31, 24, 7, -31 },
  { 914, 22, 32, 24, 0, -32 },
  { 1002, 22, 32, 24, 1, -32 },
  { 1090, 22, 32, 24, 1, -32 },
  { 1178, 22, 31, 24, 2, -31 },
  { 1264, 21, 32, 24, 3, -32 },
  { 1348, 20, 31, 24, 5, -31 },
  { 1426, 21, 32, 24, 2, -32 },
  { 1510, 21, 32, 24, 2, -32 },
  { 1594, 8, 24, 10, 1, -24 },
  { 1618, 10, 30, 10, -2, -24 },
  { 1656, 21, 20, 25, 3, -26 },
  { 1709, 21, 11, 25, 3, -21 },
  { 1738, 21, 20, 25, 3, -26 },
  { 1791, 15, 32, 18, 4, -32 },
  { 1851, 34, 35, 37, 2, -31 },
  { 2000, 24, 32, 24, -2, -32 },
  { 2096, 24, 31, 26, 2, -31 },
  { 2189, 24, 32, 26, 4, -32 },
  { 2285, 26, 31, 30, 2, -31 },
  { 2386, 23, 31, 23, 2, -31 },
  { 2476, 23, 31, 21, 2, -31 },
  { 2566, 25, 32, 30, 4, -32 },
  { 2666, 28, 31, 30, 2, -31 },
  { 2775, 15, 31, 13, 0, -31 },
  { 2834, 18, 39, 11, -7, -31 },
  { 2922, 26, 31, 24, 2, -31 },
  { 3023, 16, 31, 21, 2, -31 },
  { 3085, 34, 31, 36, 2, -31 },
  { 3217, 28, 31, 30, 2, -31 },
  { 3326, 26, 32, 32, 4, -32 },
  { 3430, 23, 31, 25, 2, -31 },
  { 3520, 26, 39, 32, 4, -32 },
  { 3647, 23, 31, 25, 2, -31 },
  { 3737, 21, 32, 22, 1, -32 },
  { 3821, 21, 31, 21, 4, -31 },
  { 3903, 26, 31, 30, 4, -31 },
  { 4004, 22, 31, 24, 5, -31 },
  { 4090, 35, 31, 37, 5, -31 },
  { 4226, 28, 31, 22, -3, -31 },
  { 4335, 22, 31, 22, 4, -31 },
  { 4421, 25, 31, 24, 0, -31 },
  { 4518, 16, 38, 13, 0, -31 },
  { 4594, 7, 31, 14, 4, -31 },
  { 4622, 16, 38, 13, -3, -31 },
  { 4698, 20, 20, 24, 2, -32 },
  { 4748, 17, 1, 17, -4, 5 },
  { 4751, 6, 7, 10, 6, -34 },
  { 4757, 21, 24, 24, 2, -24 },
  { 4820, 22, 33, 25, 1, -33 },
  { 4911, 18, 24, 20, 2, -24 },
  { 4965, 24, 33, 25, 2, -33 },
  { 5064, 17, 24, 22, 3, -24 },
  { 5115, 24, 45, 12, -6, -34 },
  { 5250, 23, 35, 25, 1, -24 },
  { 5351, 21, 33, 25, 1, -33 },
  { 5438, 9, 32, 10, 1, -32 },
  { 5474, 16, 43, 10, -6, -32 },
  { 5560, 20, 33, 20, 1, -33 },
  { 5643, 9, 33, 10, 1, -33 },
  { 5681, 34, 24, 37, 1, -24 },
  { 5783, 21, 24, 25, 1, -24 },
  { 5846, 20, 24, 25, 2, -24 },
  { 5906, 24, 34, 25, -1, -24 },
  { 6008, 22, 34, 25, 2, -24 },
  { 6102, 17, 24, 17, 1, -24 },
  { 6153, 18, 24, 19, 0, -24 },
  { 6207, 13, 29, 14, 2, -29 },
  { 6255, 21, 23, 25, 2, -23 },
  { 6316, 19, 23, 19, 2, -23 },
  { 6371, 29, 23, 29, 2, -23 },
  { 6455, 23, 23, 20, -2, -23 },
  { 6522, 26, 34, 19, -5, -23 },
  { 6633, 20, 23, 19, -1, -23 },
  { 6691, 16, 38, 15, 1, -31 },
  { 6767, 2, 44, 24, 12, -33 },
  { 6778, 16, 38, 15, -2, -31 },
  { 6854, 21, 5, 25, 3, -18 },
};

const GFXfont NotoSans_ExtraLightItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRALIGHTITALIC44PT7B_H_
