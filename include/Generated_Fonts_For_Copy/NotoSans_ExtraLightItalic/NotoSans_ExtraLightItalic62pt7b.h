#ifndef _NOTOSANS_EXTRALIGHTITALIC62PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x18, 0x0C, 0xE0,
  0x73, 0x81, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x98, 0x0C, 0x60,
  0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xE6, 0xFF, 0x00, 0x78, 0x70, 0x30, 0x0F, 0x03,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x03, 0xE6, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xDF, 0x00, 0x00, 0x04, 0x3C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x03, 0xC0, 0xC0, 0x18, 0x3C, 0x07, 0xF0, 0xDF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x04, 0x01,
  0xFF, 0x00, 0x00, 0x38, 0x03, 0xC7, 0x80, 0x00, 0x30, 0x07, 0x01, 0x80,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x30, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x60, 0x01, 0x80,
  0xE0, 0x00, 0xE0, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x03, 0x81, 0x80, 0x00,
  0xE0, 0x03, 0x03, 0x03, 0xF0, 0xE0, 0x03, 0x07, 0x0F, 0xF8, 0xE0, 0x07,
  0x0E, 0x1E, 0x1C, 0xE0, 0x06, 0x0C, 0x38, 0x0E, 0x60, 0x0E, 0x18, 0x30,
  0x06, 0x60, 0x1C, 0x38, 0x60, 0x06, 0x70, 0x38, 0x70, 0xE0, 0x06, 0x38,
  0x70, 0x60, 0xC0, 0x06, 0x1F, 0xE0, 0xC0, 0xC0, 0x07, 0x0F, 0x81, 0xC1,
  0xC0, 0x06, 0x00, 0x01, 0x81, 0x80, 0x06, 0x00, 0x03, 0x01, 0x80, 0x06,
  0x00, 0x07, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x03, 0x80, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x60,
  0x0E, 0x00, 0x01, 0x80, 0xC0, 0x1C, 0x00, 0x01, 0xF7, 0xC0, 0x38, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x08, 0x38, 0x03, 0x00, 0x01, 0x87, 0x80, 0x0C, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0x00, 0xC3, 0x80, 0x01, 0xC0, 0x0E, 0x38, 0x00,
  0x06, 0x00, 0x61, 0x80, 0x00, 0x38, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0xC0, 0x00, 0x03, 0x83, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x30, 0x00, 0x00,
  0x73, 0x81, 0x80, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x60,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x7B,
  0x80, 0x70, 0x00, 0x07, 0x0C, 0x03, 0xC0, 0x00, 0xF0, 0x70, 0x0F, 0x80,
  0x1F, 0x01, 0xC0, 0x3F, 0xFF, 0xE0, 0x06, 0x00, 0x7F, 0xFC, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x19, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x18,
  0xCC, 0x63, 0x18, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x08, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0xF8, 0x0C, 0x00,
  0x0F, 0x83, 0x00, 0x00, 0xF0, 0x80, 0x00, 0x0F, 0x20, 0x03, 0x00, 0xF9,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x38, 0x0C, 0x00,
  0x1C, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x80, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x30, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xF6, 0x03, 0xCE,
  0x07, 0x8E, 0x1E, 0x0C, 0x3C, 0x0C, 0xF0, 0x1C, 0x60, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0x80, 0x04, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE1,
  0xF8, 0x00, 0x7C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x0B, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x07, 0x80,
  0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x81, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x81, 0xFF, 0x80, 0x0E, 0x1F, 0xFF, 0x80, 0x31,
  0xE0, 0x0F, 0x00, 0xCE, 0x00, 0x1E, 0x07, 0x70, 0x00, 0x38, 0x1F, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x0F,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x86, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x06, 0xC0, 0xE0, 0x00, 0x66, 0x07, 0x80, 0x0E, 0x70, 0x1F,
  0x03, 0xE3, 0x00, 0x3F, 0xFC, 0x18, 0x00, 0x7F, 0x81, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x20, 0x03, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x10, 0x00, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xF8, 0x7E,
  0x06, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xC3, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0x8E, 0x00, 0x0F, 0x00, 0x70, 0x03, 0x18, 0x00, 0x78,
  0x00, 0xC0, 0x06, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0xE0, 0x03, 0x00,
  0x03, 0x00, 0x19, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x33, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x6E, 0x00, 0x60, 0x00, 0x30, 0x00, 0xD8, 0x01, 0xC0, 0x00,
  0x60, 0x01, 0xB0, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x60, 0x06, 0x00, 0x03,
  0x00, 0x0E, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x1B, 0x80, 0x38, 0x00, 0x1C,
  0x00, 0x37, 0x00, 0x70, 0x00, 0x38, 0x00, 0xEE, 0x00, 0xC0, 0x00, 0x60,
  0x01, 0x9C, 0x01, 0x80, 0x01, 0xC0, 0x07, 0x38, 0x03, 0x00, 0x07, 0x80,
  0x0C, 0x30, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x60, 0x06, 0x00, 0x36, 0x00,
  0xE0, 0xC0, 0x0E, 0x00, 0xCE, 0x03, 0x81, 0x80, 0x1E, 0x07, 0x0C, 0x0E,
  0x03, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x1F,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x80, 0x60, 0x00, 0x0F,
  0x80, 0x70, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x40,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x00, 0xC0, 0x00, 0x7C,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x60,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFC, 0xE0, 0x00,
  0x1F, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x0C, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x00,
  0x06, 0x3B, 0x00, 0x00, 0x00, 0x67, 0x38, 0x00, 0x00, 0x06, 0xC1, 0x80,
  0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x1B, 0x80, 0x00, 0x00, 0x1D, 0x80, 0x33, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x66, 0x00, 0x00, 0x00, 0xCE, 0x01, 0xCC, 0x00, 0x00, 0x03, 0x98,
  0x03, 0x98, 0x00, 0x00, 0x06, 0x30, 0x06, 0x38, 0x00, 0x00, 0x1C, 0x60,
  0x0C, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x80,
  0x70, 0xC0, 0x00, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x00, 0x1C, 0x38, 0x03, 0x07, 0x00, 0x00, 0x30, 0x70, 0x06,
  0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x38,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x1C, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x30, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x0C,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x18, 0x03, 0x00, 0x38,
  0x06, 0x00, 0x70, 0x06, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x00, 0x70, 0x01, 0x81,
  0x80, 0x06, 0x00, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0x03, 0x00, 0x06, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0x19, 0x80, 0x01, 0x80, 0x30, 0x00, 0x36, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x18, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x0F, 0x80,
  0x00, 0x00, 0xC0, 0x1B, 0x80, 0x00, 0x03, 0x80, 0x33, 0x00, 0x00, 0x07,
  0x00, 0x67, 0x00, 0x00, 0x0C, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x03, 0x8E,
  0x00, 0x00, 0x30, 0x06, 0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x18, 0x00, 0x01,
  0xC0, 0x18, 0x38, 0x00, 0x03, 0x00, 0x70, 0x30, 0x00, 0x06, 0x00, 0xE0,
  0x70, 0x00, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x38, 0x03, 0x00, 0xC0, 0x00,
  0x70, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x07, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x80, 0x30, 0x00, 0x38,
  0x06, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x00, 0xE0, 0x70, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x38, 0x00, 0x01, 0x83, 0x00, 0x70, 0x00, 0x03, 0x86, 0x00,
  0xC0, 0x00, 0x03, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x30, 0x03, 0x00, 0x00,
  0x0E, 0x60, 0x0E, 0x00, 0x00, 0x0C, 0xC0, 0x1C, 0x00, 0x00, 0x1D, 0x80,
  0x30, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x01, 0xE0, 0x06, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x60, 0x01,
  0xF8, 0x00, 0x60, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00,
  0xF0, 0x06, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xE0, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x40, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x01,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x36, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x3B, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x18,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x07,
  0x01, 0x80, 0x03, 0x81, 0x80, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x1C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x06, 0x00, 0x60, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x00, 0x60, 0x1C, 0x00, 0xC0,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x01,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x00, 0x0F,
  0xF8, 0x18, 0x01, 0xFF, 0xE0, 0xC0, 0x3E, 0x03, 0x86, 0x03, 0xC0, 0x06,
  0x60, 0x38, 0x00, 0x33, 0x03, 0x80, 0x00, 0xD8, 0x1C, 0x00, 0x06, 0xC1,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xD8, 0x18, 0x00, 0x0F, 0xC0,
  0xE0, 0x00, 0x6C, 0x07, 0x00, 0x0E, 0x60, 0x1C, 0x00, 0xE3, 0x00, 0xF0,
  0x0E, 0x18, 0x03, 0xFF, 0xE0, 0xC0, 0x07, 0xFC, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0F, 0xF8, 0x00, 0x60,
  0xFF, 0xF0, 0x03, 0x8F, 0x01, 0xE0, 0x0E, 0x70, 0x01, 0xC0, 0x33, 0x80,
  0x03, 0x80, 0xDC, 0x00, 0x0E, 0x03, 0x60, 0x00, 0x18, 0x1F, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x30, 0x6C, 0x00, 0x01, 0xC1,
  0xB0, 0x00, 0x0E, 0x06, 0x60, 0x00, 0x70, 0x19, 0xC0, 0x03, 0x80, 0xE3,
  0x80, 0x3C, 0x03, 0x07, 0xFF, 0xE0, 0x0C, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x60,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0xE0, 0x30, 0x00, 0x7F, 0xFC, 0x38, 0x00, 0xF8, 0x07, 0x1C, 0x00,
  0xF0, 0x01, 0xCC, 0x00, 0xE0, 0x00, 0x66, 0x00, 0xE0, 0x00, 0x1B, 0x00,
  0x60, 0x00, 0x0D, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1B, 0x00, 0x60, 0x00,
  0x1B, 0x80, 0x38, 0x00, 0x1D, 0x80, 0x1C, 0x00, 0x1C, 0xC0, 0x07, 0x00,
  0x1C, 0x60, 0x03, 0xC0, 0x3C, 0x30, 0x00, 0xFF, 0xF8, 0x30, 0x00, 0x1F,
  0xF8, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x3C, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3,
  0x00, 0x03, 0xC3, 0x80, 0x0F, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x80, 0x78, 0x01, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x38, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x06, 0x00, 0x3F,
  0xFE, 0x0C, 0x01, 0xF0, 0x0E, 0x18, 0x07, 0x80, 0x0E, 0x60, 0x1C, 0x00,
  0x0C, 0xC0, 0x70, 0x00, 0x0D, 0x80, 0xE0, 0x00, 0x1B, 0x03, 0x80, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0D, 0x80, 0xC0,
  0x00, 0x37, 0x01, 0xC0, 0x00, 0xEC, 0x03, 0x80, 0x03, 0x98, 0x03, 0x80,
  0x0E, 0x30, 0x07, 0x80, 0x70, 0xE0, 0x07, 0xFF, 0xC1, 0xC0, 0x03, 0xFE,
  0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x1E, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x03, 0xFE, 0x00, 0x30, 0x7F, 0xFC, 0x03, 0x87,
  0x00, 0xF0, 0x1C, 0xE0, 0x03, 0x80, 0xCE, 0x00, 0x0E, 0x06, 0xE0, 0x00,
  0x70, 0x36, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0x8F, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x60, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC7, 0xC0,
  0x00, 0x1C, 0xEC, 0x00, 0x01, 0x9C, 0xE0, 0x00, 0x1B, 0x86, 0x00, 0x01,
  0xF0, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01,
  0x80, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00,
  0x01, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0C, 0x38, 0x0F, 0x03, 0x80, 0xF0, 0x18, 0xE0, 0x0E, 0x1C, 0x00, 0xE0,
  0x33, 0x00, 0x0C, 0x30, 0x00, 0xE0, 0x6C, 0x00, 0x1C, 0xC0, 0x01, 0xC0,
  0xD0, 0x00, 0x1B, 0x00, 0x03, 0x83, 0x60, 0x00, 0x3C, 0x00, 0x03, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0xFF, 0x80, 0x0C, 0x1F, 0xFF, 0x00, 0xC3, 0xC0,
  0x3C, 0x06, 0x38, 0x00, 0xE0, 0x33, 0x80, 0x03, 0x81, 0xB8, 0x00, 0x1C,
  0x1D, 0x80, 0x00, 0xE0, 0xF8, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0x18,
  0x3F, 0xFC, 0x00, 0x18, 0x78, 0x0F, 0x00, 0x0C, 0x70, 0x01, 0xC0, 0x06,
  0x70, 0x00, 0x70, 0x03, 0x70, 0x00, 0x38, 0x01, 0xB0, 0x00, 0x0C, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0xE0, 0x00, 0x0E, 0x01, 0xB0, 0x00,
  0x0E, 0x00, 0xCC, 0x00, 0x0E, 0x00, 0x67, 0x00, 0x0E, 0x00, 0x71, 0xC0,
  0x1E, 0x00, 0x38, 0x7F, 0xFE, 0x00, 0x18, 0x1F, 0xFC, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x0C, 0x00, 0xFF, 0xF8, 0x30, 0x0F, 0x80, 0x70, 0xC0,
  0x78, 0x00, 0xE6, 0x03, 0x80, 0x01, 0x98, 0x1C, 0x00, 0x03, 0x60, 0x70,
  0x00, 0x0D, 0x83, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x36, 0x06, 0x00, 0x01, 0xB8, 0x1C, 0x00, 0x0E, 0xC0, 0x70, 0x00, 0x73,
  0x00, 0xE0, 0x03, 0x8C, 0x03, 0xC0, 0x3C, 0x70, 0x07, 0xFF, 0xC1, 0xC0,
  0x07, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0x81, 0xFE, 0x03, 0x07, 0xFC, 0x0C, 0x3C, 0x00, 0x18, 0xE0, 0x00,
  0x33, 0x80, 0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x80, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xF8, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x58, 0x38, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0x6E, 0x06, 0x00, 0x06,
  0x60, 0x38, 0x00, 0xE3, 0x00, 0xE0, 0x0E, 0x18, 0x07, 0xFF, 0xE0, 0xC0,
  0x0F, 0xFC, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x07,
  0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x18, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30,
  0x00, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x18, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30,
  0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x60,
  0x00, 0x7C, 0x00, 0x0E, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x60, 0x00, 0xEC,
  0x00, 0x1C, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x60, 0x01, 0xCC, 0x00, 0x38,
  0x60, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x03, 0x8C, 0x00, 0x70, 0x60, 0x03,
  0x0C, 0x00, 0x60, 0x60, 0x07, 0x0C, 0x00, 0xE0, 0x60, 0x06, 0x0E, 0x00,
  0xC0, 0x60, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x0E, 0x01, 0x80, 0x70,
  0x1C, 0x06, 0x03, 0x80, 0x70, 0x18, 0x06, 0x03, 0x80, 0x70, 0x38, 0x06,
  0x03, 0x00, 0x70, 0x30, 0x06, 0x07, 0x00, 0x70, 0x70, 0x06, 0x06, 0x00,
  0x30, 0x60, 0x06, 0x0E, 0x00, 0x30, 0xE0, 0x06, 0x0C, 0x00, 0x30, 0xC0,
  0x06, 0x1C, 0x00, 0x31, 0xC0, 0x07, 0x18, 0x00, 0x31, 0x80, 0x07, 0x38,
  0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x37,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x3C, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xFF, 0xC8, 0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_ExtraLightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 45, 14, 2, -44 },
  { 69, 14, 16, 20, 7, -44 },
  { 97, 37, 44, 39, 2, -44 },
  { 301, 29, 51, 34, 3, -47 },
  { 486, 40, 46, 48, 5, -45 },
  { 716, 37, 46, 42, 3, -45 },
  { 929, 5, 16, 11, 7, -44 },
  { 939, 18, 54, 16, 2, -44 },
  { 1061, 18, 54, 16, -4, -44 },
  { 1183, 26, 27, 33, 8, -47 },
  { 1271, 28, 29, 35, 5, -36 },
  { 1373, 9, 15, 12, -3, -7 },
  { 1390, 15, 2, 19, 2, -18 },
  { 1394, 4, 5, 14, 2, -4 },
  { 1397, 28, 44, 20, -3, -44 },
  { 1551, 29, 46, 34, 4, -45 },
  { 1718, 16, 44, 34, 10, -44 },
  { 1806, 31, 45, 34, 1, -45 },
  { 1981, 32, 46, 34, 1, -45 },
  { 2165, 32, 44, 34, 1, -44 },
  { 2341, 31, 45, 34, 2, -44 },
  { 2516, 30, 46, 34, 4, -45 },
  { 2689, 28, 44, 34, 7, -44 },
  { 2843, 30, 46, 34, 3, -45 },
  { 3016, 29, 46, 34, 3, -45 },
  { 3183, 10, 34, 14, 2, -33 },
  { 3226, 15, 41, 14, -3, -33 },
  { 3303, 28, 29, 35, 5, -37 },
  { 3405, 28, 14, 35, 5, -29 },
  { 3454, 28, 29, 35, 5, -37 },
  { 3556, 22, 46, 25, 5, -45 },
  { 3683, 47, 50, 52, 3, -44 },
  { 3977, 34, 44, 34, -3, -44 },
  { 4164, 33, 44, 37, 3, -44 },
  { 4346, 34, 46, 37, 5, -45 },
  { 4542, 37, 44, 42, 3, -44 },
  { 4746, 32, 44, 33, 3, -44 },
  { 4922, 32, 44, 30, 3, -44 },
  { 5098, 36, 46, 43, 5, -45 },
  { 5305, 39, 44, 42, 3, -44 },
  { 5520, 20, 44, 18, 0, -44 },
  { 5630, 25, 55, 15, -10, -44 },
  { 5802, 36, 44, 34, 3, -44 },
  { 6000, 23, 44, 30, 3, -44 },
  { 6127, 47, 44, 50, 3, -44 },
  { 6386, 39, 44, 42, 3, -44 },
  { 6601, 37, 46, 44, 5, -45 },
  { 6814, 32, 44, 35, 3, -44 },
  { 6990, 37, 56, 44, 5, -45 },
  { 7249, 32, 44, 35, 3, -44 },
  { 7425, 31, 46, 31, 1, -45 },
  { 7604, 30, 44, 30, 6, -44 },
  { 7769, 38, 45, 43, 5, -44 },
  { 7983, 32, 44, 33, 6, -44 },
  { 8159, 49, 44, 52, 7, -44 },
  { 8429, 40, 44, 31, -4, -44 },
  { 8649, 30, 44, 30, 6, -44 },
  { 8814, 36, 44, 33, -1, -44 },
  { 9012, 24, 54, 19, -1, -44 },
  { 9174, 10, 44, 20, 6, -44 },
  { 9229, 23, 54, 19, -4, -44 },
  { 9385, 29, 28, 34, 3, -45 },
  { 9487, 23, 2, 23, -5, 7 },
  { 9493, 8, 9, 15, 9, -47 },
  { 9502, 29, 34, 34, 3, -33 },
  { 9626, 30, 48, 35, 2, -47 },
  { 9806, 25, 34, 28, 3, -33 },
  { 9913, 33, 48, 35, 3, -47 },
  { 10111, 25, 34, 31, 4, -33 },
  { 10218, 34, 62, 17, -8, -47 },
  { 10482, 31, 48, 35, 2, -33 },
  { 10668, 29, 47, 35, 2, -47 },
  { 10839, 12, 45, 13, 2, -45 },
  { 10907, 23, 60, 13, -9, -45 },
  { 11080, 28, 47, 28, 2, -47 },
  { 11245, 12, 47, 13, 2, -47 },
  { 11316, 47, 33, 53, 2, -33 },
  { 11510, 29, 33, 35, 2, -33 },
  { 11630, 29, 34, 35, 3, -33 },
  { 11754, 33, 48, 35, -1, -33 },
  { 11952, 30, 48, 35, 3, -33 },
  { 12132, 23, 33, 23, 2, -33 },
  { 12227, 24, 34, 26, 1, -33 },
  { 12329, 18, 42, 19, 3, -41 },
  { 12424, 29, 34, 35, 3, -33 },
  { 12548, 26, 33, 26, 3, -33 },
  { 12656, 40, 33, 41, 3, -33 },
  { 12821, 32, 33, 29, -2, -33 },
  { 12953, 36, 48, 26, -7, -33 },
  { 13169, 28, 33, 27, -1, -33 },
  { 13285, 23, 54, 21, 1, -44 },
  { 13441, 2, 62, 33, 17, -47 },
  { 13457, 22, 54, 21, -3, -44 },
  { 13606, 28, 6, 35, 5, -25 },
};

const GFXfont NotoSans_ExtraLightItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRALIGHTITALIC62PT7B_H_
