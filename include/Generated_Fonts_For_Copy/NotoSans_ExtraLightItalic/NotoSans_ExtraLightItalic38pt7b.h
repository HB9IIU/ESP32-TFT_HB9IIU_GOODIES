#ifndef _NOTOSANS_EXTRALIGHTITALIC38PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x40, 0xE0, 0xC0, 0x31, 0x90, 0xD8, 0x4C, 0x24, 0x12, 0x19, 0x08,
  0x84, 0x82, 0x41, 0x00, 0x00, 0x10, 0x10, 0x00, 0x60, 0x60, 0x00, 0x80,
  0x80, 0x01, 0x01, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x20, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x02, 0x02, 0x00,
  0x0C, 0x04, 0x00, 0x10, 0x18, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x01,
  0x81, 0x80, 0x02, 0x02, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x20,
  0x30, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x03, 0x03, 0x00, 0x04, 0x04,
  0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x00, 0x40, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xC1, 0x84, 0x20,
  0xC3, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x0C, 0x40, 0x03, 0x90, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xB8,
  0x00, 0x23, 0x00, 0x08, 0x60, 0x02, 0x08, 0x01, 0x82, 0x00, 0x40, 0x80,
  0x10, 0x60, 0x04, 0x10, 0x81, 0x0C, 0x3C, 0xDC, 0x03, 0xFC, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xC0, 0x06, 0x18, 0x60, 0x0C, 0x30, 0x20, 0x08, 0x20, 0x20, 0x10, 0x20,
  0x20, 0x30, 0x60, 0x20, 0x60, 0x40, 0x20, 0x40, 0x40, 0x20, 0x80, 0xC0,
  0x61, 0x80, 0xC0, 0x43, 0x00, 0xC0, 0x42, 0x08, 0xC0, 0xC4, 0x7E, 0xC0,
  0x8C, 0xC3, 0xC1, 0x98, 0x81, 0x63, 0x11, 0x01, 0x7E, 0x31, 0x01, 0x08,
  0x63, 0x01, 0x00, 0x42, 0x01, 0x00, 0x82, 0x01, 0x01, 0x82, 0x03, 0x03,
  0x06, 0x03, 0x02, 0x06, 0x02, 0x04, 0x06, 0x06, 0x0C, 0x06, 0x04, 0x18,
  0x02, 0x0C, 0x10, 0x03, 0x18, 0x20, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x03,
  0xFC, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x20, 0x03, 0x00, 0xC0, 0x08, 0x03,
  0x00, 0x20, 0x0C, 0x00, 0x80, 0x20, 0x02, 0x01, 0x80, 0x08, 0x0C, 0x00,
  0x30, 0x60, 0x00, 0x67, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x66,
  0x00, 0x07, 0x08, 0x01, 0x30, 0x30, 0x0D, 0x80, 0x60, 0x24, 0x00, 0xC1,
  0xB0, 0x01, 0x04, 0x80, 0x06, 0x22, 0x00, 0x0D, 0x88, 0x00, 0x1C, 0x20,
  0x00, 0x60, 0xC0, 0x03, 0xC3, 0x00, 0x39, 0x87, 0x03, 0x82, 0x07, 0xF8,
  0x0C, 0x32, 0x66, 0x44, 0x44, 0x88, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x10, 0x00, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x80, 0x80,
  0xE1, 0x00, 0x39, 0x00, 0x0D, 0x0F, 0x03, 0xFF, 0x07, 0x00, 0x0C, 0x80,
  0x18, 0x80, 0x30, 0xC0, 0x60, 0x40, 0x40, 0x60, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x21, 0x84, 0x30, 0x86, 0x10, 0xC0, 0xFF, 0x80, 0x5F, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0x80, 0x38, 0x30, 0x18, 0x06, 0x04, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C,
  0x40, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xD8, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00, 0xC4, 0x00, 0x61,
  0x00, 0x10, 0x60, 0x0C, 0x08, 0x06, 0x03, 0x87, 0x00, 0x3F, 0x80, 0x01,
  0xC0, 0xE0, 0xE8, 0x66, 0x71, 0xB0, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x0F, 0xF0, 0x07, 0x03, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x1E, 0x07, 0x07,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x10, 0x00, 0xC3, 0x80, 0x70, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xA0, 0x00, 0x36, 0x00, 0x06, 0x40,
  0x00, 0x44, 0x00, 0x08, 0x40, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x08,
  0x00, 0xC0, 0x80, 0x18, 0x18, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01,
  0x00, 0x80, 0x10, 0x10, 0x03, 0x03, 0x00, 0x30, 0x60, 0x02, 0x0F, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xE0, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00,
  0xC0, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x80, 0x0E, 0x1C, 0x07, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x1F, 0xF0, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x87, 0x80, 0x47, 0xF8, 0x16, 0x03, 0x0F, 0x00, 0x63, 0x80, 0x08,
  0xC0, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x18, 0x06, 0x03, 0x07,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x30, 0x18, 0x18, 0x03, 0x04, 0x00,
  0xC3, 0x00, 0x10, 0xC0, 0x04, 0x20, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x20,
  0x40, 0x10, 0x08, 0x18, 0x01, 0x9C, 0x00, 0x3C, 0x00, 0x3B, 0x00, 0x38,
  0x70, 0x30, 0x06, 0x18, 0x00, 0x84, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x01,
  0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x0C, 0xC0, 0x06, 0x18, 0x03, 0x03,
  0x03, 0x80, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x70, 0x30, 0x30,
  0x06, 0x08, 0x00, 0x86, 0x00, 0x21, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00,
  0xC8, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x01, 0xCC, 0x00, 0x63,
  0x00, 0x28, 0x60, 0x36, 0x0F, 0xF9, 0x80, 0x70, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x08, 0x1C, 0x03, 0xFC, 0x00, 0x0C, 0x30, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0E, 0x30, 0x01, 0x80,
  0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80,
  0x80, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x03, 0xFF, 0x08, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x02, 0x30, 0x07, 0xF8, 0x19, 0x00, 0xE0, 0x40, 0xD8,
  0x0C, 0x06, 0x06, 0xC0, 0xC0, 0x30, 0x34, 0x04, 0x01, 0x01, 0xA0, 0x60,
  0x08, 0x0F, 0x02, 0x00, 0xC0, 0x58, 0x10, 0x06, 0x02, 0xC1, 0x80, 0x20,
  0x36, 0x0C, 0x03, 0x01, 0xB0, 0x60, 0x18, 0x09, 0x83, 0x01, 0x40, 0xCC,
  0x08, 0x1A, 0x0C, 0x60, 0x73, 0x99, 0xC1, 0x00, 0xF0, 0x78, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00,
  0x6C, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x10, 0x40,
  0x01, 0x83, 0x00, 0x08, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x02, 0x00, 0x40,
  0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x03, 0xFF, 0xF0, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00,
  0x46, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x07,
  0xFF, 0x80, 0x60, 0x1C, 0x06, 0x00, 0x60, 0x40, 0x03, 0x04, 0x00, 0x30,
  0xC0, 0x01, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x06,
  0x18, 0x00, 0xC1, 0x80, 0x38, 0x1F, 0xFE, 0x01, 0x01, 0xE0, 0x30, 0x01,
  0x83, 0x00, 0x08, 0x30, 0x00, 0xC2, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00,
  0x04, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x01, 0x84, 0x00, 0x18, 0xC0,
  0x07, 0x0C, 0x03, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0x80, 0x38, 0x06, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x18, 0x0F, 0x00, 0x60, 0x06, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x30,
  0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x11, 0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x00, 0x01, 0x84, 0x00, 0x1C,
  0x10, 0x00, 0xE0, 0xC0, 0x0E, 0x03, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xF0, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xB0, 0x03, 0xFC, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x40, 0x60, 0x01, 0x00, 0xE0, 0x3C,
  0x01, 0xFF, 0xC0, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x02,
  0x04, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x08, 0x1F, 0xFF, 0xF8, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20, 0x40, 0x00, 0x60,
  0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x80, 0x00, 0xC0,
  0x03, 0xF8, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0xFE, 0x00, 0xF0, 0x00,
  0x06, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x00, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x02, 0x03, 0x00, 0x08, 0x30,
  0x00, 0x21, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x13, 0xC0, 0x00,
  0x59, 0x00, 0x03, 0x86, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x30, 0x00, 0x80,
  0xC0, 0x02, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x40, 0x10, 0x01, 0x80, 0xC0, 0x02, 0x03, 0x00, 0x0C, 0x08,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0x40,
  0x00, 0x14, 0x0A, 0x00, 0x01, 0xA0, 0x50, 0x00, 0x0B, 0x06, 0xC0, 0x00,
  0xD8, 0x36, 0x00, 0x04, 0x81, 0x10, 0x00, 0x44, 0x08, 0x80, 0x06, 0x60,
  0x44, 0x00, 0x23, 0x06, 0x20, 0x03, 0x18, 0x31, 0x80, 0x10, 0x81, 0x0C,
  0x01, 0x84, 0x08, 0x20, 0x18, 0x60, 0xC1, 0x00, 0x83, 0x06, 0x08, 0x0C,
  0x18, 0x30, 0x40, 0x40, 0x81, 0x03, 0x06, 0x04, 0x08, 0x18, 0x60, 0x60,
  0xC0, 0x42, 0x03, 0x06, 0x02, 0x30, 0x10, 0x20, 0x11, 0x00, 0x81, 0x00,
  0x98, 0x04, 0x08, 0x06, 0x80, 0x60, 0xC0, 0x38, 0x03, 0x06, 0x00, 0xC0,
  0x10, 0x20, 0x04, 0x00, 0x80, 0x06, 0x00, 0x03, 0x07, 0x00, 0x02, 0x07,
  0x00, 0x02, 0x05, 0x00, 0x02, 0x05, 0x80, 0x06, 0x0C, 0x80, 0x06, 0x0C,
  0xC0, 0x04, 0x08, 0x40, 0x04, 0x08, 0x40, 0x0C, 0x08, 0x60, 0x0C, 0x18,
  0x20, 0x0C, 0x18, 0x30, 0x08, 0x10, 0x10, 0x08, 0x10, 0x18, 0x18, 0x30,
  0x18, 0x18, 0x30, 0x08, 0x10, 0x30, 0x0C, 0x10, 0x20, 0x04, 0x10, 0x20,
  0x06, 0x30, 0x60, 0x02, 0x30, 0x60, 0x02, 0x20, 0x40, 0x03, 0x20, 0x40,
  0x01, 0x20, 0x40, 0x01, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0x80,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x01, 0xC0, 0x38,
  0x01, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00,
  0x02, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C,
  0x00, 0x01, 0x88, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0x38, 0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0xC0, 0xF0, 0x18, 0x03, 0x02, 0x00, 0x30, 0x40, 0x06, 0x18,
  0x00, 0x43, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x61, 0x00, 0x18, 0x20, 0x0E, 0x0F, 0xFF, 0x01, 0xFF,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x18, 0x00, 0x02, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x4C, 0x00, 0x01, 0x88, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x70, 0x03, 0x00, 0x38, 0x1C, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0xC0, 0x70, 0x18,
  0x03, 0x02, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0x43, 0x00, 0x08, 0x40,
  0x01, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x00,
  0x38, 0x20, 0x3C, 0x0F, 0xFE, 0x01, 0x80, 0x80, 0x30, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x08, 0x10, 0x01,
  0x82, 0x00, 0x30, 0xC0, 0x02, 0x18, 0x00, 0x62, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x7F, 0xE0, 0x38, 0x0C, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x0C, 0x03, 0x81,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x10, 0x00,
  0x0C, 0x20, 0x00, 0x18, 0x40, 0x00, 0x31, 0x80, 0x00, 0x43, 0x00, 0x00,
  0x84, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00, 0x10,
  0xC0, 0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18,
  0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00, 0x63, 0x00,
  0x00, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x10, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x70, 0x1C, 0x00, 0x3F, 0xE0,
  0x00, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x4C, 0x00,
  0x18, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x06, 0x0C, 0x00,
  0x81, 0x80, 0x30, 0x30, 0x04, 0x06, 0x01, 0x80, 0x40, 0x60, 0x08, 0x08,
  0x01, 0x03, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0,
  0x03, 0x10, 0x00, 0x26, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x14, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x0D, 0x00, 0x14, 0x00, 0x68, 0x00, 0xB0, 0x02,
  0x40, 0x0D, 0x80, 0x32, 0x00, 0x4C, 0x01, 0x10, 0x06, 0x60, 0x18, 0x80,
  0x23, 0x00, 0x84, 0x03, 0x18, 0x0C, 0x30, 0x10, 0x40, 0x41, 0x81, 0x82,
  0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x03, 0x04, 0x04, 0x18,
  0x18, 0x60, 0x20, 0x80, 0xC2, 0x01, 0x0C, 0x06, 0x30, 0x08, 0x40, 0x31,
  0x00, 0x46, 0x00, 0x98, 0x02, 0x20, 0x04, 0x80, 0x1B, 0x00, 0x2C, 0x00,
  0xD0, 0x01, 0x40, 0x06, 0x80, 0x0A, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x04, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x21, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x16, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x86, 0x00, 0x01, 0x02, 0x00, 0x03, 0x03, 0x00, 0x06, 0x01, 0x00, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x80, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x11,
  0x00, 0x0C, 0x40, 0x06, 0x18, 0x03, 0x02, 0x00, 0x80, 0x80, 0x60, 0x30,
  0x30, 0x0C, 0x08, 0x01, 0x06, 0x00, 0x63, 0x00, 0x19, 0x80, 0x02, 0x40,
  0x00, 0xB0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x82, 0x0C, 0x30, 0x41, 0x04,
  0x10, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x04, 0x10, 0x41, 0x06, 0x18, 0x20,
  0x82, 0x08, 0x30, 0xC0, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1A,
  0x00, 0x19, 0x00, 0x08, 0xC0, 0x0C, 0x20, 0x0C, 0x10, 0x04, 0x0C, 0x06,
  0x02, 0x06, 0x01, 0x02, 0x00, 0x83, 0x00, 0x63, 0x00, 0x11, 0x00, 0x09,
  0x80, 0x07, 0x80, 0x01, 0x80, 0x00, 0x80, 0xFF, 0xFC, 0x8C, 0x42, 0x31,
  0x00, 0x20, 0x00, 0xFE, 0x30, 0x60, 0x48, 0x30, 0x0A, 0x18, 0x02, 0x8C,
  0x00, 0xE2, 0x00, 0x19, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x38,
  0xC0, 0x0C, 0x30, 0x05, 0x06, 0x02, 0x41, 0xC3, 0x10, 0x3F, 0x8C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x8F, 0xE0,
  0x33, 0x06, 0x04, 0x80, 0x60, 0xA0, 0x04, 0x38, 0x00, 0x86, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x22,
  0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01, 0x0A,
  0x00, 0x61, 0x60, 0x18, 0x66, 0x0E, 0x0C, 0x7F, 0x00, 0x00, 0x20, 0x07,
  0xFC, 0x18, 0x08, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x80, 0xFF,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x3F, 0xC4, 0x06, 0x06, 0x40, 0xC0, 0x2C, 0x18, 0x01, 0xC3, 0x00, 0x18,
  0x20, 0x01, 0x86, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x10, 0xC0, 0x01,
  0x0C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00,
  0x60, 0xC0, 0x0A, 0x0C, 0x01, 0xE0, 0x40, 0x36, 0x07, 0x0E, 0x40, 0x3F,
  0x84, 0x00, 0x00, 0x20, 0x03, 0xF8, 0x1C, 0x18, 0x60, 0x11, 0x80, 0x26,
  0x00, 0x48, 0x00, 0xB0, 0x03, 0x60, 0x0C, 0x80, 0xF3, 0xFF, 0x86, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x18, 0x40,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0xC4, 0x0C, 0x0C, 0x83, 0x00, 0xB0, 0xC0, 0x0E, 0x30, 0x01,
  0x84, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x02,
  0x30, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0xC2, 0x00, 0x18,
  0x60, 0x05, 0x0C, 0x01, 0xE0, 0x80, 0x6C, 0x1C, 0x39, 0x01, 0xFC, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x40, 0x18, 0x0E, 0x0E, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x1F, 0xC0, 0xCC, 0x18, 0x24,
  0x03, 0x0A, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00,
  0xC4, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x20, 0x01, 0x88, 0x00, 0x62,
  0x00, 0x11, 0x80, 0x04, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x23, 0x00,
  0x08, 0xC0, 0x06, 0x00, 0x02, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x00, 0x08, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x26, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x43, 0x00, 0x60,
  0xC0, 0x30, 0x20, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x41,
  0x80, 0x10, 0x80, 0x04, 0x40, 0x03, 0x38, 0x00, 0xD2, 0x00, 0x38, 0xC0,
  0x0C, 0x10, 0x02, 0x06, 0x01, 0x80, 0x80, 0x60, 0x30, 0x10, 0x04, 0x04,
  0x01, 0x83, 0x00, 0x20, 0xC0, 0x0C, 0x00, 0x03, 0x03, 0x02, 0x02, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0,
  0x00, 0x08, 0x00, 0x80, 0x63, 0xF0, 0x3F, 0x02, 0x60, 0xC6, 0x0C, 0x16,
  0x02, 0x60, 0x30, 0xA0, 0x1A, 0x01, 0x8E, 0x00, 0xE0, 0x04, 0x60, 0x07,
  0x00, 0x63, 0x00, 0x30, 0x03, 0x10, 0x01, 0x80, 0x18, 0x80, 0x08, 0x00,
  0x8C, 0x00, 0x40, 0x04, 0x60, 0x06, 0x00, 0x22, 0x00, 0x30, 0x03, 0x10,
  0x01, 0x00, 0x18, 0x80, 0x08, 0x00, 0x8C, 0x00, 0xC0, 0x04, 0x60, 0x06,
  0x00, 0x62, 0x00, 0x30, 0x03, 0x10, 0x01, 0x00, 0x19, 0x80, 0x08, 0x00,
  0x8C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x1F, 0xC0, 0x8C, 0x18,
  0x24, 0x03, 0x0A, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18,
  0x00, 0xC4, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x88, 0x00,
  0x62, 0x00, 0x11, 0x80, 0x04, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x23,
  0x00, 0x08, 0xC0, 0x06, 0x00, 0x03, 0xFC, 0x03, 0x03, 0x03, 0x00, 0xC3,
  0x00, 0x33, 0x00, 0x09, 0x00, 0x05, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0B, 0x00,
  0x0D, 0x80, 0x04, 0x40, 0x06, 0x30, 0x06, 0x0E, 0x0E, 0x03, 0xFC, 0x00,
  0x03, 0x1F, 0xC0, 0x11, 0x83, 0x00, 0x90, 0x0C, 0x05, 0x00, 0x20, 0x70,
  0x01, 0x03, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x18,
  0x60, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00,
  0x10, 0x60, 0x01, 0x83, 0x00, 0x08, 0x14, 0x00, 0xC0, 0xB0, 0x0C, 0x0C,
  0xC1, 0xC0, 0x63, 0xF8, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x10, 0x60, 0x64,
  0x30, 0x0B, 0x18, 0x01, 0xCC, 0x00, 0x62, 0x00, 0x19, 0x80, 0x06, 0x40,
  0x01, 0x90, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00,
  0xC8, 0x00, 0x62, 0x00, 0x18, 0xC0, 0x0A, 0x30, 0x07, 0x84, 0x03, 0x61,
  0xC3, 0x90, 0x3F, 0x84, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x0C, 0x7C, 0x23, 0x00, 0x90, 0x02, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x0F, 0xFC, 0x30, 0x08, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x32, 0x00, 0x67,
  0x03, 0x83, 0xFC, 0x00, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x81, 0xFF,
  0xC4, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x08, 0xC0, 0x02,
  0x30, 0x01, 0x88, 0x00, 0x62, 0x00, 0x10, 0x80, 0x04, 0x60, 0x01, 0x18,
  0x00, 0xC4, 0x00, 0x31, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0xE3, 0x00, 0x38, 0xC0, 0x14, 0x30, 0x09, 0x06, 0x0C, 0x40, 0xFE, 0x30,
  0x80, 0x03, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x40, 0x08, 0x40, 0x18,
  0x40, 0x30, 0x40, 0x30, 0x60, 0x60, 0x60, 0x40, 0x60, 0xC0, 0x20, 0x80,
  0x21, 0x80, 0x23, 0x00, 0x23, 0x00, 0x36, 0x00, 0x34, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x03, 0xC0, 0x38,
  0x02, 0xC0, 0x28, 0x06, 0xC0, 0x68, 0x04, 0xC0, 0x48, 0x0C, 0xC0, 0xCC,
  0x08, 0x40, 0x8C, 0x18, 0x41, 0x8C, 0x10, 0x41, 0x0C, 0x30, 0x43, 0x04,
  0x20, 0x42, 0x04, 0x60, 0x46, 0x04, 0x60, 0x44, 0x04, 0x40, 0x4C, 0x04,
  0xC0, 0x48, 0x04, 0x80, 0x58, 0x05, 0x80, 0x50, 0x05, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x06, 0x01,
  0x01, 0x80, 0x30, 0x60, 0x02, 0x18, 0x00, 0x62, 0x00, 0x04, 0x80, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x33, 0x00, 0x0C,
  0x20, 0x03, 0x06, 0x00, 0x40, 0x40, 0x10, 0x0C, 0x06, 0x00, 0x81, 0x80,
  0x18, 0x60, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x00, 0xC0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x10, 0x04, 0x00,
  0x60, 0x30, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20,
  0x80, 0x00, 0x86, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x32, 0x00,
  0x00, 0x58, 0x00, 0x01, 0x40, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x23, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3C, 0x03,
  0x80, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0xE0, 0xE0, 0xE0, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraLightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 27, 8, 1, -27 },
  { 28, 9, 10, 12, 4, -27 },
  { 40, 23, 27, 24, 1, -27 },
  { 118, 18, 31, 21, 2, -29 },
  { 188, 24, 28, 29, 3, -28 },
  { 272, 22, 28, 26, 2, -28 },
  { 349, 4, 10, 7, 4, -27 },
  { 354, 11, 33, 10, 1, -27 },
  { 400, 11, 33, 10, -3, -27 },
  { 446, 16, 16, 20, 5, -29 },
  { 478, 17, 17, 22, 3, -22 },
  { 515, 6, 9, 8, -2, -4 },
  { 522, 9, 1, 12, 1, -11 },
  { 524, 3, 3, 8, 1, -3 },
  { 526, 17, 27, 12, -2, -27 },
  { 584, 18, 28, 21, 2, -28 },
  { 647, 10, 27, 21, 6, -27 },
  { 681, 19, 28, 21, 0, -28 },
  { 748, 19, 28, 21, 1, -28 },
  { 815, 20, 27, 21, 0, -27 },
  { 883, 19, 27, 21, 1, -27 },
  { 948, 18, 28, 21, 3, -28 },
  { 1011, 17, 27, 21, 4, -27 },
  { 1069, 18, 28, 21, 2, -28 },
  { 1132, 18, 28, 21, 2, -28 },
  { 1195, 6, 20, 8, 1, -20 },
  { 1210, 9, 25, 8, -2, -20 },
  { 1239, 17, 17, 22, 3, -22 },
  { 1276, 17, 9, 22, 3, -18 },
  { 1296, 17, 17, 22, 3, -22 },
  { 1333, 13, 28, 16, 3, -28 },
  { 1379, 29, 30, 32, 2, -27 },
  { 1488, 21, 27, 21, -2, -27 },
  { 1559, 20, 27, 23, 2, -27 },
  { 1627, 21, 28, 23, 3, -28 },
  { 1701, 22, 27, 26, 2, -27 },
  { 1776, 19, 27, 20, 2, -27 },
  { 1841, 19, 27, 18, 2, -27 },
  { 1906, 22, 28, 26, 3, -28 },
  { 1983, 24, 27, 26, 2, -27 },
  { 2064, 13, 27, 11, 0, -27 },
  { 2108, 15, 34, 9, -6, -27 },
  { 2172, 22, 27, 21, 2, -27 },
  { 2247, 14, 27, 19, 2, -27 },
  { 2295, 29, 27, 31, 2, -27 },
  { 2393, 24, 27, 26, 2, -27 },
  { 2474, 23, 28, 27, 3, -28 },
  { 2555, 19, 27, 21, 2, -27 },
  { 2620, 23, 34, 27, 3, -28 },
  { 2718, 19, 27, 21, 2, -27 },
  { 2783, 18, 28, 19, 1, -28 },
  { 2846, 19, 27, 19, 3, -27 },
  { 2911, 23, 27, 26, 3, -27 },
  { 2989, 19, 27, 20, 4, -27 },
  { 3054, 29, 27, 32, 5, -27 },
  { 3152, 24, 27, 19, -2, -27 },
  { 3233, 18, 27, 19, 4, -27 },
  { 3294, 22, 27, 20, 0, -27 },
  { 3369, 14, 33, 11, 0, -27 },
  { 3427, 6, 27, 12, 4, -27 },
  { 3448, 15, 33, 11, -3, -27 },
  { 3510, 17, 17, 21, 2, -27 },
  { 3547, 14, 1, 14, -3, 4 },
  { 3549, 4, 6, 9, 6, -29 },
  { 3552, 18, 21, 21, 2, -21 },
  { 3600, 19, 29, 22, 1, -29 },
  { 3669, 15, 21, 17, 2, -21 },
  { 3709, 20, 29, 22, 2, -29 },
  { 3782, 15, 21, 19, 2, -21 },
  { 3822, 21, 38, 10, -5, -29 },
  { 3922, 19, 30, 22, 1, -21 },
  { 3994, 18, 29, 21, 1, -29 },
  { 4060, 8, 28, 8, 1, -28 },
  { 4088, 14, 37, 8, -5, -28 },
  { 4153, 18, 29, 17, 1, -29 },
  { 4219, 8, 29, 8, 1, -29 },
  { 4248, 29, 21, 32, 1, -21 },
  { 4325, 18, 21, 21, 1, -21 },
  { 4373, 17, 20, 21, 2, -20 },
  { 4416, 21, 29, 22, -1, -20 },
  { 4493, 18, 30, 22, 2, -21 },
  { 4561, 14, 20, 14, 1, -20 },
  { 4596, 15, 21, 16, 0, -21 },
  { 4636, 11, 25, 12, 2, -25 },
  { 4671, 18, 20, 21, 2, -20 },
  { 4716, 16, 20, 16, 2, -20 },
  { 4756, 24, 20, 25, 2, -20 },
  { 4816, 19, 20, 18, -1, -20 },
  { 4864, 22, 29, 16, -4, -20 },
  { 4944, 18, 20, 17, -1, -20 },
  { 4989, 14, 33, 13, 1, -27 },
  { 5047, 1, 38, 20, 11, -29 },
  { 5052, 14, 33, 13, -2, -27 },
  { 5110, 17, 3, 22, 3, -15 },
};

const GFXfont NotoSans_ExtraLightItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRALIGHTITALIC38PT7B_H_
