#ifndef _NOTOSANS_EXTRALIGHTITALIC37PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x40, 0xE0, 0xC0, 0x21, 0xB0, 0x98, 0x48, 0x64, 0x32, 0x11, 0x09, 0x04,
  0x86, 0x00, 0x00, 0x30, 0x30, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x18,
  0x18, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20,
  0x1F, 0xFF, 0xFC, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x01,
  0x01, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x02,
  0x03, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x01, 0x01, 0x00, 0x0C, 0x0C, 0x00,
  0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x18, 0x10, 0x00, 0x40,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x3B,
  0x78, 0x61, 0x04, 0x20, 0x80, 0x30, 0x40, 0x10, 0x60, 0x08, 0x30, 0x04,
  0x10, 0x03, 0x08, 0x00, 0xC4, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x9C, 0x00, 0x42, 0x00, 0x61, 0x80, 0x20, 0xC0, 0x10, 0x60, 0x08,
  0x30, 0x04, 0x30, 0x06, 0x30, 0xE2, 0x70, 0x3F, 0xE0, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x07, 0x80, 0x00, 0x0D, 0xC0, 0x0C,
  0x10, 0x40, 0x18, 0x30, 0x60, 0x10, 0x20, 0x60, 0x20, 0x60, 0x60, 0x60,
  0x40, 0x60, 0x40, 0x40, 0x60, 0x80, 0xC0, 0x41, 0x80, 0xC0, 0x43, 0x00,
  0xC0, 0x42, 0x00, 0x80, 0xC4, 0x7C, 0xC0, 0x8C, 0xC6, 0xC1, 0x99, 0x82,
  0x43, 0x11, 0x02, 0x7E, 0x23, 0x03, 0x3C, 0x62, 0x03, 0x00, 0xC2, 0x02,
  0x00, 0x86, 0x02, 0x01, 0x06, 0x02, 0x03, 0x04, 0x02, 0x06, 0x04, 0x06,
  0x04, 0x04, 0x04, 0x08, 0x04, 0x0C, 0x18, 0x06, 0x08, 0x10, 0x06, 0x18,
  0x60, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xBC, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x60, 0x02, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x60, 0x02, 0x03, 0x00, 0x08, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x6C, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xC6, 0x00, 0x0C, 0x0C, 0x03, 0x60,
  0x10, 0x19, 0x00, 0x60, 0x4C, 0x00, 0xC3, 0x20, 0x01, 0x18, 0x80, 0x06,
  0x42, 0x00, 0x0E, 0x08, 0x00, 0x18, 0x30, 0x01, 0xA0, 0xC0, 0x0C, 0xC1,
  0xC0, 0xE1, 0x83, 0xFE, 0x03, 0x00, 0x2D, 0xA4, 0x94, 0x80, 0x00, 0xE0,
  0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x03, 0x00, 0x60, 0x08, 0x02, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x03, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x0C, 0x10, 0x0C, 0x20, 0x06, 0x40, 0x03,
  0xFF, 0x03, 0x00, 0x0A, 0x00, 0x66, 0x01, 0x84, 0x06, 0x0C, 0x18, 0x08,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x0C, 0x21, 0x84, 0x30, 0x86,
  0x10, 0xC0, 0x7F, 0xFF, 0xC0, 0x5F, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x30, 0x30, 0x18, 0x06,
  0x0C, 0x00, 0x86, 0x00, 0x21, 0x80, 0x08, 0x40, 0x03, 0x30, 0x00, 0xC8,
  0x00, 0x32, 0x00, 0x09, 0x80, 0x02, 0x60, 0x00, 0x90, 0x00, 0x24, 0x00,
  0x19, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x02, 0x10, 0x01, 0x84, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x18, 0x0C,
  0x1C, 0x01, 0xFC, 0x00, 0x01, 0x83, 0x43, 0x66, 0x36, 0x14, 0x08, 0x0C,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0xF0, 0x0E, 0x03, 0x01, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x70, 0x18, 0x30, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x80, 0x0C, 0x38,
  0x0E, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x01, 0x88,
  0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x03, 0x01,
  0x00, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x30, 0x18, 0x03, 0x03, 0x00,
  0x20, 0x60, 0x02, 0x17, 0xFF, 0xFE, 0x80, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xE0, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x2F, 0xC0, 0x0F, 0x9E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x84, 0x00, 0x60, 0xE0, 0x38, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x70, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x8F, 0xE0, 0x26, 0x0E, 0x1E, 0x00, 0x85, 0x00, 0x31,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x04, 0x40,
  0x03, 0x10, 0x00, 0x84, 0x00, 0x61, 0x80, 0x10, 0x20, 0x0C, 0x0E, 0x0C,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xC0, 0x70, 0x18, 0x10, 0x02, 0x0C, 0x00, 0xC2, 0x00,
  0x30, 0x80, 0x0C, 0x20, 0x02, 0x08, 0x01, 0x83, 0x00, 0x40, 0x60, 0x60,
  0x0C, 0x30, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xE3, 0x80, 0x60, 0x30, 0x60,
  0x06, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00,
  0x88, 0x00, 0x23, 0x00, 0x18, 0x60, 0x0C, 0x0C, 0x0E, 0x01, 0xFE, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0x80, 0xC1, 0x80, 0x21, 0x80, 0x18, 0x80,
  0x04, 0xC0, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x32, 0x00, 0x39, 0x80, 0x1C, 0x60, 0x34, 0x1C, 0xF2, 0x07, 0xE3,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x40, 0xE0, 0x3F, 0xC0, 0x00, 0x0C, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0E,
  0x30, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x01, 0x80, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0x83, 0xFF, 0x08, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x21, 0x00, 0x3E,
  0x03, 0x30, 0x0E, 0x78, 0x32, 0x03, 0x01, 0x01, 0x60, 0x60, 0x10, 0x14,
  0x04, 0x03, 0x01, 0x40, 0xC0, 0x30, 0x1C, 0x08, 0x02, 0x03, 0xC1, 0x80,
  0x20, 0x38, 0x18, 0x06, 0x02, 0x81, 0x00, 0x60, 0x68, 0x10, 0x0C, 0x06,
  0x81, 0x80, 0xC0, 0xCC, 0x18, 0x16, 0x18, 0xC0, 0xC6, 0x23, 0x04, 0x07,
  0xC3, 0xE0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00,
  0x0D, 0x00, 0x00, 0xC8, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x02, 0x18,
  0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x18, 0x10, 0x01, 0x80, 0x80, 0x08,
  0x06, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x7F, 0xFC, 0x02, 0x00, 0x20,
  0x30, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00,
  0x18, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x16, 0x00, 0x00, 0xC0,
  0x07, 0xFF, 0x80, 0x40, 0x0C, 0x04, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80,
  0x0C, 0x18, 0x01, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0x00, 0x30, 0x30,
  0x01, 0x82, 0x00, 0x08, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x18, 0x40, 0x03, 0x0C, 0x00, 0x60,
  0xC0, 0x3C, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x01, 0xC0,
  0x10, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x10, 0x07, 0x00, 0x40, 0x06, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0x10, 0x30, 0x00, 0x60, 0x80, 0x00, 0x82, 0x00, 0x02, 0x18,
  0x00, 0x08, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x10, 0x00,
  0x08, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x00,
  0x06, 0x04, 0x00, 0x30, 0x30, 0x03, 0x80, 0xC0, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFC,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x1C,
  0x01, 0x80, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x61, 0x00, 0x01, 0x06, 0x00, 0x04, 0x08, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x70, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x06, 0x00, 0x06, 0x08,
  0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x80,
  0x01, 0x82, 0x00, 0x03, 0x04, 0x00, 0x04, 0x18, 0x00, 0x08, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x06, 0x00, 0x02,
  0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x41,
  0x80, 0x00, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10,
  0x00, 0x10, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x80, 0x07,
  0xF0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x0F, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x7F, 0x00, 0x20, 0x00, 0x06, 0x00, 0x38, 0x20, 0x03, 0x01, 0x00, 0x30,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x20, 0x30, 0x01, 0x03,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x27, 0x00, 0x01,
  0x6C, 0x00, 0x1E, 0x20, 0x00, 0xC1, 0x80, 0x04, 0x04, 0x00, 0x20, 0x30,
  0x01, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x20,
  0x06, 0x01, 0x00, 0x10, 0x18, 0x00, 0xC0, 0xC0, 0x02, 0x04, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x05, 0x00, 0x00, 0xA0, 0x50, 0x00, 0x1A, 0x0D, 0x00,
  0x01, 0x60, 0xD0, 0x00, 0x36, 0x09, 0x80, 0x02, 0x60, 0x98, 0x00, 0x64,
  0x18, 0x80, 0x0C, 0x41, 0x88, 0x00, 0x8C, 0x10, 0x80, 0x18, 0xC1, 0x08,
  0x01, 0x08, 0x10, 0xC0, 0x30, 0x83, 0x0C, 0x06, 0x08, 0x30, 0x40, 0x41,
  0x82, 0x04, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0x10, 0x60,
  0x61, 0x01, 0x06, 0x06, 0x20, 0x30, 0x40, 0x26, 0x03, 0x04, 0x02, 0x40,
  0x20, 0x40, 0x2C, 0x02, 0x0C, 0x02, 0x80, 0x60, 0xC0, 0x38, 0x06, 0x08,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x10,
  0x28, 0x00, 0x20, 0xD8, 0x00, 0x41, 0x90, 0x01, 0x82, 0x30, 0x03, 0x04,
  0x60, 0x04, 0x18, 0x40, 0x08, 0x30, 0xC0, 0x10, 0x60, 0x80, 0x60, 0x81,
  0x80, 0xC1, 0x01, 0x01, 0x06, 0x02, 0x02, 0x0C, 0x06, 0x0C, 0x10, 0x04,
  0x18, 0x20, 0x0C, 0x30, 0x40, 0x08, 0x41, 0x80, 0x18, 0x83, 0x00, 0x33,
  0x04, 0x00, 0x26, 0x08, 0x00, 0x68, 0x10, 0x00, 0x50, 0x60, 0x00, 0xE0,
  0xC0, 0x00, 0xC1, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00,
  0x30, 0x06, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x20, 0x00, 0x0D, 0x80, 0x00, 0x14, 0x00, 0x00,
  0x50, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00,
  0x04, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x86, 0x00, 0x06, 0x08, 0x00, 0x30,
  0x30, 0x01, 0x80, 0x70, 0x1C, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x80, 0x70, 0x10, 0x03, 0x02, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0xC2,
  0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x08,
  0x00, 0xC1, 0x00, 0x30, 0x60, 0x7C, 0x0F, 0xFC, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x00, 0x30, 0x06, 0x01, 0x80, 0x0C, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x21, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x20, 0x00, 0x0D,
  0x80, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x86,
  0x00, 0x06, 0x08, 0x00, 0x30, 0x30, 0x01, 0x80, 0x70, 0x1C, 0x00, 0x7F,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x00, 0x80, 0x70, 0x10,
  0x03, 0x02, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x18, 0x40,
  0x03, 0x18, 0x00, 0x43, 0x00, 0x18, 0x60, 0x02, 0x08, 0x00, 0xC1, 0x00,
  0x70, 0x7F, 0xF8, 0x0C, 0x0C, 0x01, 0x80, 0x80, 0x20, 0x10, 0x04, 0x03,
  0x01, 0x80, 0x20, 0x30, 0x04, 0x04, 0x00, 0xC0, 0x80, 0x08, 0x10, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x02, 0x10, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x7F,
  0xF0, 0x70, 0x0C, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x30, 0x1E, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x10,
  0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC2, 0x00,
  0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00,
  0x30, 0x80, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x30, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x10, 0x80,
  0x06, 0x10, 0x01, 0x82, 0x00, 0x30, 0x40, 0x0C, 0x08, 0x01, 0x01, 0x80,
  0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x40, 0x40, 0x08, 0x18, 0x01, 0x02,
  0x00, 0x20, 0xC0, 0x04, 0x10, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x03, 0x20,
  0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x1A, 0x00, 0x38, 0x00, 0xD0, 0x01, 0x40, 0x0C,
  0x80, 0x1A, 0x00, 0x64, 0x00, 0x90, 0x02, 0x20, 0x0C, 0x80, 0x31, 0x00,
  0x44, 0x01, 0x08, 0x06, 0x20, 0x18, 0x40, 0x21, 0x00, 0x82, 0x03, 0x08,
  0x0C, 0x10, 0x10, 0x40, 0x40, 0x80, 0x82, 0x06, 0x04, 0x0C, 0x18, 0x20,
  0x30, 0x40, 0xC1, 0x01, 0x86, 0x06, 0x18, 0x0C, 0x20, 0x30, 0x80, 0x63,
  0x01, 0x8C, 0x03, 0x10, 0x0C, 0x40, 0x19, 0x80, 0x26, 0x00, 0xC8, 0x01,
  0x20, 0x06, 0xC0, 0x0B, 0x00, 0x14, 0x00, 0x50, 0x00, 0xE0, 0x02, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x06, 0x02, 0x00, 0x18, 0x06, 0x00, 0x60, 0x04, 0x01, 0x80,
  0x0C, 0x02, 0x00, 0x08, 0x08, 0x00, 0x10, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x23, 0x00, 0x00, 0x64, 0x00, 0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x62, 0x00, 0x00, 0x86,
  0x00, 0x02, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x60, 0x18, 0x00, 0x40, 0x60, 0x00, 0xC1,
  0x80, 0x00, 0x80, 0x80, 0x01, 0xF0, 0x00, 0xCC, 0x00, 0x31, 0x00, 0x18,
  0x40, 0x0C, 0x18, 0x02, 0x02, 0x01, 0x80, 0x80, 0xC0, 0x30, 0x20, 0x0C,
  0x10, 0x01, 0x0C, 0x00, 0x46, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x82, 0x0C, 0x30, 0x41, 0x04,
  0x10, 0x61, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x04, 0x18, 0x20,
  0x82, 0x08, 0x30, 0x01, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x3F, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x08, 0x80, 0x0C, 0x40,
  0x04, 0x30, 0x04, 0x08, 0x06, 0x04, 0x02, 0x03, 0x02, 0x00, 0x83, 0x00,
  0x41, 0x00, 0x31, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x80,
  0xFF, 0xFC, 0xC3, 0x08, 0x21, 0x84, 0x01, 0xF0, 0x83, 0x8C, 0x43, 0x01,
  0x23, 0x00, 0xF3, 0x00, 0x31, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x06, 0x40,
  0x03, 0x60, 0x01, 0x30, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x22,
  0x00, 0x31, 0x80, 0x28, 0xC0, 0x34, 0x20, 0x36, 0x18, 0x32, 0x07, 0xE1,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x3E, 0x02, 0x39, 0xC0,
  0x90, 0x18, 0x28, 0x02, 0x1C, 0x00, 0xC7, 0x00, 0x11, 0x80, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00,
  0x88, 0x00, 0x66, 0x00, 0x11, 0x80, 0x0C, 0x50, 0x06, 0x14, 0x03, 0x0C,
  0xC1, 0x82, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0x1C, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xE0, 0x40, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x01, 0xF0, 0xC0, 0x71, 0xCC, 0x0C, 0x06, 0x81, 0x80, 0x28,
  0x30, 0x02, 0x82, 0x00, 0x18, 0x60, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00,
  0x60, 0x80, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x14, 0x04, 0x02, 0x40, 0x60,
  0xC4, 0x03, 0xF8, 0xC0, 0x01, 0xF8, 0x0F, 0x38, 0x30, 0x18, 0xC0, 0x31,
  0x00, 0x26, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x40, 0x39, 0xFF, 0xC3, 0xF0,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xE0, 0x40, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x01, 0xB8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x20, 0x71,
  0xCC, 0x18, 0x0D, 0x06, 0x00, 0xA1, 0x80, 0x14, 0x20, 0x01, 0x8C, 0x00,
  0x31, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00,
  0x84, 0x00, 0x10, 0x80, 0x06, 0x10, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x0A,
  0x04, 0x02, 0x40, 0xC1, 0x88, 0x0F, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x02, 0x00, 0xC0,
  0x7D, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x3E,
  0x04, 0x73, 0x82, 0x60, 0x61, 0x40, 0x11, 0xC0, 0x08, 0xE0, 0x04, 0x60,
  0x02, 0x30, 0x01, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x11, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x01,
  0x30, 0x01, 0x98, 0x00, 0xC0, 0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x0C, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C,
  0x18, 0x20, 0x41, 0x83, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x2E, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x01, 0x86,
  0x01, 0x82, 0x01, 0x81, 0x01, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x41, 0x80,
  0x21, 0x80, 0x11, 0x80, 0x19, 0x80, 0x09, 0x60, 0x05, 0x10, 0x03, 0x0C,
  0x01, 0x02, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x40, 0x30, 0x20, 0x08, 0x30,
  0x06, 0x18, 0x01, 0x80, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x0C, 0x7C, 0x07, 0xC0,
  0x8C, 0x61, 0xCE, 0x09, 0x03, 0x30, 0x30, 0xA0, 0x16, 0x01, 0x1C, 0x01,
  0x40, 0x11, 0xC0, 0x18, 0x01, 0x18, 0x01, 0x80, 0x11, 0x00, 0x10, 0x03,
  0x10, 0x03, 0x00, 0x33, 0x00, 0x30, 0x02, 0x30, 0x02, 0x00, 0x22, 0x00,
  0x20, 0x02, 0x20, 0x02, 0x00, 0x62, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00,
  0x46, 0x00, 0x40, 0x04, 0x40, 0x04, 0x00, 0x44, 0x00, 0xC0, 0x0C, 0xC0,
  0x0C, 0x00, 0xCC, 0x00, 0xC0, 0x08, 0x0C, 0x3E, 0x02, 0x39, 0xC0, 0x98,
  0x18, 0x28, 0x02, 0x1C, 0x00, 0xC7, 0x00, 0x21, 0x80, 0x08, 0x60, 0x02,
  0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0x80, 0x04, 0x20, 0x01, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00,
  0x63, 0x00, 0x18, 0x01, 0xF8, 0x03, 0xCF, 0x03, 0x00, 0x83, 0x00, 0x63,
  0x00, 0x11, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1B, 0x00, 0x09, 0x80,
  0x0C, 0x40, 0x04, 0x30, 0x0C, 0x0C, 0x0C, 0x03, 0xFC, 0x00, 0x03, 0x0F,
  0x80, 0x23, 0x9C, 0x02, 0x60, 0x60, 0x28, 0x02, 0x07, 0x00, 0x30, 0x70,
  0x01, 0x06, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x18, 0x00, 0x41,
  0x80, 0x0C, 0x14, 0x01, 0x81, 0x40, 0x30, 0x33, 0x06, 0x03, 0x1F, 0xC0,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x41, 0xC7, 0x30, 0xC0, 0x68, 0x60, 0x0A, 0x30, 0x02, 0x88, 0x00,
  0x66, 0x00, 0x19, 0x00, 0x04, 0x40, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x32,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0xE3, 0x00, 0x38, 0xC0,
  0x14, 0x10, 0x09, 0x06, 0x0C, 0x40, 0xFE, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x3C, 0x23, 0xB0, 0x90, 0x02, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x0E, 0x3C, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x23, 0x81, 0x83, 0xFE, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x3F,
  0xFF, 0xF1, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0xF8,
  0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x10, 0x00, 0x88,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31, 0x00, 0x38, 0xC0, 0x14,
  0x60, 0x16, 0x18, 0x33, 0x07, 0xF1, 0x00, 0x80, 0x03, 0x00, 0x0F, 0x00,
  0x16, 0x00, 0x6C, 0x01, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x60,
  0xC0, 0x81, 0x83, 0x03, 0x0C, 0x02, 0x18, 0x04, 0x60, 0x08, 0x80, 0x13,
  0x00, 0x34, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x03,
  0x80, 0x18, 0x02, 0xC0, 0x28, 0x06, 0xC0, 0x28, 0x04, 0xC0, 0x48, 0x0C,
  0xC0, 0x48, 0x08, 0xC0, 0xC8, 0x18, 0xC0, 0x88, 0x10, 0xC1, 0x08, 0x30,
  0x41, 0x08, 0x30, 0x42, 0x0C, 0x20, 0x42, 0x0C, 0x60, 0x44, 0x0C, 0x40,
  0x44, 0x0C, 0xC0, 0x48, 0x04, 0x80, 0x48, 0x05, 0x80, 0x50, 0x05, 0x00,
  0x50, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60,
  0x80, 0x18, 0x18, 0x06, 0x01, 0x01, 0x80, 0x30, 0x60, 0x02, 0x18, 0x00,
  0x42, 0x00, 0x0C, 0x80, 0x00, 0xB0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x32, 0x00, 0x0C, 0x60, 0x01, 0x04, 0x00, 0x40, 0xC0, 0x10,
  0x08, 0x06, 0x01, 0x81, 0x80, 0x10, 0x60, 0x03, 0x00, 0x02, 0x00, 0x08,
  0x10, 0x00, 0xC0, 0xC0, 0x04, 0x06, 0x00, 0x60, 0x10, 0x02, 0x00, 0x80,
  0x30, 0x04, 0x03, 0x00, 0x20, 0x10, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00,
  0x60, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x30,
  0x00, 0x1B, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x01, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xF0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x78, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x07, 0x80, 0x38, 0x00, 0x3E, 0x00, 0xF3, 0xC0, 0x60,
  0x3F, 0xC0, 0x03, 0x80,
};

const GFXglyph NotoSans_ExtraLightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 26, 8, 1, -26 },
  { 27, 9, 9, 12, 4, -26 },
  { 38, 22, 26, 23, 1, -26 },
  { 110, 17, 30, 20, 2, -28 },
  { 174, 24, 27, 28, 3, -27 },
  { 255, 22, 27, 25, 2, -27 },
  { 330, 3, 9, 7, 4, -26 },
  { 334, 11, 32, 9, 1, -26 },
  { 378, 10, 32, 9, -2, -26 },
  { 418, 15, 16, 20, 5, -28 },
  { 448, 17, 18, 21, 3, -22 },
  { 487, 6, 9, 7, -2, -4 },
  { 494, 9, 2, 12, 1, -11 },
  { 497, 3, 3, 8, 1, -3 },
  { 499, 17, 26, 12, -2, -26 },
  { 555, 18, 27, 20, 2, -27 },
  { 616, 9, 26, 20, 6, -26 },
  { 646, 19, 27, 20, 0, -27 },
  { 711, 18, 27, 20, 1, -27 },
  { 772, 20, 27, 20, 0, -27 },
  { 840, 19, 26, 20, 1, -26 },
  { 902, 18, 27, 20, 2, -27 },
  { 963, 17, 26, 20, 4, -26 },
  { 1019, 18, 27, 20, 2, -27 },
  { 1080, 17, 27, 20, 2, -27 },
  { 1138, 6, 20, 8, 1, -20 },
  { 1153, 9, 25, 8, -2, -20 },
  { 1182, 17, 17, 21, 3, -22 },
  { 1219, 17, 8, 21, 3, -17 },
  { 1236, 17, 17, 21, 3, -22 },
  { 1273, 13, 27, 15, 3, -27 },
  { 1317, 28, 29, 31, 2, -26 },
  { 1419, 21, 26, 20, -2, -26 },
  { 1488, 20, 26, 22, 2, -26 },
  { 1553, 20, 27, 22, 3, -27 },
  { 1621, 22, 26, 25, 2, -26 },
  { 1693, 19, 26, 20, 2, -26 },
  { 1755, 19, 26, 18, 2, -26 },
  { 1817, 22, 27, 25, 3, -27 },
  { 1892, 23, 26, 25, 2, -26 },
  { 1967, 12, 26, 11, 0, -26 },
  { 2006, 15, 33, 9, -6, -26 },
  { 2068, 21, 26, 20, 2, -26 },
  { 2137, 13, 26, 18, 2, -26 },
  { 2180, 28, 26, 30, 2, -26 },
  { 2271, 23, 26, 25, 2, -26 },
  { 2346, 22, 27, 27, 3, -27 },
  { 2421, 19, 26, 21, 2, -26 },
  { 2483, 22, 33, 27, 3, -27 },
  { 2574, 19, 26, 21, 2, -26 },
  { 2636, 18, 27, 18, 1, -27 },
  { 2697, 18, 26, 18, 3, -26 },
  { 2756, 23, 26, 26, 3, -26 },
  { 2831, 19, 26, 20, 4, -26 },
  { 2893, 29, 26, 31, 4, -26 },
  { 2988, 23, 26, 18, -2, -26 },
  { 3063, 18, 26, 18, 4, -26 },
  { 3122, 21, 26, 20, 0, -26 },
  { 3191, 14, 32, 11, 0, -26 },
  { 3247, 6, 26, 12, 4, -26 },
  { 3267, 14, 32, 11, -3, -26 },
  { 3323, 17, 17, 21, 2, -27 },
  { 3360, 14, 1, 14, -3, 4 },
  { 3362, 5, 6, 9, 5, -28 },
  { 3366, 17, 20, 20, 2, -20 },
  { 3409, 18, 28, 21, 1, -28 },
  { 3472, 15, 20, 17, 2, -20 },
  { 3510, 20, 28, 21, 2, -28 },
  { 3580, 15, 20, 18, 2, -20 },
  { 3618, 21, 37, 10, -5, -28 },
  { 3716, 19, 29, 21, 1, -20 },
  { 3785, 17, 28, 21, 1, -28 },
  { 3845, 7, 27, 8, 1, -27 },
  { 3869, 13, 36, 8, -5, -27 },
  { 3928, 17, 28, 17, 1, -28 },
  { 3988, 8, 28, 8, 1, -28 },
  { 4016, 28, 20, 31, 1, -20 },
  { 4086, 18, 20, 21, 1, -20 },
  { 4131, 17, 20, 21, 2, -20 },
  { 4174, 20, 29, 21, -1, -20 },
  { 4247, 18, 29, 21, 2, -20 },
  { 4313, 14, 20, 14, 1, -20 },
  { 4348, 15, 20, 16, 0, -20 },
  { 4386, 10, 24, 12, 2, -24 },
  { 4416, 17, 20, 21, 2, -20 },
  { 4459, 15, 20, 16, 2, -20 },
  { 4497, 24, 20, 25, 2, -20 },
  { 4557, 19, 20, 17, -1, -20 },
  { 4605, 21, 29, 16, -4, -20 },
  { 4682, 17, 20, 16, -1, -20 },
  { 4725, 13, 32, 12, 1, -26 },
  { 4777, 2, 37, 20, 10, -28 },
  { 4787, 14, 32, 12, -2, -26 },
  { 4843, 17, 4, 21, 3, -15 },
};

const GFXfont NotoSans_ExtraLightItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRALIGHTITALIC37PT7B_H_
