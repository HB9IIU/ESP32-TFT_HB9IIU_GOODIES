#ifndef _LIBERATIONMONO_BOLDITALIC70PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x3C, 0xFF, 0xF0, 0x0F, 0xFC, 0x1E, 0x3F, 0xF8, 0x07, 0xFC,
  0x0F, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0x81,
  0xFF, 0x01, 0xFF, 0x03, 0xC0, 0xFC, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x70, 0x00, 0x00, 0x1F, 0xFC,
  0x38, 0x00, 0x00, 0x0F, 0xFF, 0xBC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3D, 0xFF, 0xF8, 0x00,
  0x00, 0x1E, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0x81, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x7F, 0xC0, 0x0C, 0x03, 0xC0, 0x3F,
  0xE0, 0xFE, 0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x78, 0x0F, 0xF8, 0x3F, 0xE0, 0x38, 0x0F, 0xFC, 0x1F, 0xF8, 0x3C,
  0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F, 0xFE, 0x07, 0xFF, 0xCF, 0x1F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x00,
  0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x87, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC3, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xE1, 0xFF, 0x80,
  0x00, 0x07, 0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x1F, 0xE0,
  0x3F, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xC0,
  0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x7F, 0x80,
  0x3F, 0xEF, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0xFF,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xC1, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF3, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xF8, 0x1F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x03, 0xF0, 0x10, 0xF8, 0x7E,
  0x1F, 0x1F, 0xCF, 0xCF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0x0F, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3,
  0xFF, 0x3F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x03, 0xFF, 0x3F, 0xE1, 0xFC, 0x3F, 0xE7, 0xFE, 0x1F, 0xC3, 0xFE,
  0x7F, 0xE1, 0xFC, 0x7F, 0xE7, 0xFE, 0x3F, 0xC7, 0xFE, 0x7F, 0xC3, 0xFC,
  0x7F, 0xE7, 0xFC, 0x3F, 0x87, 0xFE, 0xFF, 0xC3, 0xF8, 0x7F, 0xCF, 0xFC,
  0x3F, 0x8F, 0xFC, 0xFF, 0xC3, 0xF8, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xE7, 0xFC, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xC0,
  0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0x3F, 0xFF,
  0xC0, 0x3F, 0xE7, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x0F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0xE0,
  0x03, 0xFF, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x80, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x01, 0xFE, 0x3E, 0xF8, 0x07, 0x80, 0xFF, 0xE7, 0xDF, 0x01, 0xF0,
  0x3F, 0xFD, 0xF3, 0xE0, 0x3C, 0x0F, 0xC3, 0xBE, 0x7C, 0x0F, 0x83, 0xF0,
  0x77, 0x8F, 0x81, 0xE0, 0xFC, 0x07, 0xF1, 0xF0, 0x7C, 0x1F, 0x00, 0xFE,
  0x3E, 0x0F, 0x07, 0xC0, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x03, 0xF0, 0xF8,
  0x7C, 0x3E, 0x00, 0xFE, 0x1E, 0x0F, 0x0F, 0xC0, 0x1F, 0x83, 0xC3, 0xE1,
  0xF0, 0x03, 0xF0, 0x78, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x0F, 0x0F, 0x80,
  0x1F, 0x83, 0xE3, 0xE1, 0xF0, 0x03, 0xF0, 0x78, 0x7C, 0x7E, 0x00, 0x7C,
  0x0F, 0x0F, 0x8F, 0x80, 0x0F, 0x83, 0xE1, 0xE1, 0xF0, 0x03, 0xE0, 0x7C,
  0x3C, 0x3E, 0x00, 0x7C, 0x0F, 0x0F, 0x8F, 0xC0, 0x1F, 0x81, 0xE1, 0xF1,
  0xF0, 0x03, 0xE0, 0x7C, 0x3E, 0x3E, 0x00, 0x7C, 0x0F, 0x07, 0x87, 0xC0,
  0x1F, 0x83, 0xE0, 0xF0, 0xF8, 0x03, 0xE0, 0x78, 0x1E, 0x1F, 0x00, 0xFC,
  0x0F, 0x07, 0xC3, 0xE0, 0x1F, 0x83, 0xC0, 0xF8, 0x7C, 0x07, 0xE0, 0x78,
  0x1F, 0x0F, 0x81, 0xDC, 0x1E, 0x03, 0xE1, 0xF0, 0x7F, 0x87, 0xC0, 0x7C,
  0x3F, 0x1E, 0xF1, 0xF0, 0x0F, 0x87, 0xFF, 0x9F, 0xFC, 0x01, 0xF0, 0x7F,
  0xE3, 0xFF, 0x00, 0x1E, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x02, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0xFF,
  0x87, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x9F,
  0xF8, 0x0F, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xF3, 0xFF, 0x80, 0xFF,
  0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xFC, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x03,
  0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x9F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xDF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xDF, 0x80, 0xFD, 0xFC, 0x01, 0xFD, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0xDF,
  0x81, 0xFF, 0xFC, 0x03, 0xFD, 0xFC, 0x1F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC3,
  0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x3F, 0x3F, 0x80, 0x3F, 0x9F, 0xC7, 0xF7,
  0xF8, 0x03, 0xF9, 0xFC, 0x7F, 0x7F, 0x80, 0x7F, 0x9F, 0xCF, 0xE7, 0xF8,
  0x07, 0xF9, 0xFC, 0xFE, 0x7F, 0x00, 0x7F, 0x9F, 0xCF, 0xC7, 0xF0, 0x07,
  0xF1, 0xFD, 0xFC, 0xFF, 0x00, 0x7F, 0x1F, 0xDF, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFD, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFF,
  0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0xE1,
  0xFE, 0x01, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0xC1, 0xFC,
  0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0xFC, 0x01,
  0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0xFC, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x80,
  0x3F, 0xDF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF8, 0x03, 0xFD,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xCF, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x7F, 0x80, 0x3F,
  0xE1, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x1F,
  0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x3F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xCF, 0xF0, 0x07, 0xFC, 0x0F, 0xF3, 0xFC, 0x01,
  0xFF, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x7F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F,
  0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFF, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFC,
  0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFF, 0x87, 0xFC,
  0x07, 0xF8, 0x7F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xFE, 0x1F, 0xE0, 0x3F,
  0xE3, 0xFF, 0xC7, 0xF8, 0x07, 0xFC, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0x9F,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE7, 0xF7, 0xE7, 0xF8, 0x03, 0xFC, 0xFE, 0xFE,
  0xFF, 0x00, 0x7F, 0x9F, 0x9F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF3, 0xFB, 0xF8,
  0x01, 0xFE, 0xFC, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x81, 0xFF,
  0xE1, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xE3,
  0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF7, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0x80, 0x7F, 0xC7,
  0xFF, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0x83, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x00,
  0x1F, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0x9F, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xF3, 0xFE,
  0x00, 0x3F, 0xFF, 0xE7, 0xFE, 0x00, 0x1F, 0xFF, 0xC7, 0xFE, 0x00, 0x0F,
  0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x04, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x03,
  0xFF, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xFF,
  0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xF8,
  0x07, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x7F, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xCF, 0xFE,
  0x3F, 0xFC, 0x07, 0xF7, 0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0xC0, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0xE3, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xC7, 0xFF,
  0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF7, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xF8, 0x00,
  0x7F, 0xE7, 0xFF, 0xFC, 0x00, 0x7F, 0xCF, 0xFF, 0xFC, 0x00, 0x7F, 0xDF,
  0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0x80,
  0x3F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xF9, 0xFF, 0x80,
  0x1F, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xE1, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFE,
  0x07, 0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0x40, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xF8, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F,
  0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF,
  0x80, 0x7F, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0x03, 0xFC,
  0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x81, 0xFC,
  0x1F, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xFF, 0x07, 0xF0, 0x1F, 0xC3, 0xFF,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0xF0, 0xFE, 0x03, 0xFC, 0x7E, 0xFC, 0x3F,
  0x80, 0xFF, 0x1F, 0xBF, 0x1F, 0xE0, 0x3F, 0xCF, 0xC7, 0xE7, 0xF0, 0x0F,
  0xE3, 0xF1, 0xF9, 0xFC, 0x03, 0xF9, 0xF8, 0x7E, 0xFF, 0x00, 0xFE, 0x7E,
  0x1F, 0xBF, 0x80, 0x3F, 0xBF, 0x07, 0xEF, 0xE0, 0x0F, 0xEF, 0xC1, 0xFB,
  0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x23,
  0xFF, 0xFF, 0xF0, 0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x03, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
};

const GFXglyph LiberationMono_BoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 19, 46, 42, 12, -46 },
  { 111, 28, 22, 42, 12, -51 },
  { 188, 42, 46, 42, 1, -46 },
  { 430, 41, 58, 42, 1, -52 },
  { 728, 47, 48, 42, -2, -47 },
  { 1010, 41, 47, 42, -1, -46 },
  { 1251, 12, 22, 42, 20, -51 },
  { 1284, 28, 66, 42, 10, -51 },
  { 1515, 27, 66, 42, 4, -51 },
  { 1738, 27, 26, 42, 11, -51 },
  { 1826, 36, 36, 42, 3, -41 },
  { 1988, 21, 23, 42, 3, -10 },
  { 2049, 22, 8, 42, 10, -22 },
  { 2071, 12, 10, 42, 12, -10 },
  { 2086, 46, 52, 42, -1, -51 },
  { 2385, 36, 48, 42, 4, -47 },
  { 2601, 36, 46, 42, 1, -46 },
  { 2808, 39, 47, 42, 1, -47 },
  { 3038, 39, 48, 42, 2, -47 },
  { 3272, 39, 46, 42, 1, -46 },
  { 3497, 39, 47, 42, 2, -46 },
  { 3727, 36, 48, 42, 4, -47 },
  { 3943, 35, 46, 42, 8, -46 },
  { 4145, 38, 48, 42, 2, -47 },
  { 4373, 37, 48, 42, 3, -47 },
  { 4595, 18, 37, 42, 12, -37 },
  { 4679, 25, 50, 42, 5, -37 },
  { 4836, 36, 37, 42, 3, -42 },
  { 5003, 36, 27, 42, 3, -36 },
  { 5125, 36, 37, 42, 3, -42 },
  { 5292, 36, 47, 42, 5, -47 },
  { 5504, 43, 61, 42, 0, -51 },
  { 5832, 42, 46, 42, -4, -46 },
  { 6074, 40, 46, 42, 1, -46 },
  { 6304, 39, 48, 42, 3, -47 },
  { 6538, 40, 46, 42, 1, -46 },
  { 6768, 42, 46, 42, 1, -46 },
  { 7010, 41, 46, 42, 2, -46 },
  { 7246, 38, 48, 42, 3, -47 },
  { 7474, 42, 46, 42, 1, -46 },
  { 7716, 40, 46, 42, 2, -46 },
  { 7946, 37, 47, 42, 3, -46 },
  { 8164, 46, 46, 42, 1, -46 },
  { 8429, 32, 46, 42, 4, -46 },
  { 8613, 44, 46, 42, 0, -46 },
  { 8866, 42, 46, 42, 1, -46 },
  { 9108, 38, 48, 42, 3, -47 },
  { 9336, 41, 46, 42, 1, -46 },
  { 9572, 38, 61, 42, 3, -47 },
  { 9862, 42, 46, 42, 1, -46 },
  { 10104, 42, 48, 42, 0, -47 },
  { 10356, 39, 46, 42, 6, -46 },
  { 10581, 39, 47, 42, 4, -46 },
  { 10811, 42, 46, 42, 5, -46 },
  { 11053, 43, 46, 42, 4, -46 },
  { 11301, 50, 46, 42, -4, -46 },
  { 11589, 42, 46, 42, 5, -46 },
  { 11831, 44, 46, 42, -1, -46 },
  { 12084, 34, 66, 42, 6, -51 },
  { 12365, 26, 52, 42, 9, -51 },
  { 12534, 34, 66, 42, 2, -51 },
  { 12815, 38, 31, 42, 1, -48 },
  { 12963, 43, 3, 42, -5, 4 },
  { 12980, 16, 9, 42, 18, -49 },
  { 12998, 36, 39, 42, 2, -38 },
  { 13174, 38, 52, 42, 1, -51 },
  { 13421, 36, 39, 42, 3, -38 },
  { 13597, 40, 52, 42, 3, -51 },
  { 13857, 36, 39, 42, 3, -38 },
  { 14033, 39, 52, 42, 6, -52 },
  { 14287, 41, 53, 42, 1, -38 },
  { 14559, 38, 51, 42, 1, -51 },
  { 14802, 37, 51, 42, 0, -51 },
  { 15038, 38, 66, 42, -2, -51 },
  { 15352, 41, 51, 42, 2, -51 },
  { 15614, 37, 51, 42, 0, -51 },
  { 15850, 42, 38, 42, -1, -38 },
  { 16050, 38, 38, 42, 1, -38 },
  { 16231, 37, 39, 42, 3, -38 },
  { 16412, 40, 53, 42, -1, -38 },
  { 16677, 38, 53, 42, 3, -38 },
  { 16929, 36, 38, 42, 5, -38 },
  { 17100, 37, 39, 42, 2, -38 },
  { 17281, 29, 48, 42, 8, -47 },
  { 17455, 37, 38, 42, 3, -37 },
  { 17631, 39, 37, 42, 5, -37 },
  { 17812, 42, 37, 42, 3, -37 },
  { 18007, 45, 37, 42, -2, -37 },
  { 18216, 45, 52, 42, -1, -37 },
  { 18509, 38, 37, 42, 1, -37 },
  { 18685, 36, 66, 42, 6, -51 },
  { 18982, 8, 67, 42, 17, -51 },
  { 19049, 36, 66, 42, 0, -51 },
  { 19346, 38, 11, 42, 3, -29 },
};

const GFXfont LiberationMono_BoldItalic70pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic70pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic70pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _LIBERATIONMONO_BOLDITALIC70PT7B_H_
