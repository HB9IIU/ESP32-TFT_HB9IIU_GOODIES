#ifndef _LIBERATIONMONO_BOLDITALIC47PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x7C,
  0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3C, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00,
  0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x0E, 0x03, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x38,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xF1, 0x9F, 0xE1,
  0xFC, 0x71, 0xFC, 0x3F, 0x0E, 0x3F, 0x87, 0xE1, 0x83, 0x80, 0xFC, 0x30,
  0x00, 0x1F, 0x86, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x19, 0xFF, 0x00, 0x03, 0x0F, 0xE0, 0x00,
  0x60, 0xFC, 0x1C, 0x1C, 0x1F, 0x9F, 0x83, 0x83, 0xF3, 0xF0, 0x60, 0xFC,
  0x7F, 0x0C, 0x3F, 0x8F, 0xF1, 0x8F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0x78, 0x1F, 0xFC,
  0x01, 0xE0, 0x3C, 0x78, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x01, 0xE0, 0xF0,
  0x3C, 0x07, 0xC3, 0xE0, 0xF0, 0x0F, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x0F,
  0x00, 0x3C, 0x1E, 0x3C, 0x00, 0x78, 0x3C, 0xF0, 0x00, 0xF0, 0xF3, 0xC0,
  0x01, 0xF3, 0xEF, 0x00, 0x03, 0xFF, 0xBE, 0x00, 0x03, 0xFE, 0x78, 0x00,
  0x01, 0xF1, 0xE7, 0xE0, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x1E, 0xFF, 0xE0,
  0x00, 0x79, 0xE3, 0xC0, 0x01, 0xE7, 0x87, 0xC0, 0x07, 0x8F, 0x0F, 0x80,
  0x1E, 0x3C, 0x1E, 0x00, 0x7C, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0xF0, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0x0F, 0x9F, 0x03, 0xC0, 0x1F, 0xFC, 0x0F, 0x00, 0x1F, 0xF0, 0x3C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xE7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x81, 0xE0, 0x7F, 0xF0, 0x3E, 0x1F, 0xFE, 0x07,
  0x87, 0xF7, 0xC1, 0xF1, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x8F, 0xC1,
  0xFB, 0xE1, 0xF8, 0x1F, 0xFC, 0x3E, 0x03, 0xFF, 0x07, 0xC0, 0x3F, 0xE0,
  0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0x83, 0xFC, 0x03, 0xF0,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0xF8, 0xF8, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x31, 0xF1, 0x9F, 0x79, 0xE7, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x3E, 0xFC, 0x1F, 0x1F, 0x0F, 0xC7, 0xE1, 0xE0, 0xE0, 0x10, 0x20, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x3E, 0x7E, 0xFE, 0x3E, 0x7E, 0xFE,
  0x7C, 0x7E, 0xFE, 0x7C, 0xFE, 0xFC, 0x7C, 0xFE, 0xFC, 0x7C, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFB, 0xF0, 0x0F, 0xF7, 0xF0, 0x0F,
  0xC7, 0xF0, 0x0E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFF,
  0x00, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xF8, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C,
  0x03, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x7F, 0x7F, 0xF0, 0x7E, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC3, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x83,
  0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xE7,
  0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0x7F, 0x83, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x87, 0xF8, 0x7F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF1,
  0xFC, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0x9F, 0x80, 0x7F, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0x07, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0,
  0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x0F, 0x1F, 0xC1, 0xC1,
  0xFD, 0xCE, 0x0E, 0x1F, 0xEE, 0x70, 0xE1, 0xE3, 0x73, 0x87, 0x1E, 0x0F,
  0x1C, 0x70, 0xE0, 0x78, 0xE3, 0x8F, 0x03, 0x8F, 0x3C, 0xF0, 0x3C, 0x71,
  0xC7, 0x01, 0xE3, 0x8E, 0x78, 0x0E, 0x1C, 0x73, 0xC0, 0xF0, 0xE7, 0x1C,
  0x07, 0x8E, 0x39, 0xE0, 0x38, 0x71, 0xCF, 0x03, 0xC3, 0x8E, 0x78, 0x1C,
  0x38, 0x73, 0x81, 0xE1, 0xC7, 0x9C, 0x0F, 0x0E, 0x38, 0xE0, 0xF0, 0xE1,
  0xC7, 0x0F, 0x8E, 0x0E, 0x3C, 0xEC, 0xF0, 0x71, 0xFE, 0x7F, 0x03, 0xC7,
  0xE3, 0xF0, 0x1E, 0x1E, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x81, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xC3, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F,
  0xC1, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC,
  0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFC,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0C,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0x07,
  0xFF, 0xBF, 0x87, 0xFF, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x07, 0xF7, 0xF0,
  0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFF, 0x00, 0xFE, 0x3F,
  0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x60, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0,
  0x1F, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7B, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xEF, 0x0F, 0xFC, 0x0F, 0xBC,
  0x3D, 0xF0, 0x3E, 0xF9, 0xF7, 0xC0, 0xFB, 0xE7, 0xBF, 0x03, 0xEF, 0x9E,
  0xF8, 0x1F, 0xBE, 0xFB, 0xE0, 0x7C, 0xFB, 0xCF, 0x81, 0xF3, 0xFF, 0x3E,
  0x07, 0xCF, 0xF9, 0xF8, 0x1F, 0x3F, 0xE7, 0xC0, 0xFC, 0xFF, 0x1F, 0x03,
  0xE3, 0xFC, 0x7C, 0x0F, 0x87, 0xE1, 0xF0, 0x3E, 0x1F, 0x8F, 0xC0, 0xF8,
  0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x03, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0x3E, 0x07, 0xFC, 0x07, 0xE0,
  0x7F, 0xC0, 0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x0F, 0xFE,
  0x07, 0xC0, 0xFF, 0xE0, 0xFC, 0x0F, 0xBE, 0x0F, 0xC0, 0xFB, 0xE0, 0xFC,
  0x0F, 0xBE, 0x0F, 0xC1, 0xFB, 0xF0, 0xF8, 0x1F, 0xBF, 0x1F, 0x81, 0xFB,
  0xF1, 0xF8, 0x1F, 0x9F, 0x1F, 0x81, 0xF9, 0xF1, 0xF8, 0x3F, 0x1F, 0x1F,
  0x83, 0xF1, 0xFB, 0xF0, 0x3F, 0x1F, 0xBF, 0x03, 0xF0, 0xFB, 0xF0, 0x3F,
  0x0F, 0xBF, 0x03, 0xE0, 0xFB, 0xF0, 0x7E, 0x0F, 0xFE, 0x07, 0xE0, 0xFF,
  0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7C, 0x07, 0xFE, 0x0F,
  0xC0, 0x7F, 0xC0, 0xFC, 0x07, 0xFC, 0x0F, 0xC0, 0x7F, 0xC0, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xC0, 0x7F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFE, 0x0F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF,
  0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xC0, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x60, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x3C, 0x1F, 0x07, 0xE1, 0xF0, 0x7C,
  0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x8F, 0x81, 0xF8, 0xFE, 0x3E, 0x07,
  0xE7, 0xF9, 0xF8, 0x1F, 0x9F, 0xE7, 0xC0, 0x7C, 0xFF, 0x9F, 0x01, 0xF3,
  0xDE, 0xFC, 0x07, 0xDF, 0x7B, 0xE0, 0x1F, 0x79, 0xEF, 0x80, 0x7F, 0xE7,
  0xBE, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03,
  0xF7, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xC0, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xFC, 0xFF, 0xFD, 0xFF,
  0x7F, 0xF9, 0xFF, 0x3F, 0xF0, 0xFF, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xFE, 0x01, 0xF9, 0xFF, 0x81, 0xFD, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x9F, 0xE0, 0x1F, 0x8F, 0xF0, 0x1F,
  0xC7, 0xF8, 0x1F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFB, 0xFF, 0xE1, 0xFD, 0xFF,
  0xE0, 0xFE, 0x7F, 0xE0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F,
  0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x30, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x87, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x07, 0xFE, 0xFE,
  0x03, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xF0,
  0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0xCF, 0xC0, 0x3F,
  0xF3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0xFC, 0xFF, 0x01, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x1F, 0xF9, 0xFC, 0x07, 0xFF, 0xBF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x80, 0x7F, 0xC7, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xC0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0xFF, 0xC1, 0xFD, 0xFF,
  0xF0, 0xFD, 0xFF, 0xF8, 0x7E, 0xFF, 0xFC, 0x3F, 0xE0, 0xFE, 0x3F, 0xE0,
  0x7F, 0x1F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0,
  0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0x01, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F,
  0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xE0,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xC7, 0x83,
  0xE0, 0x3E, 0xFE, 0x3F, 0x81, 0xEF, 0xF3, 0xFE, 0x1F, 0x7F, 0xFF, 0xF0,
  0xFE, 0x7F, 0x9F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE1, 0xF0,
  0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x80, 0x0F, 0xE0, 0xFC, 0x07, 0xF1, 0xFF, 0x83, 0xF3,
  0xFF, 0xE1, 0xFB, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F,
  0xC0, 0xFE, 0x3F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xDF, 0xC0, 0x07,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x3F,
  0xF0, 0x0F, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x07, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0x01,
  0xFC, 0xFF, 0xC0, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0xFF, 0x8F, 0xC1,
  0xFF, 0xEF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x07, 0xF8,
  0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x83, 0xFF,
  0xEF, 0xC1, 0xFF, 0xEF, 0xE0, 0x7F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xC3,
  0xFF, 0x0F, 0xC7, 0xFF, 0x0F, 0xCF, 0xFF, 0x0F, 0xDF, 0xFE, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x03,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC,
  0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x01, 0xFE, 0x3F, 0x81, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xFF, 0xDF,
  0x83, 0xFF, 0xCF, 0xC1, 0xFF, 0xE7, 0xE0, 0x7F, 0xC7, 0xF0, 0x1F, 0x83,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xFC, 0x1F, 0x07, 0xCF, 0x83, 0xF0, 0x7C, 0xF8, 0x3F, 0x0F, 0x8F, 0x87,
  0xF0, 0xF8, 0xF8, 0x7F, 0x0F, 0x8F, 0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x1F,
  0x0F, 0x9E, 0xF1, 0xE0, 0xF9, 0xEF, 0xBE, 0x0F, 0xBC, 0x7B, 0xE0, 0xFB,
  0xC7, 0xBC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF6, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF0,
};

const GFXglyph LiberationMono_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 31, 28, 8, -31 },
  { 52, 19, 15, 28, 8, -34 },
  { 88, 28, 31, 28, 1, -31 },
  { 197, 27, 38, 28, 1, -34 },
  { 326, 31, 31, 28, -1, -31 },
  { 447, 27, 31, 28, 0, -31 },
  { 552, 8, 15, 28, 13, -34 },
  { 567, 18, 44, 28, 7, -34 },
  { 666, 18, 44, 28, 3, -34 },
  { 765, 18, 17, 28, 8, -34 },
  { 804, 24, 23, 28, 2, -27 },
  { 873, 14, 15, 28, 2, -7 },
  { 900, 14, 6, 28, 7, -15 },
  { 911, 8, 7, 28, 8, -7 },
  { 918, 30, 34, 28, 0, -34 },
  { 1046, 24, 31, 28, 3, -31 },
  { 1139, 24, 31, 28, 1, -31 },
  { 1232, 27, 31, 28, 0, -31 },
  { 1337, 26, 31, 28, 1, -31 },
  { 1438, 27, 31, 28, 0, -31 },
  { 1543, 26, 31, 28, 2, -31 },
  { 1644, 24, 31, 28, 3, -31 },
  { 1737, 24, 31, 28, 5, -31 },
  { 1830, 25, 31, 28, 2, -31 },
  { 1927, 25, 31, 28, 2, -31 },
  { 2024, 12, 25, 28, 8, -25 },
  { 2062, 17, 33, 28, 3, -25 },
  { 2133, 24, 25, 28, 2, -28 },
  { 2208, 24, 18, 28, 2, -24 },
  { 2262, 24, 25, 28, 2, -28 },
  { 2337, 25, 31, 28, 3, -31 },
  { 2434, 29, 41, 28, 0, -34 },
  { 2583, 28, 31, 28, -2, -31 },
  { 2692, 27, 31, 28, 1, -31 },
  { 2797, 26, 31, 28, 2, -31 },
  { 2898, 27, 31, 28, 1, -31 },
  { 3003, 28, 31, 28, 1, -31 },
  { 3112, 28, 31, 28, 1, -31 },
  { 3221, 25, 31, 28, 2, -31 },
  { 3318, 28, 31, 28, 1, -31 },
  { 3427, 27, 31, 28, 1, -31 },
  { 3532, 25, 31, 28, 2, -31 },
  { 3629, 30, 31, 28, 1, -31 },
  { 3746, 22, 31, 28, 2, -31 },
  { 3832, 30, 31, 28, 0, -31 },
  { 3949, 28, 31, 28, 1, -31 },
  { 4058, 26, 31, 28, 2, -31 },
  { 4159, 27, 31, 28, 1, -31 },
  { 4264, 26, 40, 28, 2, -31 },
  { 4394, 28, 31, 28, 1, -31 },
  { 4503, 28, 31, 28, 0, -31 },
  { 4612, 26, 31, 28, 4, -31 },
  { 4713, 27, 31, 28, 2, -31 },
  { 4818, 28, 31, 28, 4, -31 },
  { 4927, 30, 31, 28, 2, -31 },
  { 5044, 33, 31, 28, -2, -31 },
  { 5172, 28, 31, 28, 4, -31 },
  { 5281, 29, 31, 28, 0, -31 },
  { 5394, 23, 44, 28, 4, -34 },
  { 5521, 18, 34, 28, 6, -34 },
  { 5598, 22, 44, 28, 2, -34 },
  { 5719, 25, 21, 28, 1, -32 },
  { 5785, 29, 2, 28, -4, 3 },
  { 5793, 11, 6, 28, 12, -33 },
  { 5802, 24, 25, 28, 1, -25 },
  { 5877, 25, 34, 28, 1, -34 },
  { 5984, 24, 25, 28, 2, -25 },
  { 6059, 27, 34, 28, 2, -34 },
  { 6174, 24, 25, 28, 2, -25 },
  { 6249, 26, 34, 28, 4, -34 },
  { 6360, 27, 35, 28, 1, -25 },
  { 6479, 25, 34, 28, 1, -34 },
  { 6586, 25, 34, 28, 0, -34 },
  { 6693, 25, 44, 28, -1, -34 },
  { 6831, 27, 34, 28, 2, -34 },
  { 6946, 25, 34, 28, 0, -34 },
  { 7053, 29, 25, 28, -1, -25 },
  { 7144, 25, 25, 28, 1, -25 },
  { 7223, 25, 25, 28, 2, -25 },
  { 7302, 27, 35, 28, -1, -25 },
  { 7421, 25, 35, 28, 2, -25 },
  { 7531, 24, 25, 28, 3, -25 },
  { 7606, 24, 25, 28, 2, -25 },
  { 7681, 20, 31, 28, 5, -31 },
  { 7759, 25, 25, 28, 2, -25 },
  { 7838, 27, 25, 28, 3, -25 },
  { 7923, 28, 25, 28, 2, -25 },
  { 8011, 30, 25, 28, -1, -25 },
  { 8105, 31, 35, 28, -1, -25 },
  { 8241, 25, 25, 28, 1, -25 },
  { 8320, 24, 44, 28, 4, -34 },
  { 8452, 6, 44, 28, 11, -34 },
  { 8485, 24, 44, 28, 0, -34 },
  { 8617, 25, 7, 28, 2, -19 },
};

const GFXfont LiberationMono_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic47pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _LIBERATIONMONO_BOLDITALIC47PT7B_H_
