#ifndef _LIBERATIONMONO_BOLDITALIC65PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0xC7, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xF1, 0xCF, 0xFE, 0x03, 0xFF, 0x0F, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3C, 0x3F, 0xE0, 0x3F, 0xC0, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0x81, 0xF8,
  0x07, 0xFC, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0x7F, 0xC1,
  0xE0, 0x00, 0x01, 0xFF, 0x87, 0x00, 0x00, 0x07, 0xFF, 0xDC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x1F, 0xFE, 0x00,
  0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xC0,
  0xFF, 0x80, 0x18, 0x0F, 0x03, 0xFE, 0x1F, 0xE0, 0x38, 0x0F, 0xF8, 0xFF,
  0x80, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0x80, 0xFF, 0x0F, 0xFC, 0x1E, 0x07,
  0xFC, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0x7F, 0xF1, 0xC7, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x00, 0xF8, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x87, 0xFF, 0x00, 0x00, 0x07, 0xE3, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x03, 0xF0,
  0x00, 0x3E, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00,
  0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xE3, 0xF0,
  0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x7E,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFB,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x01, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0x81,
  0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xC7, 0xF8,
  0x1F, 0x81, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF0, 0x3F,
  0xC0, 0xFF, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xF8, 0x07, 0xFF,
  0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0xFC, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x08, 0xE0, 0xFC, 0x1C, 0x7C,
  0x7E, 0x7E, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xFC,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x3F, 0x00, 0x70, 0x0E,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07,
  0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0xFC, 0x3F, 0xEF, 0xF8, 0xFE,
  0x1F, 0xF7, 0xFC, 0x7F, 0x1F, 0xF3, 0xFE, 0x3F, 0x8F, 0xF9, 0xFE, 0x1F,
  0xC7, 0xFD, 0xFF, 0x0F, 0xE3, 0xFE, 0xFF, 0x8F, 0xE1, 0xFF, 0x7F, 0xC7,
  0xF1, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xEF, 0xF8, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F,
  0x81, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xDF, 0xFF, 0x00, 0x07, 0xFB, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xC1,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x00,
  0x1F, 0xF1, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0x9F, 0xF0,
  0x07, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x60, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0xE3, 0xDF, 0x01, 0xE0, 0x3F, 0xF3,
  0xDF, 0x03, 0xE0, 0xFF, 0xF7, 0x8F, 0x03, 0xC0, 0xF8, 0x77, 0x8F, 0x07,
  0xC1, 0xF0, 0x7F, 0x8F, 0x07, 0x83, 0xE0, 0x3F, 0x1F, 0x0F, 0x87, 0xC0,
  0x3F, 0x1F, 0x0F, 0x87, 0xC0, 0x3F, 0x1F, 0x0F, 0x0F, 0x80, 0x3E, 0x1E,
  0x1F, 0x0F, 0x00, 0x7E, 0x1E, 0x1E, 0x1F, 0x00, 0x7C, 0x1E, 0x1E, 0x1F,
  0x00, 0x7C, 0x1E, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x3E, 0x3E, 0x00, 0xF8,
  0x3C, 0x3C, 0x3C, 0x00, 0xF8, 0x3C, 0x3C, 0x7C, 0x00, 0xF0, 0x3C, 0x7C,
  0x7C, 0x01, 0xF0, 0x78, 0x7C, 0x7C, 0x01, 0xF0, 0x78, 0x78, 0xF8, 0x03,
  0xE0, 0x78, 0x78, 0xF8, 0x03, 0xE0, 0xF0, 0x78, 0xF8, 0x07, 0xE0, 0xF0,
  0x78, 0xF8, 0x07, 0xC1, 0xF0, 0x78, 0xF8, 0x0F, 0xC1, 0xE0, 0xF8, 0xF8,
  0x0F, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x83, 0xC0, 0xF8, 0xF8, 0x3B, 0x87,
  0x80, 0xF8, 0xFC, 0x7B, 0x8F, 0x80, 0xF8, 0x7F, 0xF3, 0xFF, 0x00, 0xF8,
  0x7F, 0xE3, 0xFE, 0x00, 0x78, 0x3F, 0xC3, 0xFC, 0x00, 0x78, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x10, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x1F, 0xE1, 0xFF, 0x80, 0x01, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xF7, 0xFE, 0x07, 0xFF,
  0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xF3, 0xFE, 0x03,
  0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x3E,
  0xFC, 0x03, 0xFB, 0xF0, 0x3F, 0xFE, 0x01, 0xFD, 0xF8, 0x1F, 0xFF, 0x00,
  0xFE, 0xFC, 0x1F, 0xBF, 0x80, 0x7F, 0x7E, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x07, 0xFF, 0xC0, 0x3F, 0xDF, 0x87, 0xEF, 0xE0, 0x1F, 0xCF, 0xC3, 0xF7,
  0xF0, 0x0F, 0xE7, 0xE3, 0xF3, 0xF8, 0x07, 0xF3, 0xF1, 0xF9, 0xFC, 0x03,
  0xF9, 0xF9, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0xFC, 0xFE, 0x01, 0xFC, 0x7E,
  0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xBF, 0x1F,
  0xC0, 0x3F, 0x8F, 0xDF, 0x1F, 0xE0, 0x1F, 0xC7, 0xFF, 0x8F, 0xE0, 0x1F,
  0xC3, 0xFF, 0x87, 0xF0, 0x0F, 0xE0, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0x7F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x80,
  0x3F, 0xBF, 0x80, 0xFF, 0x00, 0x7F, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0xFF,
  0x03, 0xFC, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x07, 0xFB, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF3, 0xF8, 0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x7F, 0x80, 0x7F, 0xCF,
  0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xC7, 0xFC,
  0x03, 0xFC, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0xFF,
  0x00, 0xFF, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x07, 0xF7, 0xF8, 0x03, 0xFC,
  0x0F, 0xEF, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x7F,
  0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0xC3, 0xF8,
  0x07, 0xF8, 0xFF, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0xF1, 0xFC, 0x01, 0xFE,
  0x7F, 0xF8, 0xFE, 0x00, 0xFF, 0x3F, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0x7E,
  0x7F, 0x00, 0x3F, 0x9F, 0xBF, 0x3F, 0x80, 0x1F, 0xDF, 0x9F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xCF, 0xFF, 0xC0, 0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x03, 0xFF,
  0xE3, 0xFF, 0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0x0F, 0xF8,
  0x07, 0xFF, 0x87, 0xFE, 0x0F, 0xBF, 0xE3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0x83, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x01,
  0xFF, 0x3F, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xFC, 0x07, 0xFD, 0xFF,
  0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0xFC, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xF3, 0xFE,
  0x00, 0x3F, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xE7, 0xFC, 0x00, 0x7F,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x10, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xF0, 0x01, 0xFF,
  0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0xF3, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xF8,
  0x03, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0xF3, 0xFE,
  0x00, 0x0F, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x1F,
  0xFF, 0x00, 0x7F, 0x87, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0xFE, 0x03, 0xFE,
  0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xF1, 0xFE, 0x0F, 0xF8, 0x0F,
  0xE7, 0xFE, 0x3F, 0xF8, 0x1F, 0xDF, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF, 0xFB,
  0xFF, 0xE0, 0x7E, 0xFF, 0xF7, 0xFF, 0xC0, 0xFF, 0x8F, 0xFE, 0x7F, 0x83,
  0xFE, 0x1F, 0xF8, 0x7F, 0x07, 0xFC, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xF0,
  0xFF, 0x03, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x7F,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F,
  0xC3, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xE7,
  0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x0F,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0xFE, 0x00, 0x3F, 0xE7, 0xFF, 0xF8, 0x00,
  0xFF, 0xBF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0x80,
  0x1F, 0xF7, 0xFF, 0xFC, 0x00, 0x7F, 0xCF, 0xFF, 0xE0, 0x03, 0xFE, 0x1F,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC1,
  0xFF, 0x00, 0x3F, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xF3, 0xFE, 0x01, 0xFF,
  0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFC, 0xFF,
  0x80, 0x0F, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFC, 0x0F, 0xFF,
  0x81, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0x8F, 0xFF,
  0xF0, 0x3F, 0xCF, 0xFF, 0xF8, 0x1F, 0xEF, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xC0,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0x81,
  0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x01,
  0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0x3F,
  0x87, 0xF0, 0x3F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFF, 0x83, 0xF8, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0x7C, 0x3F, 0x81, 0xFC, 0x7E, 0xF8, 0x7E, 0x03, 0xF8,
  0xF9, 0xF1, 0xFC, 0x07, 0xF3, 0xF3, 0xF3, 0xF8, 0x0F, 0xE7, 0xC7, 0xE7,
  0xE0, 0x1F, 0xDF, 0x8F, 0xDF, 0xC0, 0x3F, 0xBE, 0x1F, 0xBF, 0x80, 0x7E,
  0xFC, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0D, 0xFF, 0xFF, 0xF0,
  0x0F, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x3F, 0xFF, 0xFC, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
};

const GFXglyph LiberationMono_BoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 17, 43, 39, 12, -43 },
  { 93, 26, 20, 39, 11, -47 },
  { 158, 39, 43, 39, 1, -43 },
  { 368, 38, 53, 39, 1, -48 },
  { 620, 43, 45, 39, -1, -44 },
  { 862, 38, 44, 39, -1, -43 },
  { 1071, 12, 20, 39, 18, -47 },
  { 1101, 25, 60, 39, 10, -47 },
  { 1289, 25, 60, 39, 4, -47 },
  { 1477, 25, 24, 39, 11, -47 },
  { 1552, 33, 33, 39, 3, -38 },
  { 1689, 19, 21, 39, 3, -9 },
  { 1739, 20, 8, 39, 9, -21 },
  { 1759, 11, 10, 39, 12, -10 },
  { 1773, 43, 48, 39, -1, -47 },
  { 2031, 33, 45, 39, 4, -44 },
  { 2217, 33, 43, 39, 1, -43 },
  { 2395, 37, 44, 39, 1, -44 },
  { 2599, 36, 45, 39, 2, -44 },
  { 2802, 36, 43, 39, 1, -43 },
  { 2996, 36, 44, 39, 2, -43 },
  { 3194, 33, 45, 39, 4, -44 },
  { 3380, 33, 43, 39, 7, -43 },
  { 3558, 36, 45, 39, 2, -44 },
  { 3761, 34, 45, 39, 3, -44 },
  { 3953, 15, 34, 39, 12, -34 },
  { 4017, 23, 46, 39, 5, -34 },
  { 4150, 33, 35, 39, 3, -39 },
  { 4295, 33, 25, 39, 3, -34 },
  { 4399, 33, 35, 39, 3, -39 },
  { 4544, 33, 44, 39, 5, -44 },
  { 4726, 40, 56, 39, 0, -47 },
  { 5006, 39, 43, 39, -3, -43 },
  { 5216, 37, 43, 39, 1, -43 },
  { 5415, 36, 45, 39, 3, -44 },
  { 5618, 37, 43, 39, 1, -43 },
  { 5817, 39, 43, 39, 1, -43 },
  { 6027, 38, 43, 39, 2, -43 },
  { 6232, 35, 45, 39, 3, -44 },
  { 6429, 39, 43, 39, 1, -43 },
  { 6639, 37, 43, 39, 2, -43 },
  { 6838, 35, 44, 39, 2, -43 },
  { 7031, 42, 43, 39, 1, -43 },
  { 7257, 31, 43, 39, 3, -43 },
  { 7424, 41, 43, 39, 0, -43 },
  { 7645, 39, 43, 39, 1, -43 },
  { 7855, 36, 45, 39, 2, -44 },
  { 8058, 38, 43, 39, 1, -43 },
  { 8263, 36, 57, 39, 2, -44 },
  { 8520, 39, 43, 39, 1, -43 },
  { 8730, 39, 45, 39, 0, -44 },
  { 8950, 36, 43, 39, 6, -43 },
  { 9144, 37, 44, 39, 3, -43 },
  { 9348, 39, 43, 39, 5, -43 },
  { 9558, 41, 43, 39, 3, -43 },
  { 9779, 46, 43, 39, -3, -43 },
  { 10027, 39, 43, 39, 5, -43 },
  { 10237, 41, 43, 39, -1, -43 },
  { 10458, 31, 60, 39, 6, -47 },
  { 10691, 24, 48, 39, 9, -47 },
  { 10835, 31, 60, 39, 2, -47 },
  { 11068, 35, 28, 39, 1, -45 },
  { 11191, 40, 3, 39, -5, 4 },
  { 11206, 15, 9, 39, 16, -47 },
  { 11223, 33, 36, 39, 2, -35 },
  { 11372, 36, 48, 39, 1, -47 },
  { 11588, 33, 36, 39, 3, -35 },
  { 11737, 38, 48, 39, 2, -47 },
  { 11965, 33, 36, 39, 3, -35 },
  { 12114, 35, 48, 39, 6, -48 },
  { 12324, 38, 48, 39, 1, -35 },
  { 12552, 35, 47, 39, 1, -47 },
  { 12758, 34, 47, 39, 0, -47 },
  { 12958, 35, 60, 39, -2, -47 },
  { 13221, 38, 47, 39, 2, -47 },
  { 13445, 34, 47, 39, 0, -47 },
  { 13645, 39, 35, 39, -1, -35 },
  { 13816, 35, 35, 39, 1, -35 },
  { 13970, 35, 36, 39, 2, -35 },
  { 14128, 38, 48, 39, -1, -35 },
  { 14356, 36, 48, 39, 2, -35 },
  { 14572, 33, 35, 39, 5, -35 },
  { 14717, 34, 36, 39, 2, -35 },
  { 14870, 28, 44, 39, 7, -43 },
  { 15024, 34, 35, 39, 3, -34 },
  { 15173, 37, 34, 39, 4, -34 },
  { 15331, 39, 34, 39, 3, -34 },
  { 15497, 42, 34, 39, -2, -34 },
  { 15676, 42, 47, 39, -1, -34 },
  { 15923, 35, 34, 39, 1, -34 },
  { 16072, 34, 60, 39, 5, -47 },
  { 16327, 9, 61, 39, 15, -47 },
  { 16396, 33, 60, 39, 0, -47 },
  { 16644, 35, 10, 39, 3, -27 },
};

const GFXfont LiberationMono_BoldItalic65pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic65pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic65pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _LIBERATIONMONO_BOLDITALIC65PT7B_H_
