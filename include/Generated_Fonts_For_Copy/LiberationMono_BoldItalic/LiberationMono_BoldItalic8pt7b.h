#ifndef _LIBERATIONMONO_BOLDITALIC8PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x04, 0x6A, 0xA0, 0x2B, 0xD5, 0xEA, 0x00, 0x03, 0xD8, 0x6B,
  0x78, 0x00, 0xED, 0x9C, 0xDB, 0x00, 0x72, 0x99, 0x6F, 0x00, 0x68, 0x29,
  0x69, 0x22, 0x22, 0x33, 0x22, 0x44, 0x1D, 0x80, 0x22, 0xF2, 0x48, 0xE0,
  0x40, 0x08, 0x84, 0x44, 0x40, 0x72, 0xDD, 0xA6, 0x00, 0x72, 0x22, 0xF0,
  0x78, 0x8C, 0x8F, 0x00, 0x78, 0x8C, 0x2F, 0x00, 0x11, 0x95, 0xE3, 0x00,
  0x7B, 0x14, 0x2F, 0x00, 0x7A, 0x1C, 0xA7, 0x00, 0xF2, 0x4C, 0x80, 0x7A,
  0x9D, 0x2F, 0x00, 0x72, 0xDC, 0x26, 0x00, 0x41, 0x43, 0x80, 0x07, 0xC3,
  0x00, 0xF0, 0xF0, 0x87, 0x16, 0x00, 0xF3, 0x40, 0x80, 0x32, 0x6F, 0xBE,
  0xEB, 0x80, 0x35, 0x5F, 0x90, 0x7A, 0xDD, 0xBF, 0x00, 0x7A, 0x31, 0xA7,
  0x00, 0x72, 0x57, 0xAE, 0x00, 0x7A, 0x1D, 0x8F, 0x00, 0x7A, 0x1C, 0x88,
  0x00, 0x7A, 0x3D, 0xA7, 0x00, 0x4A, 0xDD, 0xA9, 0x00, 0x79, 0x08, 0x4F,
  0x00, 0x30, 0x85, 0x26, 0x00, 0x5B, 0x99, 0xE9, 0x00, 0x44, 0x44, 0x70,
  0x5A, 0xEB, 0x69, 0x00, 0x6B, 0x5D, 0x6B, 0x00, 0x7A, 0x77, 0x27, 0x00,
  0x7A, 0x5D, 0x88, 0x00, 0x7A, 0x77, 0x27, 0x10, 0xC0, 0x7A, 0x5D, 0xA9,
  0x00, 0x7A, 0x0C, 0x2F, 0x00, 0xF4, 0x44, 0x40, 0x4A, 0xD5, 0xA7, 0x00,
  0x9A, 0xAC, 0xC0, 0x4B, 0x6D, 0xAD, 0x00, 0x59, 0x88, 0xA9, 0x00, 0x9A,
  0x44, 0x40, 0x78, 0x88, 0x8F, 0x00, 0x64, 0x44, 0x88, 0x8C, 0x91, 0x22,
  0x40, 0x31, 0x12, 0x22, 0x2E, 0x33, 0x59, 0xF8, 0x80, 0x77, 0x9F, 0x42,
  0x1C, 0xAD, 0x78, 0x74, 0xC7, 0x08, 0x5D, 0xA9, 0x78, 0x7F, 0x87, 0x74,
  0xF4, 0x88, 0x7A, 0xB4, 0xE1, 0x30, 0x44, 0x75, 0xD9, 0x10, 0x62, 0x2F,
  0x10, 0x72, 0x22, 0x2C, 0x42, 0x14, 0xC7, 0x48, 0x33, 0x22, 0x2F, 0x7D,
  0x6D, 0x60, 0x75, 0xD9, 0x76, 0xE4, 0xE0, 0x72, 0xB5, 0xE8, 0x40, 0x76,
  0xA5, 0xE1, 0x18, 0xE8, 0x88, 0x76, 0x1F, 0x5E, 0x4E, 0x52, 0xB5, 0xE0,
  0x9A, 0xCC, 0x8D, 0x7D, 0xA0, 0x51, 0x19, 0x20, 0x4A, 0x98, 0xC4, 0x40,
  0x72, 0x4F, 0x34, 0x4C, 0x88, 0x8C, 0xFF, 0x71, 0x23, 0x22, 0x2C, 0xF8,
};

const GFXglyph LiberationMono_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 5, 5, 1, -5 },
  { 3, 4, 3, 5, 1, -6 },
  { 5, 5, 5, 5, 0, -5 },
  { 9, 5, 7, 5, 0, -6 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 5, 5, 5, 0, -5 },
  { 22, 2, 3, 5, 2, -6 },
  { 23, 3, 8, 5, 1, -6 },
  { 26, 4, 8, 5, 0, -6 },
  { 30, 3, 3, 5, 1, -6 },
  { 32, 4, 4, 5, 0, -5 },
  { 34, 3, 2, 5, 0, -1 },
  { 35, 3, 1, 5, 1, -3 },
  { 36, 2, 1, 5, 1, -1 },
  { 37, 5, 6, 5, 0, -6 },
  { 41, 5, 5, 5, 0, -5 },
  { 45, 4, 5, 5, 0, -5 },
  { 48, 5, 5, 5, 0, -5 },
  { 52, 5, 5, 5, 0, -5 },
  { 56, 5, 5, 5, 0, -5 },
  { 60, 5, 5, 5, 0, -5 },
  { 64, 5, 5, 5, 0, -5 },
  { 68, 4, 5, 5, 1, -5 },
  { 71, 5, 5, 5, 0, -5 },
  { 75, 5, 5, 5, 0, -5 },
  { 79, 2, 4, 5, 1, -4 },
  { 80, 2, 5, 5, 1, -4 },
  { 82, 4, 5, 5, 0, -5 },
  { 85, 4, 3, 5, 0, -4 },
  { 87, 4, 5, 5, 0, -5 },
  { 90, 4, 5, 5, 1, -5 },
  { 93, 5, 7, 5, 0, -6 },
  { 98, 4, 5, 5, 0, -5 },
  { 101, 5, 5, 5, 0, -5 },
  { 105, 5, 5, 5, 0, -5 },
  { 109, 5, 5, 5, 0, -5 },
  { 113, 5, 5, 5, 0, -5 },
  { 117, 5, 5, 5, 0, -5 },
  { 121, 5, 5, 5, 0, -5 },
  { 125, 5, 5, 5, 0, -5 },
  { 129, 5, 5, 5, 0, -5 },
  { 133, 5, 5, 5, 0, -5 },
  { 137, 5, 5, 5, 0, -5 },
  { 141, 4, 5, 5, 0, -5 },
  { 144, 5, 5, 5, 0, -5 },
  { 148, 5, 5, 5, 0, -5 },
  { 152, 5, 5, 5, 0, -5 },
  { 156, 5, 5, 5, 0, -5 },
  { 160, 5, 7, 5, 0, -5 },
  { 165, 5, 5, 5, 0, -5 },
  { 169, 5, 5, 5, 0, -5 },
  { 173, 4, 5, 5, 1, -5 },
  { 176, 5, 5, 5, 0, -5 },
  { 180, 4, 5, 5, 1, -5 },
  { 183, 5, 5, 5, 0, -5 },
  { 187, 5, 5, 5, 0, -5 },
  { 191, 4, 5, 5, 1, -5 },
  { 194, 5, 5, 5, 0, -5 },
  { 198, 4, 8, 5, 1, -6 },
  { 202, 3, 6, 5, 1, -6 },
  { 205, 4, 8, 5, 0, -6 },
  { 209, 4, 4, 5, 0, -6 },
  { 211, 5, 1, 5, -1, 0 },
  { 212, 2, 1, 5, 2, -6 },
  { 213, 4, 4, 5, 0, -4 },
  { 215, 5, 6, 5, 0, -6 },
  { 219, 4, 4, 5, 0, -4 },
  { 221, 5, 6, 5, 0, -6 },
  { 225, 4, 4, 5, 0, -4 },
  { 227, 4, 6, 5, 1, -6 },
  { 230, 5, 6, 5, 0, -4 },
  { 234, 4, 6, 5, 0, -6 },
  { 237, 4, 6, 5, 0, -6 },
  { 240, 4, 8, 5, 0, -6 },
  { 244, 5, 6, 5, 0, -6 },
  { 248, 4, 6, 5, 0, -6 },
  { 251, 5, 4, 5, 0, -4 },
  { 254, 4, 4, 5, 0, -4 },
  { 256, 5, 4, 5, 0, -4 },
  { 259, 5, 6, 5, 0, -4 },
  { 263, 5, 6, 5, 0, -4 },
  { 267, 4, 4, 5, 1, -4 },
  { 269, 4, 4, 5, 0, -4 },
  { 271, 3, 5, 5, 1, -5 },
  { 273, 5, 4, 5, 0, -4 },
  { 276, 4, 4, 5, 1, -4 },
  { 278, 5, 4, 5, 0, -4 },
  { 281, 5, 4, 5, 0, -4 },
  { 284, 5, 6, 5, 0, -4 },
  { 288, 4, 4, 5, 0, -4 },
  { 290, 4, 8, 5, 1, -6 },
  { 294, 1, 8, 5, 2, -6 },
  { 295, 4, 8, 5, 0, -6 },
  { 299, 5, 1, 5, 0, -3 },
};

const GFXfont LiberationMono_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic8pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _LIBERATIONMONO_BOLDITALIC8PT7B_H_
