#ifndef _LIBERATIONMONO_BOLDITALIC58PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x9F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xCE, 0x7F, 0xE0, 0x7F, 0x87, 0x0F, 0xF0, 0x7F, 0x83,
  0x87, 0xF8, 0x3F, 0xC1, 0xC1, 0xFC, 0x1F, 0xC1, 0xE0, 0xE0, 0x0F, 0xE0,
  0xE0, 0x00, 0x07, 0xF8, 0x70, 0x00, 0x03, 0xFC, 0x38, 0x00, 0x01, 0xFF,
  0x9C, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x38, 0xFF, 0xC0, 0x00, 0x1C, 0x1F, 0xE0, 0x00, 0x0E, 0x0F, 0xF0,
  0x00, 0x0E, 0x03, 0xF8, 0x3E, 0x07, 0x03, 0xFC, 0xFF, 0x03, 0x81, 0xFE,
  0x7F, 0x81, 0xC0, 0xFE, 0x3F, 0xC0, 0xE0, 0xFF, 0x1F, 0xF0, 0xE0, 0xFF,
  0x87, 0xFE, 0x71, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF8,
  0x07, 0xFF, 0x80, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0x80, 0x7E, 0x3F,
  0x00, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x7C, 0x00, 0x07, 0xE3,
  0xF0, 0xF8, 0x00, 0x07, 0xFF, 0xC3, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0x80,
  0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xF1, 0xFF, 0xE0, 0x00,
  0x07, 0xC7, 0xFF, 0xE0, 0x00, 0x1F, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF8,
  0x00, 0x07, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x07, 0xFF, 0xE0, 0x1F, 0x83, 0xFF,
  0xFC, 0x0F, 0xC1, 0xFE, 0x7F, 0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x83, 0xF8, 0x7E, 0x1F, 0xE0, 0x7F, 0x3F, 0x07, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0xFC,
  0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x01, 0xF8, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC,
  0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0x07, 0xC1,
  0x87, 0x8F, 0x8F, 0x1F, 0xDF, 0x7E, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x3F, 0x81, 0xF0, 0x3E, 0x01, 0xC0, 0x70, 0x00, 0x80, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F,
  0xCF, 0xF3, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF,
  0x3F, 0xC7, 0xE3, 0xFC, 0xFF, 0x1F, 0x8F, 0xF7, 0xF8, 0xFC, 0x7F, 0x9F,
  0xE3, 0xF1, 0xFE, 0x7F, 0x8F, 0xC7, 0xF9, 0xFE, 0x3F, 0x1F, 0xE7, 0xF8,
  0xFC, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x0F, 0xF0,
  0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x07, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFB, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xF8,
  0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF7, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF1, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF9,
  0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF3,
  0xFE, 0x01, 0xFF, 0x8F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xFB, 0xFC, 0x03, 0xFF,
  0x8F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFC, 0x01, 0xFF,
  0x3F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7F, 0x1E, 0xE0, 0x3C, 0x1F, 0xFB, 0xCF,
  0x07, 0xC3, 0xFF, 0xBC, 0xF0, 0x78, 0x7E, 0x3F, 0x8F, 0x0F, 0x07, 0xC1,
  0xF8, 0xE0, 0xF0, 0xF8, 0x1F, 0x8E, 0x0F, 0x1F, 0x01, 0xF1, 0xE1, 0xE1,
  0xE0, 0x1F, 0x1E, 0x1E, 0x3E, 0x01, 0xE1, 0xE1, 0xC3, 0xC0, 0x3E, 0x1E,
  0x3C, 0x7C, 0x03, 0xC1, 0xC3, 0xC7, 0x80, 0x3C, 0x3C, 0x3C, 0x78, 0x07,
  0xC3, 0xC7, 0x8F, 0x80, 0x78, 0x3C, 0x78, 0xF0, 0x07, 0x83, 0x87, 0x8F,
  0x00, 0xF0, 0x78, 0x79, 0xF0, 0x0F, 0x07, 0x87, 0x9F, 0x01, 0xF0, 0xF0,
  0x71, 0xF0, 0x1E, 0x0F, 0x0F, 0x1E, 0x03, 0xE1, 0xE0, 0xF1, 0xE0, 0x7E,
  0x1E, 0x0F, 0x1F, 0x0E, 0xC3, 0xC0, 0xF1, 0xF1, 0xFC, 0x7C, 0x0F, 0x1F,
  0xFD, 0xFF, 0x80, 0xF0, 0xFF, 0x9F, 0xF0, 0x0F, 0x0F, 0xF0, 0xFE, 0x00,
  0x78, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xF8,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x04, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7E, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0x07, 0xF8, 0x07, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x87,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0xFE, 0x7F, 0xC1, 0xFF, 0xFE, 0x7F, 0x81, 0xFF, 0xFE, 0x7F, 0x81, 0xFF,
  0xFC, 0x7F, 0x81, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0x80, 0x03,
  0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x07,
  0xF8, 0x7F, 0xC0, 0x07, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xF7, 0xE0,
  0x7E, 0xFC, 0x1F, 0xFE, 0x07, 0xEF, 0xC3, 0xEF, 0xC0, 0x7E, 0xFC, 0x3E,
  0xFC, 0x07, 0xEF, 0xC7, 0xEF, 0xC0, 0x7E, 0xFC, 0x7C, 0xFC, 0x0F, 0xEF,
  0xCF, 0xDF, 0xC0, 0xFC, 0xFC, 0xF9, 0xF8, 0x0F, 0xC7, 0xDF, 0x9F, 0x80,
  0xFC, 0x7D, 0xF1, 0xF8, 0x0F, 0xC7, 0xDF, 0x1F, 0x81, 0xFC, 0x7F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xFE, 0x3F, 0x01, 0xF8, 0x7F, 0xE3, 0xF0, 0x1F, 0x87,
  0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0xC3, 0xF0, 0x3F, 0x87, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x87, 0xE0, 0x3F, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0xC0, 0x7F, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x01, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xF0, 0x0F, 0xE0,
  0x3F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x81,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFD, 0xF8, 0x1F, 0xC0, 0xFE, 0x7F,
  0x0F, 0xF0, 0x3F, 0x9F, 0xC3, 0xF8, 0x0F, 0xE7, 0xF0, 0xFE, 0x03, 0xF9,
  0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x0F, 0xE0, 0x7F, 0x8F, 0xC7, 0xF8, 0x1F,
  0xE3, 0xF9, 0xFC, 0x07, 0xF0, 0xFE, 0x7F, 0x01, 0xFC, 0x3F, 0x9F, 0xC0,
  0x7F, 0x0F, 0xE7, 0xF0, 0x3F, 0xC1, 0xF9, 0xFC, 0x0F, 0xF0, 0x7F, 0x7E,
  0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF,
  0xF8, 0x1F, 0xE0, 0x3F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFC, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC,
  0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x1F, 0xF0, 0xFC, 0x07, 0xF1, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0xF1, 0xFC,
  0x07, 0xE3, 0xFF, 0x1F, 0x80, 0x7E, 0x7F, 0xFB, 0xF8, 0x07, 0xE7, 0xFF,
  0xBF, 0x80, 0x7E, 0xFD, 0xFB, 0xF0, 0x07, 0xEF, 0xDF, 0xBF, 0x00, 0xFF,
  0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80,
  0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFF, 0xDF, 0xFD, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0xF1, 0xFF,
  0xC7, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xFC, 0x7F, 0xF0, 0x03, 0xFC, 0xFF, 0xF8,
  0x03, 0xFB, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFE,
  0x07, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC,
  0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0xBF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0x80,
  0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x0F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0xFF, 0x00, 0x1F, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0x8F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0x83, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xC1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xE0, 0x03, 0xFF, 0xE7, 0xF8,
  0x03, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xC3, 0xFF,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xEF, 0xF0, 0x03, 0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xF8, 0x03, 0xFC, 0xFF, 0xFC, 0x03, 0xF9,
  0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07, 0xFF,
  0x83, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xC0,
  0x01, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x7F, 0x87, 0xF8, 0x0F,
  0xDF, 0xF1, 0xFF, 0x81, 0xF7, 0xFF, 0x7F, 0xF0, 0x7E, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF9, 0xFF, 0x9F, 0xC1, 0xFE, 0x3F, 0xE3, 0xF8, 0x3F, 0x87, 0xF8,
  0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xF8, 0x03, 0xF8, 0xFF, 0xFC, 0x07, 0xF9,
  0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07, 0xFF,
  0x83, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F,
  0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD,
  0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC7, 0xFF, 0x00, 0x0F,
  0xF3, 0xFF, 0xE0, 0x03, 0xF9, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0x00,
  0x7F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xF8, 0x03, 0xFE, 0x7F,
  0xFC, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFD,
  0xFE, 0x03, 0xFF, 0xFD, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x07, 0xF8, 0x0F,
  0xFE, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x80, 0x0F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0x3F,
  0xC0, 0x0F, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0xFF,
  0xE0, 0x7F, 0x0F, 0xFF, 0x81, 0xFC, 0x7F, 0xFE, 0x07, 0xF3, 0xFF, 0xF8,
  0x1F, 0xDF, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x3E,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x02, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xCF, 0xE0, 0xFF,
  0xFE, 0x7F, 0x81, 0xFF, 0xF1, 0xFE, 0x03, 0xFF, 0x87, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x07, 0xE0, 0x7E,
  0x3F, 0x03, 0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0x83,
  0xF0, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F, 0x0F, 0xF8, 0x7F, 0x0F, 0xC3, 0xFE,
  0x1F, 0x83, 0xF1, 0xF7, 0xC7, 0xE0, 0xFC, 0x7D, 0xF3, 0xF0, 0x3F, 0x3E,
  0x7C, 0xFC, 0x0F, 0xCF, 0x9F, 0x3F, 0x03, 0xF7, 0xC7, 0xDF, 0x80, 0xFD,
  0xF1, 0xF7, 0xE0, 0x3E, 0xF8, 0x7D, 0xF8, 0x0F, 0xBE, 0x1F, 0x7C, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x05, 0xFF,
  0xFF, 0xC0, 0x73, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xBC, 0x07, 0xFF, 0xFF, 0x40, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xC0,
};

const GFXglyph LiberationMono_BoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 16, 38, 35, 10, -38 },
  { 77, 23, 18, 35, 10, -42 },
  { 129, 35, 38, 35, 1, -38 },
  { 296, 33, 48, 35, 1, -43 },
  { 494, 39, 40, 35, -1, -39 },
  { 689, 34, 39, 35, -1, -38 },
  { 855, 10, 18, 35, 16, -42 },
  { 878, 22, 54, 35, 9, -42 },
  { 1027, 23, 54, 35, 3, -42 },
  { 1183, 23, 22, 35, 9, -42 },
  { 1247, 29, 30, 35, 3, -34 },
  { 1356, 18, 19, 35, 2, -8 },
  { 1399, 18, 7, 35, 8, -19 },
  { 1415, 10, 9, 35, 10, -9 },
  { 1427, 38, 43, 35, -1, -42 },
  { 1632, 30, 40, 35, 3, -39 },
  { 1782, 30, 38, 35, 1, -38 },
  { 1925, 33, 39, 35, 1, -39 },
  { 2086, 32, 40, 35, 2, -39 },
  { 2246, 32, 38, 35, 1, -38 },
  { 2398, 32, 39, 35, 2, -38 },
  { 2554, 29, 40, 35, 4, -39 },
  { 2699, 28, 38, 35, 7, -38 },
  { 2832, 32, 40, 35, 2, -39 },
  { 2992, 30, 40, 35, 3, -39 },
  { 3142, 15, 31, 35, 10, -31 },
  { 3201, 21, 42, 35, 4, -31 },
  { 3312, 29, 31, 35, 3, -35 },
  { 3425, 29, 22, 35, 3, -30 },
  { 3505, 29, 31, 35, 3, -35 },
  { 3618, 30, 39, 35, 4, -39 },
  { 3765, 36, 50, 35, 0, -42 },
  { 3990, 35, 38, 35, -3, -38 },
  { 4157, 33, 38, 35, 1, -38 },
  { 4314, 33, 40, 35, 2, -39 },
  { 4479, 33, 38, 35, 1, -38 },
  { 4636, 35, 38, 35, 1, -38 },
  { 4803, 34, 38, 35, 2, -38 },
  { 4965, 32, 40, 35, 2, -39 },
  { 5125, 34, 38, 35, 1, -38 },
  { 5287, 34, 38, 35, 1, -38 },
  { 5449, 31, 39, 35, 2, -38 },
  { 5601, 38, 38, 35, 1, -38 },
  { 5782, 27, 38, 35, 3, -38 },
  { 5911, 36, 38, 35, 0, -38 },
  { 6082, 34, 38, 35, 1, -38 },
  { 6244, 32, 40, 35, 2, -39 },
  { 6404, 34, 38, 35, 1, -38 },
  { 6566, 32, 50, 35, 2, -39 },
  { 6766, 34, 38, 35, 1, -38 },
  { 6928, 35, 40, 35, 0, -39 },
  { 7103, 33, 38, 35, 5, -38 },
  { 7260, 33, 39, 35, 3, -38 },
  { 7421, 34, 38, 35, 5, -38 },
  { 7583, 36, 38, 35, 3, -38 },
  { 7754, 41, 38, 35, -3, -38 },
  { 7949, 34, 38, 35, 5, -38 },
  { 8111, 37, 38, 35, -1, -38 },
  { 8287, 28, 54, 35, 5, -42 },
  { 8476, 21, 43, 35, 8, -42 },
  { 8589, 27, 54, 35, 2, -42 },
  { 8772, 31, 25, 35, 1, -40 },
  { 8869, 35, 3, 35, -4, 4 },
  { 8883, 13, 8, 35, 15, -42 },
  { 8896, 30, 33, 35, 1, -32 },
  { 9020, 32, 43, 35, 1, -42 },
  { 9192, 29, 33, 35, 3, -32 },
  { 9312, 34, 43, 35, 2, -42 },
  { 9495, 30, 33, 35, 2, -32 },
  { 9619, 32, 43, 35, 5, -43 },
  { 9791, 34, 44, 35, 1, -32 },
  { 9978, 32, 42, 35, 1, -42 },
  { 10146, 31, 42, 35, 0, -42 },
  { 10309, 32, 54, 35, -2, -42 },
  { 10525, 33, 42, 35, 2, -42 },
  { 10699, 31, 42, 35, 0, -42 },
  { 10862, 35, 32, 35, -1, -32 },
  { 11002, 32, 32, 35, 1, -32 },
  { 11130, 31, 33, 35, 2, -32 },
  { 11258, 34, 44, 35, -1, -32 },
  { 11445, 32, 44, 35, 2, -32 },
  { 11621, 30, 32, 35, 4, -32 },
  { 11741, 30, 33, 35, 2, -32 },
  { 11865, 25, 40, 35, 6, -39 },
  { 11990, 30, 32, 35, 3, -31 },
  { 12110, 33, 31, 35, 4, -31 },
  { 12238, 34, 31, 35, 3, -31 },
  { 12370, 38, 31, 35, -2, -31 },
  { 12518, 38, 43, 35, -1, -31 },
  { 12723, 31, 31, 35, 1, -31 },
  { 12844, 30, 54, 35, 5, -42 },
  { 13047, 7, 55, 35, 14, -42 },
  { 13096, 30, 54, 35, 0, -42 },
  { 13299, 31, 9, 35, 3, -24 },
};

const GFXfont LiberationMono_BoldItalic58pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic58pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic58pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _LIBERATIONMONO_BOLDITALIC58PT7B_H_
