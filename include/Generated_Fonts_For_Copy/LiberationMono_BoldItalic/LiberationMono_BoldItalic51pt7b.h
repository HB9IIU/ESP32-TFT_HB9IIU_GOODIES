#ifndef _LIBERATIONMONO_BOLDITALIC51PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x07, 0xF3, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0xEF, 0xF8, 0x3F, 0x87,
  0x1F, 0xC1, 0xF8, 0x30, 0xFE, 0x1F, 0xC3, 0x87, 0xF0, 0xFE, 0x1C, 0x30,
  0x07, 0xF0, 0xE0, 0x00, 0x3F, 0x87, 0x00, 0x01, 0xFE, 0x30, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x1F, 0xE0, 0x00, 0x38, 0x7F, 0x00,
  0x01, 0x81, 0xF8, 0x0C, 0x1C, 0x0F, 0xCF, 0xE0, 0xE0, 0xFE, 0x7F, 0x07,
  0x07, 0xF3, 0xF8, 0x38, 0x3F, 0x1F, 0xE1, 0x83, 0xF8, 0x7F, 0x9C, 0x7F,
  0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x3F, 0xF8, 0x00, 0xF8, 0x1F,
  0x1F, 0x00, 0x7C, 0x07, 0x87, 0xC0, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x00,
  0xF0, 0x7C, 0x07, 0x80, 0x3C, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC1, 0xF0,
  0x07, 0xC1, 0xE0, 0xF8, 0x01, 0xE0, 0x78, 0x7C, 0x00, 0x78, 0x3E, 0x3E,
  0x00, 0x1F, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0xC7, 0x80, 0x00, 0xFF, 0xE3,
  0xC0, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x07, 0x8F, 0xFC, 0x00, 0x03, 0xC7, 0xFF, 0x00, 0x01, 0xE3, 0xE3, 0xE0,
  0x00, 0xF0, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x3E, 0x00, 0x3E, 0x1E, 0x0F,
  0x80, 0x1F, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xC0, 0xF8,
  0x3C, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x03,
  0xE1, 0xE0, 0x3C, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x1F, 0xFC, 0x0F, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0xF8, 0xFE, 0x00, 0x07, 0xDF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xE0, 0x3F, 0xF8, 0x0F,
  0x83, 0xFF, 0xC0, 0x7C, 0x3F, 0xBF, 0x07, 0xC3, 0xF9, 0xF8, 0x3E, 0x3F,
  0x8F, 0xE3, 0xE1, 0xF8, 0x3F, 0x3F, 0x1F, 0x81, 0xFD, 0xF0, 0xFC, 0x07,
  0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x3F, 0x00, 0xFF, 0x81, 0xF8, 0x03, 0xFC,
  0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xF0, 0xFF, 0xF8, 0x7F, 0x81, 0xFE,
  0x00, 0xFC, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xC7, 0x8E, 0x3F,
  0xFB, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFB, 0xE0, 0x3F, 0x3F, 0x07, 0xE3, 0xF8,
  0x7C, 0x1F, 0x03, 0xC1, 0xC0, 0x08, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xFB, 0xFD, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0x87, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x7C, 0x7F, 0x7F, 0x1F, 0x1F, 0xDF, 0xCF,
  0xCF, 0xEF, 0xE3, 0xF3, 0xFB, 0xF8, 0xF8, 0xFE, 0xFE, 0x3E, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xF7, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xF8, 0xFF, 0x00, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x83,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1E, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x03, 0xF3, 0xFF, 0xC1,
  0xFD, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF3, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xE0,
  0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF,
  0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xE1, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF1, 0xFE, 0x01, 0xFE,
  0x3F, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x0F, 0xE0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xF9,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0x01,
  0xFF, 0xCF, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x03, 0xE0, 0x38, 0x3C, 0x1F,
  0xCF, 0x70, 0x70, 0x7F, 0xDC, 0xE1, 0xE1, 0xF1, 0xF9, 0xC3, 0x87, 0x83,
  0xF3, 0x8F, 0x1E, 0x07, 0xC7, 0x1E, 0x3C, 0x0F, 0x8E, 0x38, 0xF0, 0x1E,
  0x3C, 0xF1, 0xE0, 0x3C, 0x79, 0xE7, 0x80, 0xF8, 0xE3, 0x8F, 0x01, 0xE1,
  0xC7, 0x3C, 0x03, 0xC3, 0x9E, 0x78, 0x0F, 0x0F, 0x38, 0xF0, 0x1E, 0x1C,
  0x71, 0xE0, 0x38, 0x38, 0xE7, 0x80, 0xF0, 0xE1, 0xCF, 0x01, 0xE1, 0xC7,
  0x9E, 0x07, 0x87, 0x8F, 0x3C, 0x1F, 0x0E, 0x1E, 0x78, 0x3E, 0x38, 0x3C,
  0xF9, 0xDC, 0xF0, 0x78, 0xFF, 0x3F, 0xC0, 0xF1, 0xFC, 0x7F, 0x01, 0xE1,
  0xF0, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7,
  0xF0, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8,
  0x01, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xC0, 0xFE,
  0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xFF,
  0xE7, 0xF0, 0x7F, 0xFE, 0x7F, 0x07, 0xFF, 0xEF, 0xF0, 0x7F, 0xFC, 0xFF,
  0x07, 0xFF, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01,
  0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xF8, 0xFF, 0x00, 0x3F, 0x8F,
  0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0,
  0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF8, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F,
  0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xFC,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xDE, 0x07,
  0xFE, 0x07, 0xDF, 0x0F, 0xFE, 0x07, 0xDF, 0x0F, 0x7C, 0x07, 0xDF, 0x1F,
  0x7C, 0x0F, 0xDF, 0x1F, 0x7C, 0x0F, 0xDF, 0x3E, 0xFC, 0x0F, 0x9F, 0x3E,
  0xFC, 0x0F, 0x9F, 0x3C, 0xF8, 0x0F, 0x9F, 0x7C, 0xF8, 0x1F, 0x9F, 0x78,
  0xF8, 0x1F, 0x9F, 0xF9, 0xF8, 0x1F, 0x9F, 0xF9, 0xF8, 0x1F, 0x1F, 0xF1,
  0xF8, 0x1F, 0x1F, 0xF1, 0xF0, 0x3F, 0x1F, 0xE1, 0xF0, 0x3F, 0x0F, 0xE3,
  0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0xC0, 0x03, 0xFE, 0x00, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0xFF, 0x80, 0x7F, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xFC, 0x07, 0xE0,
  0x7F, 0xF0, 0x3F, 0x81, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x3F,
  0x7C, 0x0F, 0xC0, 0xFD, 0xF8, 0x3F, 0x03, 0xF7, 0xE0, 0xFC, 0x0F, 0xDF,
  0x87, 0xF0, 0x3F, 0x7E, 0x1F, 0xC1, 0xFD, 0xF8, 0x7E, 0x07, 0xF3, 0xE1,
  0xF8, 0x1F, 0xCF, 0xC7, 0xE0, 0x7E, 0x3F, 0x3F, 0x81, 0xF8, 0xFC, 0xFE,
  0x07, 0xE3, 0xF3, 0xF0, 0x3F, 0x87, 0xCF, 0xC0, 0xFE, 0x1F, 0xBF, 0x03,
  0xF0, 0x7E, 0xFC, 0x0F, 0xC1, 0xFB, 0xF0, 0x3F, 0x07, 0xEF, 0x81, 0xFC,
  0x1F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x1F, 0x80, 0xFF, 0xE0, 0x7E, 0x03,
  0xFF, 0x81, 0xF8, 0x0F, 0xFE, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F, 0x80, 0x7F,
  0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x01,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF3,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xCF, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F,
  0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00,
  0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x87, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3,
  0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFE, 0x7F, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x3E, 0x0F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF0, 0x7E, 0x3F, 0xC7, 0xE0, 0xFC, 0x7F, 0x8F, 0xC1, 0xF9, 0xFF, 0x9F,
  0x03, 0xF3, 0xFF, 0x7E, 0x07, 0xEF, 0xBE, 0xFC, 0x0F, 0xDF, 0x7D, 0xF0,
  0x1F, 0xFC, 0xFB, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7D, 0xF3, 0xFF, 0x00,
  0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x3F,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x87, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xCF, 0xF9,
  0xFF, 0xF1, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0xFE, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF1, 0xFF,
  0x80, 0x7F, 0x3F, 0xFC, 0x07, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFE, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF1,
  0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC,
  0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xE7, 0xFF, 0x80, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x7F, 0x80,
  0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x0F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x3F,
  0xF3, 0xF8, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE3, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF0,
  0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07,
  0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xFC,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xBF, 0x80, 0x7F, 0xF9, 0xFC, 0x01, 0xFF, 0x8F, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0x87, 0xF8, 0x07, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x0F, 0xC0,
  0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xBF, 0x83, 0xFE,
  0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3,
  0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0x80, 0xFF,
  0xF9, 0xFC, 0x03, 0xFF, 0x9F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xC0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x07, 0xF1, 0xFF, 0xC0, 0x7F, 0x3F, 0xFE, 0x07, 0xF7, 0xFF, 0xE0,
  0xFE, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x1F, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xC0, 0xF8, 0x0F, 0x9F, 0xC3, 0xF8, 0x1F, 0x7F, 0xCF,
  0xF8, 0x3E, 0xFF, 0xBF, 0xF0, 0x7F, 0x3F, 0xE7, 0xE0, 0xFC, 0x3F, 0x8F,
  0xC3, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x83, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F,
  0x83, 0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F,
  0x83, 0xF0, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0x87, 0xE0, 0xFC,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x1F, 0xFC, 0x07, 0xF3, 0xFF,
  0xC0, 0x7E, 0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF1,
  0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0x00, 0x7F, 0x7F, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFE, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xE0, 0x0F,
  0xE3, 0xFF, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF8, 0x7F, 0x03, 0xFF, 0xCF, 0xE0, 0x7F, 0xFE, 0xFE, 0x07,
  0xFF, 0xEF, 0xE0, 0xFF, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0xC1, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7,
  0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xEF, 0xE0, 0x3F, 0xFC, 0xFE, 0x01, 0xFF, 0x8F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x7F, 0xE0, 0xFC, 0x7F, 0xF8,
  0x3F, 0x3F, 0xFE, 0x0F, 0xCF, 0xFF, 0x83, 0xF7, 0xFF, 0xE1, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC3, 0xFC, 0x0F, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3C, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xF3,
  0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x21, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xF0, 0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0xF7,
  0xF0, 0x7F, 0xFC, 0xFE, 0x0F, 0xFF, 0x1F, 0xC0, 0xFF, 0xC3, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x07, 0xC0, 0xF8,
  0x7C, 0x1F, 0x83, 0xF0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0xFE, 0x0F, 0x83,
  0xE1, 0xFE, 0x3F, 0x07, 0xC7, 0xFC, 0x7C, 0x0F, 0x8F, 0xF8, 0xF8, 0x1F,
  0x3E, 0xF3, 0xF0, 0x7E, 0x79, 0xE7, 0xC0, 0xFD, 0xF3, 0xCF, 0x81, 0xFB,
  0xC7, 0xBF, 0x03, 0xEF, 0x8F, 0x7C, 0x07, 0xDE, 0x1E, 0xF8, 0x0F, 0xFC,
  0x3D, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x80,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x02, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 34, 31, 9, -34 },
  { 61, 20, 16, 31, 9, -37 },
  { 101, 30, 34, 31, 1, -34 },
  { 229, 29, 42, 31, 1, -38 },
  { 382, 34, 36, 31, -1, -35 },
  { 535, 29, 35, 31, 0, -34 },
  { 662, 9, 16, 31, 14, -37 },
  { 680, 20, 48, 31, 8, -37 },
  { 800, 20, 48, 31, 3, -37 },
  { 920, 20, 19, 31, 8, -37 },
  { 968, 25, 26, 31, 3, -30 },
  { 1050, 15, 16, 31, 2, -7 },
  { 1080, 16, 6, 31, 7, -16 },
  { 1092, 9, 8, 31, 9, -8 },
  { 1101, 34, 38, 31, -1, -37 },
  { 1263, 26, 36, 31, 3, -35 },
  { 1380, 26, 34, 31, 1, -34 },
  { 1491, 29, 35, 31, 0, -35 },
  { 1618, 29, 36, 31, 1, -35 },
  { 1749, 28, 34, 31, 1, -34 },
  { 1868, 28, 35, 31, 2, -34 },
  { 1991, 26, 36, 31, 3, -35 },
  { 2108, 25, 34, 31, 6, -34 },
  { 2215, 27, 36, 31, 2, -35 },
  { 2337, 27, 36, 31, 2, -35 },
  { 2459, 13, 27, 31, 9, -27 },
  { 2503, 18, 36, 31, 4, -27 },
  { 2584, 25, 27, 31, 3, -30 },
  { 2669, 25, 20, 31, 3, -27 },
  { 2732, 25, 27, 31, 3, -30 },
  { 2817, 26, 35, 31, 4, -35 },
  { 2931, 31, 44, 31, 0, -37 },
  { 3102, 31, 34, 31, -3, -34 },
  { 3234, 29, 34, 31, 1, -34 },
  { 3358, 29, 36, 31, 2, -35 },
  { 3489, 29, 34, 31, 1, -34 },
  { 3613, 30, 34, 31, 1, -34 },
  { 3741, 29, 34, 31, 2, -34 },
  { 3865, 28, 36, 31, 2, -35 },
  { 3991, 30, 34, 31, 1, -34 },
  { 4119, 30, 34, 31, 1, -34 },
  { 4247, 27, 35, 31, 2, -34 },
  { 4366, 33, 34, 31, 1, -34 },
  { 4507, 23, 34, 31, 3, -34 },
  { 4605, 32, 34, 31, 0, -34 },
  { 4741, 30, 34, 31, 1, -34 },
  { 4869, 28, 36, 31, 2, -35 },
  { 4995, 30, 34, 31, 1, -34 },
  { 5123, 28, 45, 31, 2, -35 },
  { 5281, 30, 34, 31, 1, -34 },
  { 5409, 30, 36, 31, 0, -35 },
  { 5544, 29, 34, 31, 4, -34 },
  { 5668, 28, 35, 31, 3, -34 },
  { 5791, 30, 34, 31, 4, -34 },
  { 5919, 31, 34, 31, 3, -34 },
  { 6051, 37, 34, 31, -3, -34 },
  { 6209, 30, 34, 31, 4, -34 },
  { 6337, 31, 34, 31, 0, -34 },
  { 6469, 24, 48, 31, 5, -37 },
  { 6613, 19, 38, 31, 7, -37 },
  { 6704, 24, 48, 31, 2, -37 },
  { 6848, 28, 22, 31, 1, -35 },
  { 6925, 32, 2, 31, -4, 3 },
  { 6933, 12, 7, 31, 13, -36 },
  { 6944, 27, 29, 31, 1, -28 },
  { 7042, 28, 38, 31, 1, -37 },
  { 7175, 26, 29, 31, 2, -28 },
  { 7270, 29, 38, 31, 2, -37 },
  { 7408, 26, 29, 31, 2, -28 },
  { 7503, 28, 38, 31, 5, -38 },
  { 7636, 29, 39, 31, 1, -28 },
  { 7778, 28, 37, 31, 1, -37 },
  { 7908, 27, 37, 31, 0, -37 },
  { 8033, 28, 48, 31, -2, -37 },
  { 8201, 29, 37, 31, 2, -37 },
  { 8336, 27, 37, 31, 0, -37 },
  { 8461, 31, 28, 31, -1, -28 },
  { 8570, 28, 28, 31, 1, -28 },
  { 8668, 27, 29, 31, 2, -28 },
  { 8766, 30, 39, 31, -1, -28 },
  { 8913, 28, 39, 31, 2, -28 },
  { 9050, 26, 28, 31, 4, -28 },
  { 9141, 26, 29, 31, 2, -28 },
  { 9236, 21, 35, 31, 6, -34 },
  { 9328, 27, 28, 31, 2, -27 },
  { 9423, 29, 27, 31, 3, -27 },
  { 9521, 31, 27, 31, 2, -27 },
  { 9626, 32, 27, 31, -1, -27 },
  { 9734, 33, 38, 31, -1, -27 },
  { 9891, 27, 27, 31, 1, -27 },
  { 9983, 27, 48, 31, 4, -37 },
  { 10145, 7, 48, 31, 12, -37 },
  { 10187, 26, 48, 31, 0, -37 },
  { 10343, 28, 8, 31, 2, -21 },
};

const GFXfont LiberationMono_BoldItalic51pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic51pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic51pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _LIBERATIONMONO_BOLDITALIC51PT7B_H_
