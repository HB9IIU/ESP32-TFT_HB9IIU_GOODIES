#ifndef _LIBERATIONMONO_BOLDITALIC17PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x07, 0x38, 0x6F, 0x9B, 0x36, 0x6C,
  0x80, 0x04, 0x43, 0x20, 0x89, 0xFF, 0x11, 0x04, 0x43, 0x23, 0xFE, 0x66,
  0x11, 0x04, 0xC0, 0x02, 0x03, 0xE3, 0xFC, 0xCB, 0x34, 0x0F, 0x01, 0xF8,
  0x1E, 0x29, 0xBA, 0x67, 0xF8, 0xF8, 0x08, 0x00, 0x38, 0x6D, 0x99, 0x36,
  0x25, 0x87, 0x60, 0x08, 0x02, 0xF0, 0xB6, 0x26, 0xC8, 0x9B, 0x1E, 0x00,
  0x0F, 0x07, 0xE1, 0x98, 0x6C, 0x1E, 0x0E, 0x26, 0xDB, 0x34, 0xC7, 0x3F,
  0xE7, 0x98, 0xFB, 0x6C, 0x1C, 0x63, 0x1C, 0x61, 0x8C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x18, 0x1C, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x86, 0x0C,
  0x18, 0x70, 0xC3, 0x86, 0x1C, 0x70, 0x10, 0x4F, 0xCC, 0xDB, 0x60, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x31, 0x98, 0xCC, 0x40, 0x7D,
  0xE0, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x00, 0x1F, 0x1F, 0x9C, 0xEC,
  0x7E, 0xBF, 0xDB, 0x0D, 0x8E, 0xC6, 0x7F, 0x1E, 0x00, 0x07, 0x07, 0x8F,
  0xC6, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x3F, 0xFF, 0xE0, 0x0F, 0x87,
  0xF3, 0x9C, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x3F, 0xEF, 0xF0,
  0x0F, 0x87, 0xF3, 0x1C, 0x06, 0x0F, 0x03, 0xC0, 0x38, 0x06, 0x63, 0x9F,
  0xC3, 0xE0, 0x03, 0x81, 0xE0, 0x78, 0x36, 0x1B, 0x8C, 0xC6, 0x33, 0xFF,
  0xFF, 0x81, 0xC0, 0x60, 0x3F, 0xBF, 0xD8, 0x0F, 0xC7, 0xF7, 0x18, 0x0C,
  0x06, 0xC7, 0x7F, 0x1E, 0x00, 0x1F, 0x1F, 0xDC, 0xEC, 0x0E, 0xE7, 0xFB,
  0x8D, 0x86, 0xE7, 0x3F, 0x1F, 0x00, 0xFF, 0xFF, 0x06, 0x0E, 0x1C, 0x18,
  0x30, 0x70, 0x60, 0xE0, 0xC0, 0x1F, 0x1F, 0xDC, 0xEC, 0x67, 0xE3, 0xF3,
  0x8D, 0x86, 0xC7, 0x7F, 0x1F, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x3B,
  0xF9, 0xEC, 0x0E, 0xC6, 0x7E, 0x1E, 0x00, 0x33, 0x70, 0x00, 0xEE, 0xE0,
  0x0C, 0x31, 0xC0, 0x00, 0x00, 0x06, 0x30, 0xC6, 0x18, 0xC0, 0x01, 0x0F,
  0x3E, 0xF0, 0x80, 0xF0, 0x3E, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xF0, 0x3E, 0x0F, 0x01, 0x0F, 0x3E, 0xF0, 0x80, 0x1F,
  0x3F, 0xD8, 0xFC, 0x30, 0x30, 0x70, 0x70, 0x70, 0x00, 0x18, 0x0C, 0x00,
  0x07, 0x86, 0x31, 0x04, 0x9B, 0x69, 0x54, 0x55, 0x36, 0xC9, 0xA2, 0xA9,
  0xAB, 0xB3, 0x00, 0x43, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x36, 0x0D,
  0x86, 0x71, 0xFC, 0xFF, 0x70, 0xD8, 0x3E, 0x0C, 0x3F, 0x8F, 0xF3, 0x1C,
  0xC7, 0x3F, 0x9F, 0xE7, 0x1D, 0x87, 0x61, 0x9F, 0xEF, 0xE0, 0x1F, 0x1F,
  0xDC, 0xFC, 0x2E, 0x06, 0x03, 0x01, 0x87, 0xE7, 0x7F, 0x1F, 0x00, 0x3F,
  0x0F, 0xE3, 0x1C, 0xC7, 0x31, 0xDC, 0x77, 0x19, 0x86, 0x63, 0x9F, 0xCF,
  0xC0, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x3F, 0x9F, 0xE7, 0x01, 0x80, 0x60,
  0x1F, 0xEF, 0xF8, 0x3F, 0xBF, 0xDC, 0x0C, 0x06, 0x03, 0xFB, 0xFD, 0xC0,
  0xC0, 0x60, 0x30, 0x00, 0x1F, 0x1F, 0x9C, 0xFC, 0x4E, 0x06, 0x7F, 0x3D,
  0x86, 0xE3, 0x7F, 0x9F, 0x00, 0x38, 0xCE, 0x33, 0x1C, 0xC7, 0x3F, 0x9F,
  0xE7, 0x19, 0x8E, 0x63, 0x98, 0xCE, 0x30, 0x1F, 0xCF, 0xF0, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x1F, 0xC7, 0xF0, 0x0F, 0x87, 0x80,
  0xC0, 0x60, 0x70, 0x38, 0x19, 0x8C, 0xCE, 0x7E, 0x1E, 0x00, 0x38, 0xE7,
  0x38, 0xCE, 0x1B, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0x38, 0x67, 0x0C, 0x73,
  0x8E, 0x00, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xFF,
  0xFF, 0x38, 0xE7, 0x38, 0xA7, 0x35, 0xE6, 0xAC, 0xDD, 0x9B, 0x22, 0x6C,
  0xC1, 0x98, 0x33, 0x06, 0x00, 0x38, 0xCF, 0x33, 0xCC, 0xF3, 0x3D, 0x9B,
  0x66, 0xD9, 0x9E, 0x67, 0x99, 0xEC, 0x70, 0x1F, 0x1F, 0xDC, 0xFC, 0x3E,
  0x1E, 0x1F, 0x0F, 0x86, 0xC7, 0x7F, 0x1F, 0x00, 0x3F, 0x8F, 0xF3, 0x0C,
  0xC3, 0x31, 0xDF, 0xE7, 0xF1, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x1F, 0x1F,
  0xDC, 0xFC, 0x3E, 0x1E, 0x1F, 0x0F, 0x86, 0xC7, 0x7F, 0x1F, 0x07, 0x01,
  0xE0, 0xF0, 0x3F, 0x8F, 0xF3, 0x0C, 0xC3, 0x31, 0xDF, 0xE7, 0xE1, 0x9C,
  0x63, 0x18, 0xEE, 0x38, 0x0F, 0x8F, 0xF3, 0x1C, 0xC0, 0x3C, 0x07, 0xE0,
  0x38, 0x06, 0xE1, 0x9F, 0xE3, 0xE0, 0x7F, 0xDF, 0xF0, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x71, 0xB8, 0xD8, 0xEC,
  0x7E, 0x3F, 0x1B, 0x8D, 0x8E, 0xC6, 0x7F, 0x1F, 0x00, 0xE0, 0xD8, 0x76,
  0x19, 0x8E, 0x63, 0x19, 0x87, 0x61, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xC0,
  0xD8, 0x1B, 0x03, 0x66, 0xCD, 0xD9, 0xBB, 0x3F, 0xC7, 0xF8, 0xEE, 0x1D,
  0xC3, 0x38, 0x00, 0x18, 0x71, 0xCE, 0x0C, 0xC0, 0xF8, 0x07, 0x00, 0x70,
  0x0F, 0x01, 0xF8, 0x39, 0x87, 0x1C, 0x60, 0xC0, 0x60, 0xD8, 0x67, 0x30,
  0xDC, 0x36, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0xCF,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x3F, 0xEF, 0xF8,
  0x1F, 0x3E, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0,
  0xC0, 0xC0, 0xF8, 0xF8, 0xC0, 0xC1, 0x81, 0x03, 0x06, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0x1F, 0x3E, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0xF8, 0xF8, 0x07, 0x03, 0xC1, 0xB0, 0x66,
  0x31, 0x98, 0x66, 0x18, 0xFF, 0xC0, 0x63, 0x0F, 0x1F, 0xCC, 0xE0, 0x73,
  0xF3, 0x19, 0x9D, 0xF7, 0x73, 0x80, 0x18, 0x0E, 0x03, 0x80, 0xDE, 0x3F,
  0x8E, 0x77, 0x1D, 0xC6, 0x61, 0x9C, 0xE7, 0xF3, 0xB8, 0x1E, 0x7F, 0x63,
  0xE0, 0xC0, 0xC0, 0xC7, 0xFE, 0x7C, 0x01, 0x80, 0x60, 0x18, 0xEE, 0x7F,
  0xB8, 0xCE, 0x33, 0x0C, 0xC7, 0x31, 0xCF, 0xE1, 0xD8, 0x1E, 0x7F, 0x63,
  0xFF, 0xFF, 0xC0, 0xC2, 0xFE, 0x7C, 0x0F, 0x9F, 0xCC, 0x1F, 0xEF, 0xF1,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x1E, 0xCF, 0xB3, 0x9D,
  0xC6, 0x61, 0x98, 0x67, 0x39, 0xFE, 0x3B, 0x00, 0xCE, 0x71, 0xF8, 0x7C,
  0x00, 0x18, 0x0E, 0x03, 0x80, 0xDE, 0x3F, 0x8E, 0x77, 0x19, 0xC6, 0x61,
  0x98, 0xE6, 0x3B, 0x8C, 0x03, 0x01, 0x80, 0x03, 0xC3, 0xE0, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x3F, 0xFF, 0xF0, 0x01, 0xC0, 0x60, 0x00, 0x3E, 0x0F,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x87,
  0xC1, 0xE0, 0x30, 0x18, 0x1C, 0x0E, 0x76, 0x73, 0x71, 0xF1, 0xF8, 0xEC,
  0x67, 0x31, 0x98, 0xE0, 0x1F, 0x0F, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x3F, 0xFF, 0xF0, 0x6D, 0xDF, 0xF6, 0x6D, 0xB3, 0x6C,
  0xF3, 0x2C, 0xDB, 0x26, 0xD9, 0x80, 0x37, 0x8F, 0xE3, 0x9D, 0xC6, 0x71,
  0x98, 0x66, 0x39, 0x8E, 0xE3, 0x00, 0x1E, 0x3F, 0xB8, 0xFC, 0x7C, 0x36,
  0x1B, 0x1D, 0xFC, 0x7C, 0x00, 0x33, 0x8D, 0xE3, 0x9D, 0xC7, 0x71, 0x98,
  0x67, 0x39, 0xFC, 0x6E, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x39, 0xBF,
  0xF8, 0xDC, 0x6C, 0x36, 0x3B, 0x1D, 0xFC, 0xF6, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x37, 0x9F, 0xDE, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x00,
  0x3E, 0x7F, 0x63, 0x78, 0x7E, 0x07, 0xC3, 0xFE, 0x7C, 0x10, 0x63, 0xFF,
  0xF6, 0x0C, 0x18, 0x30, 0xE1, 0xF9, 0xF0, 0x63, 0xB1, 0xD8, 0xDC, 0x6C,
  0x36, 0x3B, 0x1D, 0xFC, 0xF6, 0x00, 0xE1, 0xB8, 0x66, 0x31, 0x9C, 0x66,
  0x1B, 0x86, 0xC1, 0xE0, 0x38, 0x00, 0xC0, 0xF0, 0x2C, 0x9B, 0x76, 0xDD,
  0x3B, 0xCA, 0xF3, 0x38, 0xC6, 0x00, 0x30, 0xCE, 0x61, 0xB0, 0x78, 0x0E,
  0x07, 0x83, 0x71, 0x8C, 0xC3, 0x80, 0x70, 0xC6, 0x18, 0xC6, 0x18, 0xC3,
  0x30, 0x66, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x78, 0x0E, 0x00,
  0x3F, 0x9F, 0xC0, 0xC0, 0xC0, 0xC1, 0xC1, 0xC0, 0xFE, 0xFF, 0x00, 0x07,
  0x87, 0xC3, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0xE0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x0F, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0F, 0x07, 0x87, 0x03, 0x01, 0x80, 0xC0,
  0xE3, 0xE1, 0xE0, 0x78, 0xFF, 0xE3, 0xC0,
};

const GFXglyph LiberationMono_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 11, 10, 3, -11 },
  { 8, 7, 5, 10, 3, -12 },
  { 13, 10, 11, 10, 0, -11 },
  { 27, 10, 13, 10, 0, -12 },
  { 44, 11, 11, 10, 0, -11 },
  { 60, 10, 11, 10, 0, -11 },
  { 74, 3, 5, 10, 5, -12 },
  { 76, 6, 16, 10, 3, -12 },
  { 88, 7, 16, 10, 1, -12 },
  { 102, 6, 6, 10, 3, -12 },
  { 107, 8, 8, 10, 1, -10 },
  { 115, 5, 6, 10, 1, -2 },
  { 119, 6, 2, 10, 2, -5 },
  { 121, 3, 3, 10, 3, -3 },
  { 123, 11, 12, 10, 0, -12 },
  { 140, 9, 11, 10, 1, -11 },
  { 153, 9, 11, 10, 0, -11 },
  { 166, 10, 11, 10, 0, -11 },
  { 180, 10, 11, 10, 0, -11 },
  { 194, 10, 11, 10, 0, -11 },
  { 208, 9, 11, 10, 1, -11 },
  { 221, 9, 11, 10, 1, -11 },
  { 234, 8, 11, 10, 2, -11 },
  { 245, 9, 11, 10, 1, -11 },
  { 258, 9, 11, 10, 1, -11 },
  { 271, 4, 9, 10, 3, -9 },
  { 276, 6, 13, 10, 1, -9 },
  { 286, 8, 9, 10, 1, -10 },
  { 295, 8, 7, 10, 1, -9 },
  { 302, 8, 9, 10, 1, -10 },
  { 311, 9, 11, 10, 1, -11 },
  { 324, 10, 14, 10, 0, -12 },
  { 342, 10, 11, 10, -1, -11 },
  { 356, 10, 11, 10, 0, -11 },
  { 370, 9, 11, 10, 1, -11 },
  { 383, 10, 11, 10, 0, -11 },
  { 397, 10, 11, 10, 0, -11 },
  { 411, 9, 11, 10, 1, -11 },
  { 424, 9, 11, 10, 1, -11 },
  { 437, 10, 11, 10, 0, -11 },
  { 451, 10, 11, 10, 0, -11 },
  { 465, 9, 11, 10, 1, -11 },
  { 478, 11, 11, 10, 0, -11 },
  { 494, 8, 11, 10, 1, -11 },
  { 505, 11, 11, 10, 0, -11 },
  { 521, 10, 11, 10, 0, -11 },
  { 535, 9, 11, 10, 1, -11 },
  { 548, 10, 11, 10, 0, -11 },
  { 562, 9, 14, 10, 1, -11 },
  { 578, 10, 11, 10, 0, -11 },
  { 592, 10, 11, 10, 0, -11 },
  { 606, 10, 11, 10, 1, -11 },
  { 620, 9, 11, 10, 1, -11 },
  { 633, 10, 11, 10, 1, -11 },
  { 647, 11, 11, 10, 1, -11 },
  { 663, 12, 11, 10, -1, -11 },
  { 680, 10, 11, 10, 1, -11 },
  { 694, 10, 11, 10, 0, -11 },
  { 708, 8, 16, 10, 2, -12 },
  { 724, 7, 12, 10, 2, -12 },
  { 735, 8, 16, 10, 1, -12 },
  { 751, 10, 7, 10, 0, -12 },
  { 760, 10, 1, 10, -1, 1 },
  { 762, 4, 2, 10, 4, -12 },
  { 763, 9, 9, 10, 0, -9 },
  { 774, 10, 12, 10, 0, -12 },
  { 789, 8, 9, 10, 1, -9 },
  { 798, 10, 12, 10, 1, -12 },
  { 813, 8, 9, 10, 1, -9 },
  { 822, 9, 12, 10, 2, -12 },
  { 836, 10, 13, 10, 0, -9 },
  { 853, 10, 12, 10, 0, -12 },
  { 868, 9, 12, 10, 0, -12 },
  { 882, 10, 16, 10, -1, -12 },
  { 902, 9, 12, 10, 1, -12 },
  { 916, 9, 12, 10, 0, -12 },
  { 930, 10, 9, 10, 0, -9 },
  { 942, 10, 9, 10, 0, -9 },
  { 954, 9, 9, 10, 1, -9 },
  { 965, 10, 13, 10, 0, -9 },
  { 982, 9, 13, 10, 1, -9 },
  { 997, 9, 9, 10, 1, -9 },
  { 1008, 8, 9, 10, 1, -9 },
  { 1017, 7, 11, 10, 2, -11 },
  { 1027, 9, 9, 10, 1, -9 },
  { 1038, 10, 9, 10, 1, -9 },
  { 1050, 10, 9, 10, 1, -9 },
  { 1062, 10, 9, 10, 0, -9 },
  { 1074, 11, 13, 10, 0, -9 },
  { 1092, 9, 9, 10, 0, -9 },
  { 1103, 9, 16, 10, 1, -12 },
  { 1121, 2, 16, 10, 4, -12 },
  { 1125, 9, 16, 10, 0, -12 },
  { 1143, 9, 3, 10, 1, -7 },
};

const GFXfont LiberationMono_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic17pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _LIBERATIONMONO_BOLDITALIC17PT7B_H_
