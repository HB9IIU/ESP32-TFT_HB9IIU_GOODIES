#ifndef _LIBERATIONMONO_BOLDITALIC19PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0x06, 0x18, 0xE0, 0x67,
  0x66, 0x66, 0x66, 0xC6, 0xC4, 0x06, 0x20, 0x46, 0x04, 0x40, 0xC4, 0x3F,
  0xF1, 0x88, 0x11, 0x81, 0x10, 0xFF, 0xC2, 0x20, 0x62, 0x04, 0x60, 0x44,
  0x00, 0x01, 0x01, 0xF8, 0x7F, 0x9D, 0x73, 0x24, 0x74, 0x0F, 0xC0, 0xFE,
  0x07, 0xC0, 0x9F, 0x93, 0x72, 0xE7, 0xF8, 0x7E, 0x02, 0x00, 0x40, 0x3C,
  0x36, 0x46, 0x64, 0x44, 0xC8, 0x4D, 0x07, 0xB0, 0x06, 0x00, 0xDE, 0x1B,
  0x61, 0x26, 0x22, 0x66, 0x24, 0xC3, 0xC0, 0x07, 0x81, 0xF8, 0x73, 0x0C,
  0x61, 0xB8, 0x3C, 0x0F, 0x1B, 0x66, 0xCE, 0xD8, 0xF3, 0x0E, 0x7F, 0xF7,
  0xCC, 0x76, 0x66, 0x6C, 0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x30, 0xE1,
  0xC3, 0x86, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xE0, 0x0C, 0x0E, 0x06, 0x06,
  0x06, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38,
  0x70, 0x60, 0x18, 0x31, 0xFB, 0xF3, 0x8D, 0x92, 0x00, 0x0C, 0x06, 0x03,
  0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x39, 0x9C, 0xCC,
  0x60, 0xFB, 0xE0, 0x76, 0xE0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x0F, 0x07, 0xE3, 0x1D, 0xC7, 0x61, 0xDB, 0x7E, 0xDF, 0x86,
  0xE3, 0xB8, 0xEE, 0x71, 0xF8, 0x3C, 0x00, 0x03, 0x81, 0xE3, 0xF8, 0xCC,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE1, 0xFF, 0xFF, 0xC0,
  0x07, 0xC3, 0xFC, 0x63, 0x9C, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0x8F, 0xF7, 0x1C, 0xC7, 0x01,
  0x83, 0xC1, 0xF0, 0x0E, 0x01, 0xB0, 0xEE, 0x3B, 0xFC, 0x7C, 0x00, 0x01,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0xDC, 0x33, 0x0C, 0x63, 0x0C, 0xFF, 0xFF,
  0xF8, 0x0E, 0x01, 0x80, 0x30, 0x3F, 0xCF, 0xF3, 0x01, 0xC0, 0x7F, 0x1F,
  0xE6, 0x38, 0x06, 0x01, 0xB0, 0xEE, 0x73, 0xFC, 0x7C, 0x00, 0x0F, 0x87,
  0xF3, 0x9D, 0xC0, 0x70, 0x1B, 0xCF, 0xFB, 0xCE, 0xE1, 0xB8, 0xEE, 0x39,
  0xFC, 0x3C, 0x00, 0x7F, 0xBF, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x0F, 0x8F, 0xF7, 0x1D,
  0xC7, 0x71, 0x8F, 0xC3, 0xF3, 0x8E, 0xE3, 0xB0, 0xEE, 0x3B, 0xFC, 0x7C,
  0x00, 0x0F, 0x0F, 0xE7, 0x1D, 0xC7, 0x61, 0xDC, 0xF7, 0xFC, 0xF6, 0x03,
  0x80, 0xEE, 0x73, 0xF8, 0x7C, 0x00, 0x39, 0xCE, 0x00, 0x00, 0x0E, 0x67,
  0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x60, 0xC3, 0x04,
  0x00, 0x00, 0x81, 0xC7, 0xEF, 0xCF, 0x06, 0x03, 0xC0, 0xFC, 0x1F, 0x81,
  0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x78,
  0x3F, 0x03, 0xE0, 0x78, 0x04, 0x1E, 0x3E, 0xFC, 0x70, 0x20, 0x00, 0x0F,
  0x8F, 0xF7, 0x1D, 0x87, 0x01, 0xC0, 0xE0, 0xF0, 0x70, 0x18, 0x00, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0xC6, 0x18, 0x21, 0x03, 0x27, 0x72,
  0xDF, 0x49, 0xA5, 0x9A, 0x51, 0x2F, 0x12, 0xB3, 0x4B, 0x64, 0x9B, 0x8C,
  0x00, 0x40, 0x06, 0x30, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0x60,
  0xEC, 0x19, 0x87, 0x38, 0xC7, 0x3F, 0xE7, 0xFD, 0xC3, 0xB0, 0x3E, 0x06,
  0x1F, 0xC7, 0xFC, 0xE3, 0x9C, 0x73, 0x8E, 0x7F, 0x0F, 0xF3, 0x87, 0x70,
  0xEE, 0x1D, 0xC7, 0x3F, 0xEF, 0xF0, 0x0F, 0x8F, 0xF3, 0x9D, 0xC3, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x6E, 0x39, 0xFC, 0x3C, 0x00, 0x1F,
  0x87, 0xF8, 0xE7, 0x9C, 0x73, 0x8E, 0x61, 0xDC, 0x3B, 0x87, 0x70, 0xCE,
  0x39, 0xCE, 0x3F, 0x8F, 0xE0, 0x1F, 0xF3, 0xFE, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xFC, 0x3F, 0xC7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFC, 0xFF,
  0xC0, 0x3F, 0xE7, 0xF8, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xE3, 0xFC,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x0F, 0x8F, 0xE7, 0x9D, 0xC7,
  0x60, 0x38, 0x0E, 0x7F, 0xBF, 0xE1, 0xB8, 0x6E, 0x39, 0xFC, 0x3C, 0x00,
  0x18, 0x63, 0x86, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFE, 0x3F, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x61, 0xC6, 0x18, 0xE3, 0x80, 0x1F, 0xE3, 0xFC, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x3F,
  0xC7, 0xF8, 0x0F, 0xC3, 0xF0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x03, 0x31, 0xCE, 0x73, 0xF8, 0x7C, 0x00, 0x18, 0x71, 0xC7, 0x0E, 0x70,
  0x77, 0x03, 0x70, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x73, 0x83, 0x9C, 0x1C,
  0xE0, 0xC3, 0x8E, 0x1C, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1F, 0xFF, 0xF8, 0x3C, 0x73, 0xCF, 0x3C,
  0xA3, 0xDE, 0x3D, 0xE6, 0xD6, 0x6F, 0x66, 0xE6, 0x6E, 0xC6, 0xEC, 0xC0,
  0xCC, 0x0C, 0xC0, 0xC0, 0x1C, 0x73, 0xC6, 0x3C, 0x63, 0xC6, 0x3E, 0xE3,
  0x6E, 0x76, 0xC7, 0x6C, 0x76, 0xC6, 0x7C, 0x63, 0xC6, 0x38, 0xE3, 0x80,
  0x0F, 0x0F, 0xF7, 0x1D, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xB8,
  0xEE, 0x73, 0xFC, 0x7C, 0x00, 0x1F, 0xC7, 0xFC, 0xE3, 0x9C, 0x33, 0x8E,
  0x61, 0xDF, 0xF3, 0xF8, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x0F,
  0x0F, 0xF7, 0x1D, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xB8, 0xEE,
  0x7B, 0xFC, 0x7C, 0x06, 0x01, 0xC0, 0x7C, 0x0F, 0x00, 0x1F, 0xC3, 0xFE,
  0x38, 0xF3, 0x87, 0x38, 0x63, 0x0E, 0x3F, 0xC7, 0xF0, 0x73, 0x87, 0x38,
  0x73, 0x86, 0x1C, 0xE1, 0xC0, 0x0F, 0xC3, 0xFC, 0xE3, 0x98, 0x23, 0x80,
  0x7E, 0x07, 0xF0, 0x1E, 0x00, 0xFC, 0x1B, 0x87, 0x3F, 0xC3, 0xF0, 0xFF,
  0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x00, 0x30, 0xEE, 0x19, 0xC7, 0x38, 0xE7, 0x1C, 0xC3,
  0xB8, 0x67, 0x0C, 0xE3, 0x9C, 0x73, 0x9C, 0x7F, 0x07, 0xC0, 0x60, 0x76,
  0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x03, 0x70, 0x36, 0x03,
  0x60, 0x3C, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x0E,
  0xEC, 0xCE, 0xEC, 0xDE, 0xCD, 0xF8, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70,
  0xE7, 0x00, 0x1C, 0x38, 0x63, 0x83, 0x98, 0x1D, 0xC0, 0x7C, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0D, 0x80, 0xEE, 0x0E, 0x30, 0xE1, 0xCE, 0x0E, 0x00,
  0x70, 0x67, 0x0E, 0x71, 0xC3, 0x38, 0x3B, 0x01, 0xF0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xFC, 0x7C,
  0x00, 0xC1, 0x83, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60, 0x60,
  0xC1, 0x80, 0x1F, 0x8F, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0xF8, 0x7C, 0x00, 0x07,
  0x80, 0xF0, 0x36, 0x0C, 0xC1, 0x8C, 0x61, 0x98, 0x33, 0x06, 0xFF, 0xE0,
  0xE6, 0x30, 0x0F, 0x87, 0xF3, 0x9C, 0x07, 0x1F, 0xDC, 0x66, 0x3B, 0x8E,
  0x7D, 0xDE, 0x70, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0xBC, 0x7F, 0x8E,
  0x39, 0x87, 0x70, 0xEE, 0x19, 0xC7, 0x38, 0xE7, 0xF9, 0xDE, 0x00, 0x1F,
  0x0F, 0xE7, 0x1B, 0x80, 0xE0, 0x38, 0x0E, 0x3B, 0x8C, 0xFF, 0x1F, 0x00,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE1, 0xDC, 0xFF, 0x9C, 0xE7, 0x0C, 0xE1,
  0x9C, 0x73, 0x0E, 0x73, 0xCF, 0xF0, 0xE6, 0x00, 0x1F, 0x0F, 0xE7, 0x1B,
  0x87, 0xFF, 0xFF, 0xEC, 0x03, 0x8E, 0xFF, 0x1F, 0x00, 0x07, 0xC7, 0xF1,
  0xC0, 0x60, 0xFF, 0xBF, 0xE3, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x00, 0x0E, 0x63, 0xFC, 0xE7, 0x98, 0x77, 0x0C, 0xE1, 0x9C,
  0x73, 0x9E, 0x7F, 0xC7, 0xB0, 0x0E, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x1C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0xBC, 0x7F, 0xCE, 0x39, 0x87, 0x70, 0xCE,
  0x19, 0xC7, 0x30, 0xE6, 0x1D, 0xC3, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x7E,
  0x1F, 0x00, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x1C, 0xE7, 0x1D, 0xC3,
  0x70, 0x7E, 0x1F, 0xC3, 0x98, 0x73, 0x8E, 0x71, 0x87, 0x00, 0x0F, 0x83,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0xFF, 0xFF, 0xF0, 0x2E, 0xEF, 0xFD, 0xDD, 0xB3, 0x36, 0x66, 0xCC,
  0xFB, 0x36, 0x66, 0xCC, 0xD9, 0x98, 0x3B, 0xC7, 0xFC, 0xE3, 0x98, 0x77,
  0x0C, 0xE1, 0x9C, 0x73, 0x0E, 0x61, 0xDC, 0x30, 0x1F, 0x0F, 0xE7, 0x1F,
  0x87, 0xE1, 0xF0, 0x6C, 0x3B, 0x8E, 0xFF, 0x1F, 0x00, 0x3B, 0xC7, 0xF8,
  0xE3, 0x98, 0x77, 0x0E, 0xE1, 0x9C, 0x73, 0x8E, 0x7F, 0x9D, 0xE3, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x00, 0x1D, 0xDF, 0xF7, 0x3F, 0x86, 0xE1, 0xB8,
  0xEC, 0x3B, 0x9E, 0xFF, 0x1C, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x33,
  0xCD, 0xF3, 0xC0, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00,
  0x1F, 0x0F, 0xE6, 0x19, 0xC0, 0x7F, 0x07, 0xE0, 0x3B, 0x0E, 0xFF, 0x1F,
  0x80, 0x18, 0x18, 0x38, 0xFF, 0xFF, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60,
  0x7E, 0x7E, 0x71, 0xDC, 0x76, 0x19, 0x86, 0xE3, 0xB8, 0xEE, 0x3B, 0x9C,
  0xFB, 0x1C, 0xC0, 0xE0, 0xEC, 0x39, 0x87, 0x39, 0xC7, 0x30, 0xEE, 0x1D,
  0x81, 0xF0, 0x3C, 0x07, 0x00, 0xC0, 0x78, 0x0F, 0x33, 0x66, 0x6D, 0xCD,
  0xAB, 0x3D, 0xE7, 0x38, 0xE7, 0x18, 0xE0, 0x1C, 0x70, 0xE3, 0x03, 0xB0,
  0x0F, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x03, 0x38, 0x39, 0xC3, 0x87, 0x00,
  0x70, 0x73, 0x0E, 0x38, 0xE3, 0x9C, 0x39, 0x81, 0xB8, 0x1B, 0x01, 0xF0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x1F, 0xC7, 0xF8,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x7F, 0x9F, 0xF0, 0x0F,
  0x87, 0xC7, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0xF0, 0x70, 0x1C, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x7C, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x07, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x03, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0xFC,
  0x3E, 0x00, 0x78, 0x7F, 0xF8, 0x78,
};

const GFXglyph LiberationMono_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 13, 11, 3, -13 },
  { 11, 8, 6, 11, 3, -14 },
  { 17, 12, 13, 11, 0, -13 },
  { 37, 11, 16, 11, 0, -14 },
  { 59, 12, 13, 11, 0, -13 },
  { 79, 11, 13, 11, 0, -13 },
  { 97, 4, 6, 11, 5, -14 },
  { 100, 7, 18, 11, 3, -14 },
  { 116, 8, 18, 11, 1, -14 },
  { 134, 7, 7, 11, 3, -14 },
  { 141, 9, 10, 11, 1, -11 },
  { 153, 5, 6, 11, 1, -3 },
  { 157, 6, 2, 11, 3, -6 },
  { 159, 4, 3, 11, 3, -3 },
  { 161, 12, 14, 11, 0, -14 },
  { 182, 10, 13, 11, 1, -13 },
  { 199, 10, 13, 11, 0, -13 },
  { 216, 11, 13, 11, 0, -13 },
  { 234, 10, 13, 11, 1, -13 },
  { 251, 11, 13, 11, 0, -13 },
  { 269, 10, 13, 11, 1, -13 },
  { 286, 10, 13, 11, 1, -13 },
  { 303, 10, 13, 11, 2, -13 },
  { 320, 10, 13, 11, 1, -13 },
  { 337, 10, 13, 11, 1, -13 },
  { 354, 5, 10, 11, 3, -10 },
  { 361, 7, 13, 11, 1, -10 },
  { 373, 9, 11, 11, 1, -12 },
  { 386, 9, 7, 11, 1, -10 },
  { 394, 9, 11, 11, 1, -12 },
  { 407, 10, 13, 11, 1, -13 },
  { 424, 12, 17, 11, 0, -14 },
  { 450, 11, 13, 11, -1, -13 },
  { 468, 11, 13, 11, 0, -13 },
  { 486, 10, 13, 11, 1, -13 },
  { 503, 11, 13, 11, 0, -13 },
  { 521, 12, 13, 11, 0, -13 },
  { 541, 11, 13, 11, 1, -13 },
  { 559, 10, 13, 11, 1, -13 },
  { 576, 12, 13, 11, 0, -13 },
  { 596, 11, 13, 11, 0, -13 },
  { 614, 10, 13, 11, 1, -13 },
  { 631, 13, 13, 11, 0, -13 },
  { 653, 9, 13, 11, 1, -13 },
  { 668, 12, 13, 11, 0, -13 },
  { 688, 12, 13, 11, 0, -13 },
  { 708, 10, 13, 11, 1, -13 },
  { 725, 11, 13, 11, 0, -13 },
  { 743, 10, 17, 11, 1, -13 },
  { 765, 12, 13, 11, 0, -13 },
  { 785, 11, 13, 11, 0, -13 },
  { 803, 10, 13, 11, 2, -13 },
  { 820, 11, 13, 11, 1, -13 },
  { 838, 12, 13, 11, 1, -13 },
  { 858, 12, 13, 11, 1, -13 },
  { 878, 13, 13, 11, -1, -13 },
  { 900, 12, 13, 11, 1, -13 },
  { 920, 12, 13, 11, 0, -13 },
  { 940, 9, 18, 11, 2, -14 },
  { 961, 7, 14, 11, 3, -14 },
  { 974, 9, 18, 11, 1, -14 },
  { 995, 11, 8, 11, 0, -13 },
  { 1006, 11, 1, 11, -1, 1 },
  { 1008, 4, 3, 11, 5, -14 },
  { 1010, 10, 10, 11, 0, -10 },
  { 1023, 11, 14, 11, 0, -14 },
  { 1043, 10, 10, 11, 1, -10 },
  { 1056, 11, 14, 11, 1, -14 },
  { 1076, 10, 10, 11, 1, -10 },
  { 1089, 10, 14, 11, 2, -14 },
  { 1107, 11, 14, 11, 0, -10 },
  { 1127, 11, 14, 11, 0, -14 },
  { 1147, 10, 14, 11, 0, -14 },
  { 1165, 11, 18, 11, -1, -14 },
  { 1190, 11, 14, 11, 1, -14 },
  { 1210, 10, 14, 11, 0, -14 },
  { 1228, 11, 10, 11, 0, -10 },
  { 1242, 11, 10, 11, 0, -10 },
  { 1256, 10, 10, 11, 1, -10 },
  { 1269, 11, 14, 11, 0, -10 },
  { 1289, 10, 14, 11, 1, -10 },
  { 1307, 10, 10, 11, 1, -10 },
  { 1320, 10, 10, 11, 1, -10 },
  { 1333, 8, 13, 11, 2, -13 },
  { 1346, 10, 10, 11, 1, -10 },
  { 1359, 11, 10, 11, 1, -10 },
  { 1373, 11, 10, 11, 1, -10 },
  { 1387, 13, 10, 11, -1, -10 },
  { 1404, 12, 14, 11, 0, -10 },
  { 1425, 11, 10, 11, 0, -10 },
  { 1439, 9, 18, 11, 2, -14 },
  { 1460, 3, 18, 11, 4, -14 },
  { 1467, 10, 18, 11, 0, -14 },
  { 1490, 10, 3, 11, 1, -8 },
};

const GFXfont LiberationMono_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic19pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _LIBERATIONMONO_BOLDITALIC19PT7B_H_
