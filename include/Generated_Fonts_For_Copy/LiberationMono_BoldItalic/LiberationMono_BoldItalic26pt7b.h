#ifndef _LIBERATIONMONO_BOLDITALIC26PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x80,
  0x00, 0x3C, 0x78, 0xE0, 0x79, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xE3,
  0x18, 0xE7, 0x1C, 0x01, 0x86, 0x01, 0x86, 0x01, 0x86, 0x03, 0x0C, 0x03,
  0x0C, 0x3F, 0xFF, 0x3F, 0xFF, 0x06, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x18,
  0x60, 0x7F, 0xFC, 0xFF, 0xFC, 0x30, 0xC0, 0x30, 0xC0, 0x61, 0x80, 0x61,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0x07, 0xFF, 0x3F, 0xFC, 0xF2, 0xF3,
  0x99, 0xCE, 0x60, 0x3F, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x02, 0x78,
  0x08, 0xEE, 0x23, 0xBD, 0x9E, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x01, 0x00,
  0x0C, 0x00, 0x07, 0x81, 0x87, 0xE0, 0xE1, 0x9C, 0x70, 0xE7, 0x38, 0x31,
  0x8C, 0x0C, 0x66, 0x03, 0xBB, 0x00, 0xFD, 0x80, 0x1E, 0xDE, 0x00, 0x6F,
  0xC0, 0x37, 0x30, 0x1D, 0x8C, 0x0E, 0x63, 0x03, 0x18, 0xC1, 0x86, 0x60,
  0xC1, 0xF8, 0x60, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x1C, 0x60, 0x30,
  0xC0, 0xE3, 0x81, 0xCE, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x0C, 0xFE, 0x39,
  0xCE, 0x77, 0x1F, 0xCE, 0x1F, 0x1C, 0x1E, 0x3C, 0x7C, 0x7F, 0xFF, 0x3E,
  0x1C, 0x7B, 0xDC, 0xE7, 0x33, 0x9C, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC1, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x03, 0xC0, 0x06, 0x01, 0x84, 0xE5, 0xFF, 0xFF,
  0xC7, 0x83, 0xF1, 0xDC, 0xF3, 0x88, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x60,
  0xE0, 0xFF, 0xFE, 0xFE, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x8F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE,
  0xEF, 0x73, 0xB9, 0xCC, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF1, 0xC3, 0xC7,
  0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0xC3,
  0xDE, 0x18, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x01, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F,
  0x38, 0x3C, 0x00, 0xF0, 0x07, 0x81, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x07,
  0x80, 0x1E, 0xE0, 0x7B, 0xC3, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x77, 0x01, 0xCE,
  0x07, 0x1C, 0x1C, 0x78, 0x70, 0xF1, 0xC1, 0xC3, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFF, 0x80, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xCF, 0x00, 0x3C, 0x00, 0xEF, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0xFE, 0x1F, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF7, 0x84, 0x38, 0x03, 0xCF,
  0x1F, 0xFC, 0xFF, 0xF7, 0x87, 0xB8, 0x3D, 0xC1, 0xEE, 0x0F, 0x78, 0xF3,
  0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0x87, 0xFC, 0x0F,
  0xC0, 0xFF, 0xC7, 0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0xFF, 0x1F,
  0xF8, 0x3F, 0x80, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x3D,
  0xE0, 0xF7, 0x83, 0xDE, 0x1F, 0x7F, 0xF8, 0xFE, 0xE1, 0xF7, 0x80, 0x1C,
  0x30, 0xF3, 0xC7, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x3C, 0xF3, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0xF3, 0x80, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC3, 0xC1, 0xC0,
  0xE0, 0xE0, 0x60, 0x60, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x7E, 0x0F, 0xE3,
  0xFC, 0x7F, 0x83, 0xE0, 0x1C, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x07, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x03,
  0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xC0, 0x78, 0x02, 0x00, 0x00,
  0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0xF0, 0xFF, 0x03, 0xB8, 0x3C, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x07,
  0x0C, 0x03, 0x18, 0xEF, 0x31, 0xEB, 0x33, 0x3B, 0x26, 0x33, 0x6E, 0x33,
  0x6C, 0x32, 0x4C, 0x66, 0x58, 0x66, 0xD8, 0x66, 0xD8, 0xCC, 0xD9, 0xCC,
  0xDF, 0x78, 0xCE, 0x70, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x70, 0x3F, 0xC0,
  0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B, 0xC0,
  0x73, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x7F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x0F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xF8, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x0F, 0x1F,
  0xFC, 0x3F, 0xE0, 0x7F, 0xF8, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x07,
  0x9F, 0xFF, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xF1, 0xE3, 0xC1, 0xEF, 0x02, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x81, 0xCF, 0x07, 0x9F, 0x1E, 0x1F, 0xFC, 0x3F, 0xE0,
  0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x73, 0xC1,
  0xE7, 0x87, 0x8F, 0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C,
  0x3D, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xBC,
  0x0E, 0xF0, 0x7B, 0xE1, 0xE7, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x0E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0x1E,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x3C, 0x78, 0x3C, 0x78, 0x38,
  0x78, 0x78, 0x78, 0x78, 0x70, 0x78, 0x70, 0x78, 0x1F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x1C,
  0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x0E, 0x0F,
  0x8F, 0x0F, 0x87, 0x8F, 0x83, 0xCF, 0x81, 0xCF, 0x80, 0xEF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0xF8, 0xF0, 0x3C, 0x00, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xF7, 0xFF, 0xFF,
  0xF0, 0x1F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F, 0x36, 0x3F,
  0x7E, 0x3B, 0x6E, 0x3B, 0xEE, 0x33, 0xCE, 0x73, 0xCE, 0x73, 0xDC, 0x73,
  0x9C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0x0F,
  0x07, 0x1F, 0x0F, 0x1F, 0x0E, 0x1F, 0x8E, 0x1F, 0x8E, 0x1F, 0x8E, 0x3F,
  0x9E, 0x3B, 0x9C, 0x39, 0xDC, 0x39, 0xDC, 0x39, 0xDC, 0x79, 0xDC, 0x79,
  0xF8, 0x70, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0xF0, 0xF8, 0x03, 0xF0, 0x3F,
  0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E, 0xF0, 0x7B, 0xE3, 0xC7, 0xFE, 0x1F,
  0xF0, 0x1F, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x1E,
  0x0F, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xE0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D, 0xE0, 0xF7,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF0, 0x7B,
  0xE3, 0xCF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x1F,
  0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x70, 0x7C,
  0xF0, 0x3C, 0x01, 0xF8, 0x0F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF3, 0xC0, 0xE7,
  0x80, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF0, 0x00,
  0xFF, 0x01, 0xDF, 0x07, 0x9F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0x71,
  0xE0, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0xF0,
  0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x1F, 0xF8, 0x3F, 0xE0,
  0x3F, 0x00, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x70, 0x3C, 0x70, 0x78,
  0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xC0, 0x3B, 0xC0,
  0x3B, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x9C,
  0x71, 0xCE, 0x70, 0xEF, 0x38, 0x77, 0x9C, 0x3F, 0xFC, 0x1B, 0xFE, 0x0F,
  0xBF, 0x0F, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0xF0, 0x1E, 0x78, 0x03, 0x9C,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x0F, 0x03, 0xC3, 0xC1, 0xE0,
  0x78, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x78, 0x78,
  0x38, 0xF0, 0x3C, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8,
  0x07, 0xF8, 0x3F, 0x81, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xFC, 0x1F, 0xE0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0xFF, 0x0F, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x76, 0x03, 0x9C, 0x0E, 0x70,
  0x71, 0xC3, 0x83, 0x0E, 0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0x80, 0xFF,
  0xFF, 0xE1, 0xC1, 0x80, 0x07, 0xE0, 0xFF, 0x8F, 0x1C, 0x70, 0xF0, 0x07,
  0x80, 0x38, 0x7F, 0xCF, 0xFE, 0xF8, 0xF7, 0x87, 0xB8, 0x79, 0xE7, 0xCF,
  0xEF, 0xBE, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xDF, 0x07, 0x7F, 0x0F, 0x9E, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x79,
  0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x7C, 0x78, 0xEF,
  0xE1, 0xCF, 0x00, 0x07, 0xE0, 0x7F, 0x8F, 0x1E, 0x70, 0x77, 0x83, 0xBC,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFC, 0x3C, 0xF1, 0xC7, 0xFC,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC1,
  0xF7, 0x87, 0xFF, 0x1E, 0x3E, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF0, 0xFD, 0xE0,
  0xF3, 0xC0, 0x07, 0xE0, 0xFF, 0x8F, 0x1E, 0x70, 0x77, 0x83, 0xB8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x1C, 0xF1, 0xE7, 0xFC, 0x0F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xFF,
  0x3F, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x03, 0xCE, 0x1F, 0xDC, 0x78, 0xF8, 0xF0, 0xF3, 0xC1, 0xE7, 0x83,
  0x8E, 0x07, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xE1, 0xE7, 0xC3,
  0xFF, 0x83, 0xCF, 0x00, 0x1E, 0x78, 0x38, 0x78, 0xF0, 0xFF, 0xC0, 0x7E,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xCF,
  0x07, 0x7F, 0x0F, 0xFF, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xE0, 0xE3,
  0x83, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0xE0, 0xF1, 0xC1,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC1,
  0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x87, 0x8F, 0x1E, 0x1E, 0x78, 0x39, 0xE0, 0x77, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x78, 0x1C, 0x78, 0x38, 0xF0, 0xF0,
  0xE1, 0xE1, 0xE3, 0xC3, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0x3B, 0x9E, 0x7F, 0xFC, 0xE7, 0xB9, 0xCE, 0x77, 0x1C,
  0xEE, 0x39, 0xDC, 0xE3, 0xB9, 0xC7, 0x73, 0x9D, 0xC7, 0x3B, 0x8E, 0x77,
  0x38, 0xEE, 0x71, 0xDC, 0xE3, 0x00, 0x1C, 0x78, 0x3B, 0xF8, 0x7F, 0xF1,
  0xF8, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0xF0,
  0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x07, 0x8E, 0x0F, 0x00, 0x07, 0xE0, 0x7F,
  0xE3, 0xC7, 0x9E, 0x0F, 0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x0F, 0x3C, 0x38, 0x7F, 0xC0, 0x7C, 0x00, 0x0F, 0x7C,
  0x0E, 0xFE, 0x0F, 0x9E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E,
  0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x3E, 0x3C, 0x3B, 0xF8,
  0x39, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x0F, 0xBC, 0x7F, 0xF3, 0xC7, 0xDE, 0x1E, 0x78, 0x79, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0x7E, 0xF0, 0xF3,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x38, 0xF9,
  0xCF, 0xCE, 0xFE, 0x7E, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x07, 0xE0, 0xFF,
  0xCF, 0x0E, 0x70, 0x73, 0x80, 0x1F, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xF8,
  0x03, 0xF8, 0x1D, 0xE1, 0xE7, 0xFE, 0x1F, 0xC0, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x0F, 0xFF, 0xFF, 0xCE, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0x87, 0xF0, 0x3C, 0x3C, 0xE0,
  0xF3, 0x83, 0xDE, 0x0E, 0x78, 0x39, 0xE1, 0xE7, 0x07, 0x9C, 0x1E, 0xF0,
  0x73, 0xC3, 0xCF, 0x1F, 0x3F, 0xFC, 0x7E, 0xF1, 0xF3, 0x80, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0x70, 0xF1, 0xC3, 0x87, 0x1E, 0x1E, 0x70,
  0x7B, 0xC1, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE3, 0x8E, 0xE3, 0x9C, 0xE7, 0x9C, 0xE7,
  0x98, 0xED, 0xB8, 0xED, 0xB8, 0xF9, 0xB0, 0xF9, 0xB0, 0xF1, 0xF0, 0xF1,
  0xE0, 0xE0, 0xE0, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xC7, 0x80, 0xF7, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xB8,
  0x07, 0x9E, 0x03, 0x87, 0x03, 0x83, 0xC3, 0xC0, 0xE0, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x83, 0xC1, 0xC1, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x3C, 0xF0,
  0x1E, 0x70, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F,
  0xF9, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x1E, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x83, 0xFC, 0x1F, 0x80, 0x3F, 0x05,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7E,
};

const GFXglyph LiberationMono_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 17, 16, 5, -17 },
  { 16, 11, 8, 16, 4, -19 },
  { 27, 16, 17, 16, 0, -17 },
  { 61, 14, 21, 16, 1, -19 },
  { 98, 18, 17, 16, -1, -17 },
  { 137, 15, 17, 16, 0, -17 },
  { 169, 5, 8, 16, 7, -19 },
  { 174, 10, 24, 16, 4, -19 },
  { 204, 10, 24, 16, 2, -19 },
  { 234, 10, 10, 16, 4, -19 },
  { 247, 13, 13, 16, 1, -15 },
  { 269, 8, 8, 16, 1, -4 },
  { 277, 8, 3, 16, 4, -8 },
  { 280, 4, 4, 16, 5, -4 },
  { 282, 17, 19, 16, 0, -19 },
  { 323, 14, 17, 16, 1, -17 },
  { 353, 13, 17, 16, 1, -17 },
  { 381, 15, 17, 16, 0, -17 },
  { 413, 14, 17, 16, 1, -17 },
  { 443, 15, 17, 16, 0, -17 },
  { 475, 14, 17, 16, 1, -17 },
  { 505, 13, 17, 16, 2, -17 },
  { 533, 13, 17, 16, 3, -17 },
  { 561, 14, 17, 16, 1, -17 },
  { 591, 14, 17, 16, 1, -17 },
  { 621, 6, 14, 16, 5, -14 },
  { 632, 9, 18, 16, 2, -14 },
  { 653, 13, 15, 16, 1, -16 },
  { 678, 13, 10, 16, 1, -14 },
  { 695, 13, 15, 16, 1, -16 },
  { 720, 13, 17, 16, 2, -17 },
  { 748, 16, 23, 16, 0, -19 },
  { 794, 15, 17, 16, -1, -17 },
  { 826, 15, 17, 16, 0, -17 },
  { 858, 15, 17, 16, 1, -17 },
  { 890, 15, 17, 16, 0, -17 },
  { 922, 16, 17, 16, 0, -17 },
  { 956, 15, 17, 16, 1, -17 },
  { 988, 14, 17, 16, 1, -17 },
  { 1018, 16, 17, 16, 0, -17 },
  { 1052, 15, 17, 16, 1, -17 },
  { 1084, 14, 17, 16, 1, -17 },
  { 1114, 17, 17, 16, 0, -17 },
  { 1151, 12, 17, 16, 1, -17 },
  { 1177, 16, 17, 16, 0, -17 },
  { 1211, 16, 17, 16, 0, -17 },
  { 1245, 14, 17, 16, 1, -17 },
  { 1275, 16, 17, 16, 0, -17 },
  { 1309, 14, 22, 16, 1, -17 },
  { 1348, 16, 17, 16, 0, -17 },
  { 1382, 15, 17, 16, 0, -17 },
  { 1414, 15, 17, 16, 2, -17 },
  { 1446, 15, 17, 16, 1, -17 },
  { 1478, 16, 17, 16, 2, -17 },
  { 1512, 17, 17, 16, 1, -17 },
  { 1549, 18, 17, 16, -1, -17 },
  { 1588, 16, 17, 16, 2, -17 },
  { 1622, 16, 17, 16, 0, -17 },
  { 1656, 13, 24, 16, 2, -19 },
  { 1695, 10, 19, 16, 3, -19 },
  { 1719, 12, 24, 16, 1, -19 },
  { 1755, 14, 11, 16, 1, -18 },
  { 1775, 16, 1, 16, -2, 2 },
  { 1777, 6, 3, 16, 7, -18 },
  { 1780, 13, 14, 16, 1, -14 },
  { 1803, 15, 19, 16, 0, -19 },
  { 1839, 13, 14, 16, 1, -14 },
  { 1862, 15, 19, 16, 1, -19 },
  { 1898, 13, 14, 16, 1, -14 },
  { 1921, 15, 19, 16, 2, -19 },
  { 1957, 15, 19, 16, 0, -14 },
  { 1993, 15, 19, 16, 0, -19 },
  { 2029, 14, 19, 16, 0, -19 },
  { 2063, 14, 24, 16, -1, -19 },
  { 2105, 15, 19, 16, 1, -19 },
  { 2141, 14, 19, 16, 0, -19 },
  { 2175, 15, 14, 16, 0, -14 },
  { 2202, 15, 14, 16, 0, -14 },
  { 2229, 14, 14, 16, 1, -14 },
  { 2254, 16, 19, 16, -1, -14 },
  { 2292, 14, 19, 16, 1, -14 },
  { 2326, 13, 14, 16, 2, -14 },
  { 2349, 13, 14, 16, 1, -14 },
  { 2372, 11, 18, 16, 3, -18 },
  { 2397, 14, 14, 16, 1, -14 },
  { 2422, 14, 14, 16, 2, -14 },
  { 2447, 16, 14, 16, 1, -14 },
  { 2475, 17, 14, 16, -1, -14 },
  { 2505, 17, 19, 16, -1, -14 },
  { 2546, 14, 14, 16, 0, -14 },
  { 2571, 14, 24, 16, 2, -19 },
  { 2613, 3, 25, 16, 6, -19 },
  { 2623, 13, 24, 16, 0, -19 },
  { 2662, 14, 4, 16, 1, -11 },
};

const GFXfont LiberationMono_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic26pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _LIBERATIONMONO_BOLDITALIC26PT7B_H_
