#ifndef _LIBERATIONMONO_BOLDITALIC22PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x70, 0x00, 0x38, 0xE3, 0x80,
  0x67, 0x73, 0xB9, 0xDC, 0xEC, 0x66, 0x33, 0x18, 0x03, 0x18, 0x18, 0x81,
  0x8C, 0x0C, 0x63, 0xFF, 0x9F, 0xFC, 0x31, 0x83, 0x18, 0x18, 0xC7, 0xFF,
  0xBF, 0xFC, 0x62, 0x06, 0x30, 0x21, 0x00, 0x00, 0x80, 0x3F, 0x07, 0xFC,
  0x3A, 0x73, 0x93, 0x9C, 0x80, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x17, 0x88,
  0x9D, 0xC4, 0xE7, 0x6E, 0x3F, 0xF0, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x1E,
  0x0C, 0xD8, 0x66, 0x63, 0x19, 0x98, 0x66, 0xC1, 0x96, 0x03, 0xB0, 0x01,
  0xBC, 0x05, 0x98, 0x36, 0x61, 0x99, 0x8C, 0xC4, 0x61, 0xB3, 0x07, 0x80,
  0x03, 0xC0, 0x7E, 0x0E, 0x60, 0xC6, 0x0C, 0xC0, 0xF8, 0x1E, 0x37, 0xE3,
  0x67, 0x6E, 0x7E, 0xC3, 0xCE, 0x3C, 0xFF, 0xF7, 0xC7, 0x77, 0x66, 0x6E,
  0xC0, 0x07, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03,
  0x80, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x00, 0x1C, 0x18, 0xDB, 0xFF, 0x38, 0x6C, 0xEE, 0x48, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C,
  0xE3, 0x9C, 0x61, 0x8C, 0x00, 0x7F, 0xFC, 0xFE, 0xE0, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0x07, 0xC1, 0xFE, 0x38, 0xE3, 0x87, 0x70, 0x77, 0x6E, 0x76, 0xEE,
  0x6E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCF, 0x38, 0x7F, 0x03, 0xE0, 0x01, 0xC0,
  0x7C, 0x1F, 0xC3, 0x9C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x7F, 0xE7, 0xFE, 0x03, 0xE0, 0x7F, 0x87, 0x1E,
  0x38, 0x70, 0x07, 0x00, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xC1, 0xFE, 0x38, 0xF7, 0x07,
  0x00, 0xE0, 0x0E, 0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x0E, 0xE0, 0xEE, 0x1C,
  0xFF, 0x83, 0xF0, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x37, 0x06, 0xE0, 0xCE,
  0x1C, 0xE3, 0x8E, 0x70, 0xE7, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C,
  0x1F, 0xF3, 0xFF, 0x38, 0x03, 0x80, 0x30, 0x07, 0x78, 0x7F, 0xC7, 0x1E,
  0x00, 0xE0, 0x0E, 0xE1, 0xEE, 0x3C, 0xFF, 0x83, 0xE0, 0x07, 0xC1, 0xFE,
  0x3C, 0xE3, 0x87, 0x70, 0x07, 0x78, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE, 0x0E,
  0xE1, 0xC7, 0x1C, 0x7F, 0x83, 0xE0, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0xF3, 0x87, 0x78, 0xE3, 0x8E, 0x3F,
  0xC3, 0xFC, 0x71, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xFF, 0x83, 0xF0, 0x0F,
  0xC1, 0xFE, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xE7, 0xFE, 0x3E,
  0xE0, 0x1C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x39, 0xCE, 0x00, 0x00,
  0x00, 0x07, 0xB9, 0xC0, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xE1, 0xC7, 0x0C, 0x30, 0x60, 0x00, 0x20, 0x3C, 0x3F, 0x3F, 0x8F,
  0x81, 0x80, 0x3E, 0x03, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1E, 0x01,
  0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0xC0, 0xF8, 0xFE, 0x7E, 0x1E, 0x03, 0x00,
  0x00, 0x1F, 0x87, 0xF9, 0xC7, 0xF0, 0x7E, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x30,
  0x83, 0x06, 0x30, 0x11, 0x3A, 0x93, 0x34, 0x91, 0xAD, 0x89, 0x48, 0xCA,
  0xC6, 0xF6, 0x27, 0xA3, 0x2D, 0x1B, 0x69, 0xD3, 0x77, 0x18, 0x00, 0x40,
  0x43, 0x0C, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x06, 0xE0, 0x77,
  0x07, 0x38, 0x39, 0xC3, 0x8E, 0x1F, 0xF1, 0xFF, 0x8E, 0x0E, 0xE0, 0x77,
  0x03, 0xF0, 0x1C, 0x1F, 0xF0, 0xFF, 0xC7, 0x1E, 0x78, 0x73, 0x87, 0x9C,
  0x38, 0xFF, 0x87, 0xFC, 0x78, 0x73, 0x83, 0xDC, 0x1C, 0xE1, 0xE7, 0xFE,
  0x7F, 0xE0, 0x07, 0xC1, 0xFE, 0x3C, 0xF7, 0x87, 0x70, 0x67, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xE0, 0xEF, 0x1C, 0x7F, 0x83, 0xE0, 0x1F,
  0xC0, 0xFF, 0x87, 0x1C, 0x78, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F,
  0x78, 0x73, 0x83, 0x9C, 0x38, 0xE3, 0xC7, 0xFC, 0x7F, 0x80, 0x1F, 0xF8,
  0x7F, 0xE1, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0x0F, 0xF8,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0x8E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xFF, 0x8F, 0xFC,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xC1,
  0xFE, 0x38, 0xE7, 0x87, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x3E, 0xE7, 0xEE,
  0x0E, 0xE0, 0xEF, 0x1E, 0x7F, 0xC3, 0xF0, 0x1C, 0x38, 0xE1, 0xC7, 0x0E,
  0x78, 0x73, 0xC7, 0x9C, 0x38, 0xFF, 0xC7, 0xFE, 0x78, 0x73, 0x87, 0x1C,
  0x38, 0xE1, 0xC7, 0x0E, 0x78, 0x70, 0x3F, 0xF3, 0xFF, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFF, 0xCF, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xFF, 0x03, 0xC0,
  0x1C, 0x3C, 0x38, 0xF0, 0x73, 0xC1, 0xEF, 0x03, 0xBC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xF3, 0x81, 0xC7, 0x83, 0x8F, 0x07, 0x0E,
  0x1E, 0x1E, 0x00, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0xF9,
  0xF3, 0xE7, 0x8D, 0xBE, 0x36, 0xD8, 0xDF, 0xE7, 0x7B, 0x9D, 0xEC, 0x67,
  0x31, 0x9C, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x01, 0x80, 0x1E, 0x18,
  0xF1, 0xC7, 0x8E, 0x7C, 0x73, 0xF3, 0x9F, 0x98, 0xFD, 0xC6, 0x6E, 0x73,
  0x73, 0x9F, 0x9C, 0xF8, 0xE7, 0xC6, 0x1E, 0x70, 0xF0, 0x07, 0xC1, 0xFE,
  0x38, 0xF7, 0x07, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x0E,
  0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0x1E, 0x78,
  0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0xFC, 0x7F, 0xC3, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0xF7, 0x07, 0x70,
  0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x0E, 0xE1, 0xEF, 0x3C, 0x7F,
  0x83, 0xE0, 0x1C, 0x01, 0xE0, 0x0F, 0xC0, 0x7C, 0x1F, 0xF0, 0xFF, 0xC7,
  0x0E, 0x78, 0x73, 0x83, 0x9C, 0x38, 0xFF, 0x87, 0xF8, 0x79, 0xC3, 0x8E,
  0x1C, 0x78, 0xE1, 0xC7, 0x0E, 0x78, 0x78, 0x07, 0xE0, 0xFF, 0x87, 0x1E,
  0x70, 0x73, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xB8,
  0x1D, 0xE1, 0xE7, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x0F, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x0F, 0x38, 0x71, 0xE7, 0x87, 0xF8,
  0x1F, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCF, 0x1C, 0x38, 0xE1,
  0xCE, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0x60, 0x1D, 0x80, 0x66, 0x03, 0x98, 0x0E, 0x67, 0x33, 0x9D, 0xCE,
  0xF7, 0x3B, 0xD8, 0xFB, 0xE3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83,
  0x8E, 0x00, 0x1E, 0x0E, 0x1C, 0x38, 0x3C, 0xE0, 0x3B, 0x80, 0x7E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1D, 0xC0, 0x73, 0x81, 0xC3,
  0x87, 0x07, 0x1E, 0x07, 0x00, 0xE0, 0x77, 0x87, 0x9C, 0x38, 0xE3, 0x83,
  0xB8, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFE, 0x7F, 0xF0, 0x0F, 0xC3, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0xF8, 0xFE, 0x00, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x30,
  0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x0F, 0xC7,
  0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xF0, 0xFC,
  0x00, 0x03, 0xC0, 0x3C, 0x06, 0xE0, 0xEE, 0x0C, 0x61, 0xC6, 0x18, 0x63,
  0x07, 0x70, 0x36, 0x03, 0xFF, 0xFC, 0xE3, 0x8C, 0x0F, 0x83, 0xF8, 0xE7,
  0x38, 0xE0, 0x1C, 0x7F, 0x9F, 0xF7, 0x0E, 0xE3, 0xDC, 0xF3, 0xF7, 0xBC,
  0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1D, 0xE3, 0xBF, 0x3C, 0x73,
  0x87, 0x38, 0x73, 0x87, 0x30, 0x77, 0x07, 0x70, 0xE7, 0x9E, 0x7F, 0xCE,
  0x78, 0x0F, 0x83, 0xFC, 0xE3, 0xB8, 0x77, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xDE, 0x79, 0xFE, 0x1F, 0x00, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE1, 0xE7, 0x1F, 0xB9, 0xE7, 0x8E, 0x1C, 0xF0, 0xE7, 0x07, 0x38, 0x39,
  0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0xF7, 0x0F, 0x38, 0x0F, 0x83, 0xF8, 0xE3,
  0xB8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1E, 0x39, 0xFE, 0x1F,
  0x00, 0x03, 0xF0, 0xFF, 0x0E, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x07, 0xB8, 0xFD, 0xC7, 0x1E, 0x70, 0xE3, 0x87, 0x3C, 0x39, 0xC1,
  0xCE, 0x0E, 0x70, 0xE3, 0xCF, 0x0F, 0xF8, 0x79, 0xC0, 0x0E, 0x78, 0xE1,
  0xC7, 0x0F, 0xF0, 0x3E, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1D,
  0xE3, 0xBF, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x70,
  0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x1F,
  0xC1, 0xF8, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0xFF, 0xEF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x07, 0xE0, 0xFC,
  0x00, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x73, 0x8E, 0x39, 0xC7,
  0x38, 0x77, 0x07, 0xF0, 0x7F, 0x07, 0x78, 0xE3, 0x8E, 0x38, 0xE1, 0xCE,
  0x1C, 0x0F, 0xC0, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xEF,
  0xFE, 0x37, 0x39, 0xFB, 0xDE, 0xEE, 0xE6, 0x77, 0x33, 0xB3, 0x9D, 0x9C,
  0xCC, 0xE6, 0xE6, 0x77, 0x33, 0xB1, 0x9D, 0x9C, 0xC0, 0x19, 0xE3, 0xBF,
  0x3C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x0F, 0x87, 0xFD, 0xE3, 0xB8, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xDC, 0x79, 0xFE, 0x1F, 0x00, 0x1D, 0xE3, 0xBF, 0x3C,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0x77, 0x07, 0x70, 0xE7, 0x9E, 0x7F,
  0xC7, 0x78, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x73,
  0xFE, 0x79, 0xE7, 0x0E, 0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE,
  0x3C, 0xFD, 0xC7, 0x9C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x73, 0xEE, 0xFD, 0xFF, 0x3E, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0xC7, 0xFC, 0xC3, 0xB8, 0x07, 0xC0,
  0x7F, 0x07, 0xF0, 0x0E, 0x00, 0xDC, 0x3B, 0xFE, 0x3F, 0x80, 0x0C, 0x03,
  0x01, 0xC1, 0xFF, 0x7F, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1F, 0xC3, 0xF0, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xE7, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x3C, 0xFD, 0xC7, 0x9C, 0x70,
  0x3B, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x1C, 0x38, 0xE0, 0xEE, 0x07, 0x70,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x00, 0xE0, 0x1F, 0x01, 0xF8, 0x0D,
  0xCC, 0x6C, 0xE7, 0x67, 0x33, 0x6D, 0x9B, 0x7C, 0xF3, 0xC7, 0x9E, 0x38,
  0xE1, 0xC7, 0x00, 0x1C, 0x1C, 0x1C, 0x70, 0x39, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0E, 0xE0, 0x39, 0xC0, 0xE1, 0xC3,
  0x83, 0x80, 0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x18, 0xE0, 0x73,
  0x81, 0xDC, 0x07, 0x70, 0x1D, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F,
  0xEF, 0xFE, 0x03, 0xE0, 0xFC, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x81, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x81, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0xFE, 0x83,
  0xE0,
};

const GFXglyph LiberationMono_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 14, 13, 4, -14 },
  { 12, 9, 7, 13, 4, -16 },
  { 20, 13, 14, 13, 0, -14 },
  { 43, 13, 17, 13, 0, -15 },
  { 71, 14, 14, 13, 0, -14 },
  { 96, 12, 14, 13, 0, -14 },
  { 117, 4, 7, 13, 6, -16 },
  { 121, 9, 21, 13, 3, -16 },
  { 145, 9, 21, 13, 1, -16 },
  { 169, 8, 8, 13, 4, -16 },
  { 177, 11, 10, 13, 1, -13 },
  { 191, 6, 7, 13, 1, -3 },
  { 197, 7, 2, 13, 3, -7 },
  { 199, 4, 3, 13, 4, -3 },
  { 201, 14, 16, 13, 0, -16 },
  { 229, 12, 14, 13, 1, -14 },
  { 250, 12, 14, 13, 0, -14 },
  { 271, 13, 14, 13, 0, -14 },
  { 294, 12, 14, 13, 1, -14 },
  { 315, 12, 14, 13, 0, -14 },
  { 336, 12, 14, 13, 1, -14 },
  { 357, 12, 14, 13, 1, -14 },
  { 378, 11, 14, 13, 2, -14 },
  { 398, 12, 14, 13, 1, -14 },
  { 419, 12, 14, 13, 1, -14 },
  { 440, 5, 12, 13, 4, -12 },
  { 448, 7, 16, 13, 2, -12 },
  { 462, 11, 11, 13, 1, -13 },
  { 478, 11, 8, 13, 1, -11 },
  { 489, 11, 11, 13, 1, -13 },
  { 505, 11, 14, 13, 2, -14 },
  { 525, 13, 19, 13, 0, -16 },
  { 556, 13, 14, 13, -1, -14 },
  { 579, 13, 14, 13, 0, -14 },
  { 602, 12, 14, 13, 1, -14 },
  { 623, 13, 14, 13, 0, -14 },
  { 646, 14, 14, 13, 0, -14 },
  { 671, 13, 14, 13, 1, -14 },
  { 694, 12, 14, 13, 1, -14 },
  { 715, 13, 14, 13, 0, -14 },
  { 738, 12, 14, 13, 1, -14 },
  { 759, 12, 14, 13, 1, -14 },
  { 780, 15, 14, 13, 0, -14 },
  { 807, 10, 14, 13, 1, -14 },
  { 825, 14, 14, 13, 0, -14 },
  { 850, 13, 14, 13, 0, -14 },
  { 873, 12, 14, 13, 1, -14 },
  { 894, 13, 14, 13, 0, -14 },
  { 917, 12, 18, 13, 1, -14 },
  { 944, 13, 14, 13, 0, -14 },
  { 967, 13, 14, 13, 0, -14 },
  { 990, 12, 14, 13, 2, -14 },
  { 1011, 13, 14, 13, 1, -14 },
  { 1034, 13, 14, 13, 2, -14 },
  { 1057, 14, 14, 13, 1, -14 },
  { 1082, 15, 14, 13, -1, -14 },
  { 1109, 13, 14, 13, 2, -14 },
  { 1132, 13, 14, 13, 0, -14 },
  { 1155, 10, 21, 13, 2, -16 },
  { 1182, 8, 16, 13, 3, -16 },
  { 1198, 10, 21, 13, 1, -16 },
  { 1225, 12, 10, 13, 0, -15 },
  { 1240, 14, 1, 13, -2, 1 },
  { 1242, 5, 3, 13, 6, -16 },
  { 1244, 11, 12, 13, 1, -12 },
  { 1261, 12, 16, 13, 0, -16 },
  { 1285, 11, 12, 13, 1, -12 },
  { 1302, 13, 16, 13, 1, -16 },
  { 1328, 11, 12, 13, 1, -12 },
  { 1345, 12, 16, 13, 2, -16 },
  { 1369, 13, 17, 13, 0, -12 },
  { 1397, 12, 16, 13, 0, -16 },
  { 1421, 12, 16, 13, 0, -16 },
  { 1445, 12, 21, 13, -1, -16 },
  { 1477, 12, 16, 13, 1, -16 },
  { 1501, 12, 16, 13, 0, -16 },
  { 1525, 13, 12, 13, 0, -12 },
  { 1545, 12, 12, 13, 0, -12 },
  { 1563, 11, 12, 13, 1, -12 },
  { 1580, 12, 17, 13, 0, -12 },
  { 1606, 12, 17, 13, 1, -12 },
  { 1632, 11, 12, 13, 2, -12 },
  { 1649, 11, 12, 13, 1, -12 },
  { 1666, 10, 15, 13, 2, -15 },
  { 1685, 12, 12, 13, 1, -12 },
  { 1703, 13, 12, 13, 1, -12 },
  { 1723, 13, 12, 13, 1, -12 },
  { 1743, 15, 12, 13, -1, -12 },
  { 1766, 14, 17, 13, 0, -12 },
  { 1796, 12, 12, 13, 0, -12 },
  { 1814, 11, 21, 13, 2, -16 },
  { 1843, 3, 21, 13, 5, -16 },
  { 1851, 11, 21, 13, 0, -16 },
  { 1880, 12, 3, 13, 1, -9 },
};

const GFXfont LiberationMono_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic22pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _LIBERATIONMONO_BOLDITALIC22PT7B_H_
