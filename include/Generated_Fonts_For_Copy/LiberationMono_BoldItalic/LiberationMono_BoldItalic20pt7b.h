#ifndef _LIBERATIONMONO_BOLDITALIC20PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0xE7, 0x39, 0x8C, 0x00, 0x39, 0xCC, 0x00, 0x73, 0x77,
  0x67, 0x66, 0x66, 0xC6, 0x02, 0x30, 0x62, 0x04, 0x60, 0x46, 0x3F, 0xF0,
  0x8C, 0x18, 0x81, 0x18, 0xFF, 0xE2, 0x30, 0x62, 0x06, 0x20, 0x46, 0x00,
  0x01, 0x00, 0xFC, 0x1F, 0xE3, 0x97, 0x3A, 0x63, 0xA0, 0x3F, 0x01, 0xFC,
  0x03, 0xE0, 0x4E, 0xE4, 0xE7, 0x4E, 0x7F, 0xC3, 0xF0, 0x08, 0x00, 0x80,
  0x1C, 0x19, 0x31, 0x99, 0x98, 0xCD, 0x86, 0x58, 0x37, 0x81, 0xFB, 0x80,
  0xA6, 0x0B, 0x30, 0x99, 0x8C, 0xC8, 0xC6, 0xCC, 0x1C, 0x00, 0x07, 0xC1,
  0xF8, 0x33, 0x0C, 0x61, 0xF8, 0x1E, 0x0F, 0x1B, 0xF3, 0xE6, 0xD8, 0xF3,
  0x8E, 0x7F, 0xF7, 0xCE, 0xFF, 0x6D, 0x80, 0x06, 0x0E, 0x1C, 0x18, 0x38,
  0x30, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0x70, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0x60, 0x0C, 0x08, 0x7F,
  0x7E, 0x3C, 0x6E, 0x44, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x38, 0xE7, 0x18, 0x63, 0x00, 0xFF, 0xF0,
  0xFF, 0x00, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x0F, 0x87, 0xF3, 0x9D, 0xC3, 0x70, 0xDB, 0x3E, 0xDF,
  0x87, 0xE1, 0xF8, 0xEE, 0x39, 0xFC, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0xFE,
  0x1D, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x3F,
  0xE7, 0xFC, 0x07, 0xC0, 0xFE, 0x1C, 0xF3, 0x87, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0x87,
  0xF8, 0xE7, 0xB8, 0x60, 0x1C, 0x1E, 0x03, 0xE0, 0x1E, 0x01, 0xD8, 0x3B,
  0x8E, 0x7F, 0x87, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0x60, 0xCC, 0x33,
  0x8C, 0x73, 0x0E, 0x7F, 0xFF, 0xFC, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0xE7,
  0xF8, 0xC0, 0x38, 0x07, 0xF0, 0xFF, 0x1C, 0x70, 0x0E, 0x01, 0xD8, 0x33,
  0x8E, 0x7F, 0x87, 0xC0, 0x0F, 0x87, 0xF3, 0x8D, 0xC0, 0x70, 0x1B, 0xEF,
  0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x39, 0xFC, 0x3E, 0x00, 0x7F, 0xFF, 0xF0,
  0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x00, 0x0F, 0x87, 0xF8, 0xE3, 0xB8, 0x67, 0x1C, 0x7F, 0x0F, 0xE3,
  0x0E, 0xE1, 0xDC, 0x3B, 0x8E, 0x7F, 0x87, 0xE0, 0x0F, 0x8F, 0xF7, 0x9D,
  0xC3, 0x71, 0xDC, 0x77, 0xFC, 0xF7, 0x01, 0x88, 0xEE, 0x73, 0xFC, 0x7C,
  0x00, 0x37, 0x70, 0x00, 0x00, 0xEE, 0xC0, 0x06, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x18, 0x38, 0x30, 0x60, 0x60, 0x00, 0x40, 0xF0,
  0xF9, 0xF8, 0xF0, 0x30, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0xF0, 0x04, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x3C, 0x07, 0xC0,
  0x7E, 0x03, 0xC0, 0x30, 0x3C, 0x7E, 0x7C, 0x3C, 0x08, 0x00, 0x0F, 0x87,
  0xF9, 0xC3, 0xB8, 0x70, 0x0C, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x42, 0x08, 0x31, 0x01, 0x33, 0x52,
  0x4D, 0x68, 0xD5, 0x89, 0x59, 0x9D, 0x1B, 0xD1, 0x2F, 0x32, 0x95, 0x4D,
  0x98, 0xC0, 0x04, 0x08, 0x61, 0x83, 0xE0, 0x01, 0xC0, 0x3C, 0x03, 0xE0,
  0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0x61, 0xC6, 0x3F, 0xE3, 0xFF, 0x70, 0x77,
  0x07, 0xE0, 0x70, 0x1F, 0xE1, 0xFF, 0x38, 0x73, 0x87, 0x38, 0xE3, 0xFC,
  0x3F, 0xC7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0xFC, 0xFF, 0x80, 0x0F,
  0x83, 0xF8, 0xE3, 0xB8, 0x77, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x3B, 0x8E, 0x3F, 0x83, 0xE0, 0x1F, 0x81, 0xFE, 0x38, 0xE3, 0x87, 0x38,
  0x73, 0x87, 0x30, 0x67, 0x0E, 0x70, 0xE7, 0x1C, 0x73, 0xC7, 0xF8, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFE, 0x3F, 0xC7,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xF3, 0xFE, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x0F, 0x83, 0xF8, 0xE7, 0x38, 0x76, 0x01, 0xC0, 0x39,
  0xF7, 0x3E, 0xE1, 0xDC, 0x3B, 0x86, 0x3F, 0xC3, 0xE0, 0x1C, 0x71, 0x87,
  0x38, 0x73, 0x86, 0x38, 0xE3, 0xFE, 0x3F, 0xE7, 0x0E, 0x70, 0xE7, 0x1C,
  0x71, 0xC6, 0x1C, 0xE1, 0xC0, 0x3F, 0xE7, 0xFC, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0xCF, 0xF8, 0x07,
  0xC3, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x23, 0xB8, 0xEE,
  0x73, 0xF8, 0x7C, 0x00, 0x1C, 0x78, 0xC7, 0x8E, 0x78, 0x77, 0x83, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x7B, 0x83, 0x9C, 0x1C, 0x70, 0xC3, 0x8E,
  0x1E, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x1F, 0xFF, 0xF8, 0x3C, 0x71, 0xE3, 0x8F, 0x3C, 0x79, 0xE3,
  0xDB, 0x3E, 0xF1, 0xB5, 0x8D, 0xEC, 0x66, 0x63, 0x33, 0x38, 0x39, 0x81,
  0x8C, 0x0C, 0x00, 0x1C, 0x31, 0xC7, 0x3E, 0x73, 0xE7, 0x36, 0x63, 0x66,
  0x36, 0xE7, 0x7E, 0x77, 0xE6, 0x3C, 0x63, 0xC6, 0x3C, 0xE3, 0xC0, 0x0F,
  0x87, 0xF8, 0xE7, 0xB8, 0x76, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDC,
  0x3B, 0x8E, 0x7F, 0x83, 0xC0, 0x1F, 0xC1, 0xFF, 0x38, 0x73, 0x87, 0x38,
  0x73, 0x8E, 0x3F, 0xC7, 0xF8, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x00, 0x0F, 0x87, 0xF8, 0xE7, 0xB8, 0x76, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E,
  0xE1, 0xDC, 0x3B, 0x8E, 0x7F, 0x87, 0xE0, 0x38, 0x07, 0x00, 0xFC, 0x0F,
  0x80, 0x1F, 0xE1, 0xFF, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x3F, 0xC7,
  0xF8, 0x73, 0x87, 0x3C, 0x71, 0xC6, 0x1C, 0xE0, 0xE0, 0x07, 0xC1, 0xFE,
  0x38, 0x73, 0x87, 0x38, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xEE, 0x0E,
  0xF0, 0xE7, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFC, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38,
  0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC,
  0x73, 0x8E, 0x7F, 0x87, 0xC0, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3,
  0x8E, 0x38, 0x67, 0x06, 0x60, 0x6E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x00, 0x60, 0x37, 0x01, 0xB8, 0x1D, 0xC0, 0xCE, 0x66, 0x77, 0x73, 0xBB,
  0x1F, 0xD8, 0xDF, 0xC7, 0xBC, 0x3D, 0xE1, 0xCE, 0x0E, 0x70, 0x00, 0x1C,
  0x1C, 0x38, 0xE0, 0xE7, 0x01, 0xB8, 0x07, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0xC0, 0x77, 0x03, 0x8E, 0x1C, 0x38, 0xE0, 0x70, 0xE0, 0xEE,
  0x1C, 0x61, 0xC7, 0x38, 0x77, 0x03, 0xE0, 0x3C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFC,
  0xFF, 0xC0, 0x1F, 0x8F, 0xC7, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x7E, 0x3F, 0x00,
  0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60, 0xC1,
  0xC1, 0x80, 0x1F, 0x8F, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x7E, 0x3F, 0x00,
  0x03, 0x80, 0xF0, 0x3F, 0x06, 0x61, 0x8C, 0x31, 0x8C, 0x3B, 0x83, 0x60,
  0x60, 0x7F, 0xF8, 0xE3, 0x8E, 0x0F, 0x83, 0xF8, 0xE3, 0x00, 0x61, 0xFC,
  0x7F, 0x9C, 0x73, 0x8E, 0xE3, 0xCF, 0xBD, 0xE7, 0x80, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0xBC, 0x7F, 0xCF, 0x39, 0xC7, 0x30, 0xEE, 0x1D, 0xC3,
  0xB8, 0x67, 0x1C, 0xDF, 0x3B, 0xC0, 0x0F, 0x0F, 0xF7, 0x1D, 0xC7, 0xE0,
  0x38, 0x0E, 0x03, 0x86, 0xE3, 0x9F, 0xC3, 0xE0, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x71, 0xEE, 0x7D, 0x9C, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x86, 0x71,
  0xCE, 0x79, 0xFF, 0x1E, 0xE0, 0x0F, 0x0F, 0xE7, 0x1D, 0x83, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0xE3, 0x9F, 0xC3, 0xE0, 0x07, 0xE1, 0xFC, 0x70, 0x0E,
  0x0F, 0xFD, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x00, 0x0F, 0x71, 0xFF, 0x38, 0xE3, 0x8E, 0x70, 0xE7,
  0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0xFC, 0x3D, 0xC0, 0x1C, 0xE3, 0x87,
  0xF0, 0x3E, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x9C, 0x7F, 0xCF,
  0x39, 0xC7, 0x30, 0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xC3, 0xB8, 0x70,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE1, 0xFF, 0xBF, 0xF0, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x0F, 0xC3, 0xF0, 0x00,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x0E, 0xE3, 0x9C, 0xE3, 0xB0, 0x7E,
  0x0F, 0xC1, 0xDC, 0x73, 0x8E, 0x71, 0xC7, 0x38, 0xE0, 0x0F, 0x81, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE1, 0xFF, 0xBF, 0xF0, 0x36, 0x67, 0xEF, 0x77, 0x77, 0x77,
  0x66, 0x66, 0x66, 0x66, 0x6E, 0x66, 0xCE, 0xEC, 0xCE, 0xCC, 0xC0, 0x39,
  0xC7, 0xFC, 0xF3, 0x9C, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x86, 0x71, 0xCC,
  0x3B, 0x87, 0x00, 0x1F, 0x8F, 0xF7, 0x1D, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x86, 0xE3, 0xBF, 0xC3, 0xE0, 0x3B, 0xC7, 0xFC, 0xF3, 0x9C, 0x73, 0x0E,
  0xE1, 0xDC, 0x3B, 0x86, 0x71, 0xCD, 0xF3, 0xBC, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x00, 0x1E, 0xE7, 0xD9, 0xC7, 0x30, 0xEE, 0x1D, 0xC3, 0xB8, 0x67,
  0x1C, 0xE7, 0x9F, 0xF1, 0xEE, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B,
  0xE7, 0xF8, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x00, 0x1F, 0x8F, 0xF7, 0x1D, 0xC0, 0x7E, 0x0F, 0xE0, 0xF8,
  0x06, 0xC3, 0xBF, 0xC7, 0xE0, 0x08, 0x0C, 0x06, 0x0F, 0xFF, 0xF1, 0x80,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE1, 0xF0, 0x70, 0xCE, 0x19,
  0xC7, 0x30, 0xEE, 0x1D, 0xC3, 0x38, 0x67, 0x1C, 0xE7, 0x9F, 0xF1, 0xCE,
  0x00, 0xE0, 0x66, 0x0E, 0x70, 0xC7, 0x1C, 0x73, 0x87, 0x38, 0x77, 0x03,
  0x60, 0x36, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0xE6,
  0xCE, 0xCD, 0xEC, 0xDE, 0xCF, 0x78, 0xF7, 0x8E, 0x78, 0xE3, 0x00, 0x1C,
  0x38, 0xE3, 0x83, 0xB8, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xB8,
  0x19, 0xC1, 0xC7, 0x1C, 0x38, 0x70, 0x31, 0xC3, 0x8E, 0x18, 0x71, 0xC3,
  0x9C, 0x0C, 0xE0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0xF0, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x7C, 0x03, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xC3,
  0xF0, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x3C, 0x0F, 0x01,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x07, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x80, 0xF0, 0x3C, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x3F, 0x0F, 0x80, 0x7C, 0x3F, 0xFA, 0x1F, 0x00,
};

const GFXglyph LiberationMono_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 13, 12, 4, -13 },
  { 10, 8, 6, 12, 3, -15 },
  { 16, 12, 13, 12, 0, -13 },
  { 36, 12, 16, 12, 0, -14 },
  { 60, 13, 13, 12, 0, -13 },
  { 82, 11, 13, 12, 0, -13 },
  { 100, 3, 6, 12, 6, -15 },
  { 103, 8, 19, 12, 3, -15 },
  { 122, 8, 19, 12, 1, -15 },
  { 141, 8, 7, 12, 3, -15 },
  { 148, 10, 10, 12, 1, -12 },
  { 161, 6, 6, 12, 1, -3 },
  { 166, 6, 2, 12, 3, -6 },
  { 168, 3, 3, 12, 4, -3 },
  { 170, 13, 15, 12, 0, -15 },
  { 195, 10, 13, 12, 1, -13 },
  { 212, 11, 13, 12, 0, -13 },
  { 230, 12, 13, 12, 0, -13 },
  { 250, 11, 13, 12, 1, -13 },
  { 268, 11, 13, 12, 0, -13 },
  { 286, 11, 13, 12, 1, -13 },
  { 304, 10, 13, 12, 1, -13 },
  { 321, 10, 13, 12, 2, -13 },
  { 338, 11, 13, 12, 1, -13 },
  { 356, 10, 13, 12, 1, -13 },
  { 373, 4, 11, 12, 4, -11 },
  { 379, 8, 14, 12, 1, -11 },
  { 393, 10, 11, 12, 1, -12 },
  { 407, 10, 7, 12, 1, -10 },
  { 416, 10, 11, 12, 1, -12 },
  { 430, 11, 13, 12, 1, -13 },
  { 448, 12, 18, 12, 0, -15 },
  { 475, 12, 13, 12, -1, -13 },
  { 495, 12, 13, 12, 0, -13 },
  { 515, 11, 13, 12, 1, -13 },
  { 533, 12, 13, 12, 0, -13 },
  { 553, 12, 13, 12, 0, -13 },
  { 573, 11, 13, 12, 1, -13 },
  { 591, 11, 13, 12, 1, -13 },
  { 609, 12, 13, 12, 0, -13 },
  { 629, 11, 13, 12, 1, -13 },
  { 647, 10, 13, 12, 1, -13 },
  { 664, 13, 13, 12, 0, -13 },
  { 686, 9, 13, 12, 1, -13 },
  { 701, 13, 13, 12, 0, -13 },
  { 723, 12, 13, 12, 0, -13 },
  { 743, 11, 13, 12, 1, -13 },
  { 761, 12, 13, 12, 0, -13 },
  { 781, 11, 17, 12, 1, -13 },
  { 805, 12, 13, 12, 0, -13 },
  { 825, 12, 13, 12, 0, -13 },
  { 845, 11, 13, 12, 2, -13 },
  { 863, 11, 13, 12, 1, -13 },
  { 881, 12, 13, 12, 2, -13 },
  { 901, 13, 13, 12, 1, -13 },
  { 923, 14, 13, 12, -1, -13 },
  { 946, 12, 13, 12, 2, -13 },
  { 966, 12, 13, 12, 0, -13 },
  { 986, 9, 19, 12, 2, -15 },
  { 1008, 7, 15, 12, 3, -15 },
  { 1022, 9, 19, 12, 1, -15 },
  { 1044, 11, 9, 12, 0, -14 },
  { 1057, 13, 1, 12, -2, 1 },
  { 1059, 5, 3, 12, 5, -15 },
  { 1061, 11, 11, 12, 0, -11 },
  { 1077, 11, 15, 12, 0, -15 },
  { 1098, 10, 11, 12, 1, -11 },
  { 1112, 11, 15, 12, 1, -15 },
  { 1133, 10, 11, 12, 1, -11 },
  { 1147, 11, 15, 12, 2, -15 },
  { 1168, 12, 15, 12, 0, -11 },
  { 1191, 11, 15, 12, 0, -15 },
  { 1212, 11, 15, 12, 0, -15 },
  { 1233, 11, 19, 12, -1, -15 },
  { 1260, 11, 15, 12, 1, -15 },
  { 1281, 11, 15, 12, 0, -15 },
  { 1302, 12, 11, 12, 0, -11 },
  { 1319, 11, 11, 12, 0, -11 },
  { 1335, 10, 11, 12, 1, -11 },
  { 1349, 11, 15, 12, 0, -11 },
  { 1370, 11, 15, 12, 1, -11 },
  { 1391, 11, 11, 12, 1, -11 },
  { 1407, 10, 11, 12, 1, -11 },
  { 1421, 9, 14, 12, 2, -14 },
  { 1437, 11, 11, 12, 1, -11 },
  { 1453, 12, 11, 12, 1, -11 },
  { 1470, 12, 11, 12, 1, -11 },
  { 1487, 13, 11, 12, -1, -11 },
  { 1505, 13, 15, 12, 0, -11 },
  { 1530, 11, 11, 12, 0, -11 },
  { 1546, 10, 19, 12, 2, -15 },
  { 1570, 2, 19, 12, 5, -15 },
  { 1575, 10, 19, 12, 0, -15 },
  { 1599, 11, 3, 12, 1, -8 },
};

const GFXfont LiberationMono_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic20pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _LIBERATIONMONO_BOLDITALIC20PT7B_H_
