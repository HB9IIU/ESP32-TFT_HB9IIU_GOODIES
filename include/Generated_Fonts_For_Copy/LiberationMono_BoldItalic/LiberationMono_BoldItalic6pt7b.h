#ifndef _LIBERATIONMONO_BOLDITALIC6PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xF0, 0x0F, 0xE8, 0x64, 0x2E, 0x40, 0xCE, 0x6A, 0x6F, 0xF0,
  0x80, 0x6A, 0x80, 0x24, 0xA4, 0xF0, 0x49, 0xA0, 0x60, 0xC0, 0x80, 0x22,
  0x48, 0x76, 0xF0, 0x65, 0x70, 0x65, 0x70, 0x64, 0xF0, 0x2F, 0x90, 0x66,
  0x2E, 0x7E, 0xB0, 0xEA, 0x40, 0x6E, 0xF0, 0x75, 0xF0, 0x08, 0x01, 0x20,
  0x1F, 0x80, 0xFC, 0x8D, 0xC0, 0x72, 0x44, 0x7F, 0xAE, 0xC0, 0x2F, 0xD0,
  0x66, 0xAE, 0x68, 0x8E, 0x65, 0xAE, 0x74, 0xAE, 0x74, 0xE8, 0x72, 0xF0,
  0x56, 0xAA, 0x74, 0x4E, 0x24, 0xF0, 0x56, 0xEA, 0x49, 0x70, 0x5E, 0xEA,
  0x56, 0xAA, 0x69, 0xAE, 0x65, 0xE8, 0x69, 0xAE, 0x60, 0x75, 0xAA, 0x64,
  0x2E, 0xF2, 0x40, 0x5A, 0xAE, 0x16, 0x64, 0x99, 0xEA, 0x56, 0x6A, 0x56,
  0x44, 0x72, 0x4E, 0xEA, 0x80, 0xA5, 0x24, 0xA4, 0x6E, 0x00, 0xE0, 0x80,
  0x7F, 0x80, 0x4E, 0xF0, 0x73, 0x80, 0x16, 0xAE, 0x7F, 0x80, 0xDA, 0x40,
  0x6A, 0xEE, 0x4E, 0xD0, 0x0D, 0x70, 0x0C, 0xAC, 0x46, 0xCA, 0x25, 0x70,
  0xFD, 0xE0, 0x76, 0x80, 0x77, 0x80, 0x77, 0xC0, 0x6A, 0xE2, 0x6A, 0x00,
  0x6F, 0x80, 0xBB, 0xB7, 0x80, 0xA6, 0x40, 0x9E, 0xA0, 0x64, 0xA0, 0xA6,
  0x4C, 0x6B, 0x80, 0x24, 0x44, 0x40, 0xF8, 0x64, 0xAC, 0x60,
};

const GFXglyph LiberationMono_BoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 5, 4, 0, -4 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 2, -4 },
  { 13, 2, 5, 4, 1, -4 },
  { 15, 3, 5, 4, 0, -4 },
  { 17, 2, 2, 4, 1, -4 },
  { 18, 3, 4, 4, 0, -4 },
  { 20, 2, 2, 4, 0, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 4, 4, 4, 0, -4 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 4, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 1, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 2, 3, 4, 1, -3 },
  { 46, 3, 4, 4, 0, -3 },
  { 48, 3, 4, 4, 0, -4 },
  { 50, 3, 2, 4, 0, -3 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 4, 4, 4, 0, -4 },
  { 55, 4, 5, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 4, 5, 4, 0, -4 },
  { 93, 4, 4, 4, 0, -4 },
  { 95, 4, 4, 4, 0, -4 },
  { 97, 3, 4, 4, 1, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 4, 4, 4, 0, -4 },
  { 105, 4, 4, 4, 0, -4 },
  { 107, 4, 4, 4, 0, -4 },
  { 109, 4, 4, 4, 0, -4 },
  { 111, 2, 5, 4, 1, -4 },
  { 113, 2, 4, 4, 1, -4 },
  { 114, 3, 5, 4, 0, -4 },
  { 116, 3, 3, 4, 0, -4 },
  { 118, 3, 1, 4, 0, 0 },
  { 119, 1, 1, 4, 2, -4 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 3, 4, 4, 0, -4 },
  { 124, 3, 3, 4, 0, -3 },
  { 126, 4, 4, 4, 0, -4 },
  { 128, 3, 3, 4, 0, -3 },
  { 130, 3, 4, 4, 1, -4 },
  { 132, 4, 4, 4, 0, -3 },
  { 134, 3, 4, 4, 0, -4 },
  { 136, 3, 4, 4, 0, -4 },
  { 138, 3, 5, 4, 0, -4 },
  { 140, 4, 4, 4, 0, -4 },
  { 142, 3, 4, 4, 0, -4 },
  { 144, 4, 3, 4, 0, -3 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 3, 3, 4, 0, -3 },
  { 150, 3, 4, 4, 0, -3 },
  { 152, 4, 4, 4, 0, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 2, 4, 4, 1, -4 },
  { 159, 3, 3, 4, 0, -3 },
  { 161, 4, 3, 4, 0, -3 },
  { 163, 4, 3, 4, 0, -3 },
  { 165, 4, 3, 4, 0, -3 },
  { 167, 4, 4, 4, 0, -3 },
  { 169, 3, 3, 4, 0, -3 },
  { 171, 4, 5, 4, 0, -4 },
  { 174, 1, 5, 4, 1, -4 },
  { 175, 3, 5, 4, 0, -4 },
  { 177, 3, 1, 4, 0, -2 },
};

const GFXfont LiberationMono_BoldItalic6pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic6pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _LIBERATIONMONO_BOLDITALIC6PT7B_H_
