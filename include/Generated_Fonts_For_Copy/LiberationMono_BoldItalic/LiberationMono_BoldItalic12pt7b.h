#ifndef _LIBERATIONMONO_BOLDITALIC12PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB4, 0x36, 0xDE, 0xB5, 0x20, 0x12, 0x25, 0xF9, 0x22, 0x9F,
  0x92, 0x48, 0x08, 0x7D, 0xBB, 0x47, 0x83, 0xD5, 0xEA, 0x78, 0x40, 0x72,
  0x54, 0xD4, 0x68, 0x1E, 0x2A, 0x4A, 0x8C, 0x1C, 0x48, 0xB1, 0x85, 0x73,
  0xA2, 0x7B, 0x57, 0x32, 0x64, 0xCC, 0x88, 0x8C, 0xC0, 0x33, 0x11, 0x11,
  0x33, 0x26, 0xC0, 0x27, 0x99, 0x60, 0x20, 0x8F, 0xC8, 0x20, 0x32, 0x44,
  0xE0, 0xF0, 0x02, 0x06, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x39,
  0x3C, 0xFB, 0x8E, 0x29, 0xBC, 0x1D, 0xA0, 0x86, 0x18, 0x61, 0xBF, 0x1C,
  0x4C, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x1C, 0x4C, 0x18, 0xC0, 0x40, 0xB3,
  0x3C, 0x0E, 0x38, 0x51, 0x64, 0xDF, 0xC2, 0x04, 0x3E, 0x41, 0x83, 0xE0,
  0x60, 0xB3, 0x3C, 0x39, 0x3C, 0x3E, 0xCA, 0x2D, 0x9C, 0x7C, 0x31, 0x8C,
  0x21, 0x84, 0x30, 0x3C, 0x4D, 0x98, 0xC6, 0x58, 0xB3, 0x3C, 0x7B, 0x3C,
  0xF3, 0x7C, 0x29, 0xBC, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x64, 0x80,
  0x0F, 0xC8, 0x3C, 0x0C, 0xFC, 0x00, 0x3F, 0xC1, 0xE0, 0xDE, 0xC0, 0x7B,
  0x30, 0xC6, 0x20, 0x06, 0x18, 0x1C, 0x45, 0x0A, 0xF6, 0x75, 0x72, 0xDE,
  0x81, 0x01, 0xE0, 0x0E, 0x0E, 0x1E, 0x16, 0x32, 0x3E, 0x62, 0x43, 0x3E,
  0xCD, 0x9B, 0xC6, 0x68, 0xF1, 0x7C, 0x1C, 0x4D, 0x9A, 0x04, 0x18, 0xDB,
  0x3C, 0x3C, 0xCD, 0x9B, 0x36, 0x68, 0xB3, 0x7C, 0x3E, 0xC1, 0x83, 0xE4,
  0x08, 0x30, 0x7E, 0x3E, 0x41, 0x83, 0x07, 0xCC, 0x10, 0x60, 0x1C, 0x4D,
  0x9A, 0x04, 0xE8, 0xD9, 0x3C, 0x26, 0xCD, 0x9B, 0xF4, 0x49, 0xB3, 0x66,
  0x3E, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x7E, 0x1E, 0x0C, 0x10, 0x60, 0xC9,
  0x92, 0x38, 0x27, 0x6E, 0x7C, 0x78, 0x78, 0x4C, 0xCC, 0xCC, 0x63, 0x11,
  0x8C, 0x63, 0x1F, 0x76, 0x56, 0x5E, 0x5A, 0x5E, 0xD4, 0xC4, 0x84, 0x32,
  0xE5, 0xDB, 0xB5, 0xCB, 0xB7, 0x66, 0x1C, 0x4D, 0x9A, 0x3C, 0x78, 0x93,
  0x3C, 0x3E, 0xCD, 0x9B, 0x37, 0xC8, 0x30, 0x60, 0x1C, 0x4D, 0x9A, 0x3C,
  0x78, 0xD3, 0x3C, 0x30, 0x38, 0x3E, 0xCD, 0x9B, 0x37, 0xC9, 0xB3, 0x66,
  0x3C, 0xCD, 0x83, 0xC1, 0xE0, 0xF1, 0x3C, 0xFE, 0x60, 0xC1, 0x82, 0x04,
  0x18, 0x30, 0x47, 0x3C, 0xF3, 0xCA, 0x29, 0xBC, 0xC7, 0x8B, 0x36, 0x45,
  0x8A, 0x1C, 0x30, 0x87, 0x0E, 0xD5, 0xAF, 0xDB, 0x36, 0x4C, 0x31, 0x0D,
  0x87, 0x81, 0x81, 0xC0, 0xA0, 0x98, 0xC4, 0xC6, 0x99, 0xE3, 0x83, 0x04,
  0x18, 0x30, 0x3E, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x7E, 0x3C, 0xC2, 0x08,
  0x61, 0x86, 0x10, 0x43, 0x0F, 0x00, 0x88, 0xC4, 0x46, 0x23, 0x10, 0x3C,
  0x30, 0xC2, 0x08, 0x61, 0x86, 0x10, 0x4F, 0x00, 0x1C, 0x38, 0x93, 0x24,
  0x60, 0xFE, 0xCC, 0x3D, 0x90, 0x5F, 0x4F, 0x37, 0xC0, 0x20, 0x41, 0xF3,
  0x36, 0x68, 0xD1, 0x36, 0xF8, 0x7B, 0x3C, 0x20, 0x82, 0x6F, 0x00, 0x02,
  0x0C, 0xFB, 0x36, 0x68, 0xB3, 0x26, 0x7C, 0x3C, 0xCD, 0x9B, 0xFC, 0x09,
  0x9E, 0x00, 0x1E, 0x63, 0xF3, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x3E, 0xCD,
  0x9A, 0x34, 0x4D, 0x9F, 0x06, 0xF8, 0x20, 0x41, 0xF3, 0x36, 0x6C, 0x91,
  0x66, 0xCC, 0x0C, 0x03, 0x86, 0x18, 0x61, 0x84, 0xFC, 0x0C, 0x03, 0xC2,
  0x08, 0x61, 0x86, 0x18, 0x4E, 0x00, 0x30, 0x40, 0x9B, 0x67, 0x8F, 0x1A,
  0x26, 0xCC, 0x3C, 0x20, 0x86, 0x18, 0x61, 0x84, 0xFC, 0x76, 0xB5, 0x4E,
  0xBD, 0x72, 0xAD, 0x00, 0x7C, 0xCD, 0x9A, 0x24, 0x59, 0xB3, 0x00, 0x3C,
  0xCD, 0x1A, 0x3C, 0x49, 0x9E, 0x00, 0x7C, 0xCD, 0x9A, 0x34, 0x5D, 0xBE,
  0x60, 0xC0, 0x3E, 0xCD, 0x92, 0x2C, 0xC9, 0x9F, 0x06, 0x08, 0x5D, 0x86,
  0x30, 0xC3, 0x0C, 0x00, 0x3C, 0xCD, 0x81, 0xE0, 0xD8, 0x9E, 0x00, 0x21,
  0x3E, 0xC6, 0x31, 0x08, 0x78, 0xCF, 0x3C, 0xA2, 0x9A, 0x6F, 0x80, 0xC5,
  0x9B, 0x26, 0xC5, 0x0E, 0x18, 0x00, 0x87, 0x0A, 0xD5, 0xED, 0x9B, 0x26,
  0x00, 0x66, 0x58, 0xE0, 0xC3, 0x8D, 0xB3, 0x00, 0x62, 0x66, 0x64, 0x2C,
  0x28, 0x38, 0x30, 0x30, 0xE0, 0x3E, 0x18, 0x61, 0x83, 0x0C, 0x3F, 0x00,
  0x1C, 0xC3, 0x08, 0x63, 0x06, 0x18, 0x41, 0x07, 0x00, 0xFF, 0xF0, 0x38,
  0x30, 0x82, 0x18, 0x31, 0x84, 0x10, 0xCE, 0x00, 0xE4, 0x70,
};

const GFXglyph LiberationMono_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 5, 4, 7, 2, -9 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 7, 10, 7, 0, -9 },
  { 23, 8, 8, 7, 0, -8 },
  { 31, 7, 8, 7, 0, -8 },
  { 38, 2, 4, 7, 3, -9 },
  { 39, 4, 11, 7, 2, -9 },
  { 45, 4, 11, 7, 1, -9 },
  { 51, 5, 4, 7, 2, -9 },
  { 54, 6, 5, 7, 1, -7 },
  { 58, 4, 4, 7, 0, -2 },
  { 60, 3, 1, 7, 2, -4 },
  { 61, 2, 2, 7, 2, -2 },
  { 62, 8, 9, 7, 0, -9 },
  { 71, 6, 8, 7, 1, -8 },
  { 77, 6, 8, 7, 0, -8 },
  { 83, 7, 8, 7, 0, -8 },
  { 90, 7, 8, 7, 0, -8 },
  { 97, 7, 8, 7, 0, -8 },
  { 104, 7, 8, 7, 0, -8 },
  { 111, 6, 8, 7, 1, -8 },
  { 117, 6, 8, 7, 1, -8 },
  { 123, 7, 8, 7, 0, -8 },
  { 130, 6, 8, 7, 1, -8 },
  { 136, 3, 7, 7, 2, -7 },
  { 139, 4, 9, 7, 1, -7 },
  { 144, 6, 5, 7, 1, -7 },
  { 148, 6, 4, 7, 1, -6 },
  { 151, 6, 5, 7, 1, -7 },
  { 155, 6, 8, 7, 1, -8 },
  { 161, 7, 11, 7, 0, -9 },
  { 171, 8, 8, 7, -1, -8 },
  { 179, 7, 8, 7, 0, -8 },
  { 186, 7, 8, 7, 0, -8 },
  { 193, 7, 8, 7, 0, -8 },
  { 200, 7, 8, 7, 0, -8 },
  { 207, 7, 8, 7, 0, -8 },
  { 214, 7, 8, 7, 0, -8 },
  { 221, 7, 8, 7, 0, -8 },
  { 228, 7, 8, 7, 0, -8 },
  { 235, 7, 8, 7, 0, -8 },
  { 242, 8, 8, 7, 0, -8 },
  { 250, 5, 8, 7, 1, -8 },
  { 255, 8, 8, 7, 0, -8 },
  { 263, 7, 8, 7, 0, -8 },
  { 270, 7, 8, 7, 0, -8 },
  { 277, 7, 8, 7, 0, -8 },
  { 284, 7, 10, 7, 0, -8 },
  { 293, 7, 8, 7, 0, -8 },
  { 300, 7, 8, 7, 0, -8 },
  { 307, 7, 8, 7, 1, -8 },
  { 314, 6, 8, 7, 1, -8 },
  { 320, 7, 8, 7, 1, -8 },
  { 327, 7, 8, 7, 1, -8 },
  { 334, 9, 8, 7, -1, -8 },
  { 343, 7, 8, 7, 1, -8 },
  { 350, 7, 8, 7, 0, -8 },
  { 357, 6, 11, 7, 1, -9 },
  { 366, 4, 9, 7, 2, -9 },
  { 371, 6, 11, 7, 0, -9 },
  { 380, 7, 5, 7, 0, -8 },
  { 385, 7, 1, 7, -1, 1 },
  { 386, 3, 2, 7, 3, -9 },
  { 387, 6, 7, 7, 0, -7 },
  { 393, 7, 9, 7, 0, -9 },
  { 401, 6, 7, 7, 1, -7 },
  { 407, 7, 9, 7, 0, -9 },
  { 415, 7, 7, 7, 0, -7 },
  { 422, 7, 9, 7, 1, -9 },
  { 430, 7, 9, 7, 0, -7 },
  { 438, 7, 9, 7, 0, -9 },
  { 446, 6, 9, 7, 0, -9 },
  { 453, 6, 11, 7, 0, -9 },
  { 462, 7, 9, 7, 0, -9 },
  { 470, 6, 9, 7, 0, -9 },
  { 477, 7, 7, 7, 0, -7 },
  { 484, 7, 7, 7, 0, -7 },
  { 491, 7, 7, 7, 0, -7 },
  { 498, 7, 9, 7, 0, -7 },
  { 506, 7, 9, 7, 0, -7 },
  { 514, 6, 7, 7, 1, -7 },
  { 520, 7, 7, 7, 0, -7 },
  { 527, 5, 9, 7, 1, -9 },
  { 533, 6, 7, 7, 1, -7 },
  { 539, 7, 7, 7, 1, -7 },
  { 546, 7, 7, 7, 1, -7 },
  { 553, 7, 7, 7, 0, -7 },
  { 560, 8, 9, 7, 0, -7 },
  { 569, 7, 7, 7, 0, -7 },
  { 576, 6, 11, 7, 1, -9 },
  { 585, 1, 12, 7, 3, -9 },
  { 587, 6, 11, 7, 0, -9 },
  { 596, 6, 2, 7, 1, -5 },
};

const GFXfont LiberationMono_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic12pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _LIBERATIONMONO_BOLDITALIC12PT7B_H_
