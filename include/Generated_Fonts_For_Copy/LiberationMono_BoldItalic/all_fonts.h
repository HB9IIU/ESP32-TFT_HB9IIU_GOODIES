#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/LiberationMono_BoldItalic
// Headers: 67

#include "LiberationMono_BoldItalic6pt7b.h"
#include "LiberationMono_BoldItalic7pt7b.h"
#include "LiberationMono_BoldItalic8pt7b.h"
#include "LiberationMono_BoldItalic9pt7b.h"
#include "LiberationMono_BoldItalic10pt7b.h"
#include "LiberationMono_BoldItalic11pt7b.h"
#include "LiberationMono_BoldItalic12pt7b.h"
#include "LiberationMono_BoldItalic13pt7b.h"
#include "LiberationMono_BoldItalic14pt7b.h"
#include "LiberationMono_BoldItalic15pt7b.h"
#include "LiberationMono_BoldItalic16pt7b.h"
#include "LiberationMono_BoldItalic17pt7b.h"
#include "LiberationMono_BoldItalic18pt7b.h"
#include "LiberationMono_BoldItalic19pt7b.h"
#include "LiberationMono_BoldItalic20pt7b.h"
#include "LiberationMono_BoldItalic21pt7b.h"
#include "LiberationMono_BoldItalic22pt7b.h"
#include "LiberationMono_BoldItalic23pt7b.h"
#include "LiberationMono_BoldItalic24pt7b.h"
#include "LiberationMono_BoldItalic25pt7b.h"
#include "LiberationMono_BoldItalic26pt7b.h"
#include "LiberationMono_BoldItalic27pt7b.h"
#include "LiberationMono_BoldItalic28pt7b.h"
#include "LiberationMono_BoldItalic29pt7b.h"
#include "LiberationMono_BoldItalic30pt7b.h"
#include "LiberationMono_BoldItalic31pt7b.h"
#include "LiberationMono_BoldItalic32pt7b.h"
#include "LiberationMono_BoldItalic33pt7b.h"
#include "LiberationMono_BoldItalic34pt7b.h"
#include "LiberationMono_BoldItalic35pt7b.h"
#include "LiberationMono_BoldItalic36pt7b.h"
#include "LiberationMono_BoldItalic37pt7b.h"
#include "LiberationMono_BoldItalic38pt7b.h"
#include "LiberationMono_BoldItalic39pt7b.h"
#include "LiberationMono_BoldItalic40pt7b.h"
#include "LiberationMono_BoldItalic41pt7b.h"
#include "LiberationMono_BoldItalic42pt7b.h"
#include "LiberationMono_BoldItalic43pt7b.h"
#include "LiberationMono_BoldItalic44pt7b.h"
#include "LiberationMono_BoldItalic45pt7b.h"
#include "LiberationMono_BoldItalic46pt7b.h"
#include "LiberationMono_BoldItalic47pt7b.h"
#include "LiberationMono_BoldItalic48pt7b.h"
#include "LiberationMono_BoldItalic49pt7b.h"
#include "LiberationMono_BoldItalic50pt7b.h"
#include "LiberationMono_BoldItalic51pt7b.h"
#include "LiberationMono_BoldItalic52pt7b.h"
#include "LiberationMono_BoldItalic53pt7b.h"
#include "LiberationMono_BoldItalic54pt7b.h"
#include "LiberationMono_BoldItalic55pt7b.h"
#include "LiberationMono_BoldItalic56pt7b.h"
#include "LiberationMono_BoldItalic57pt7b.h"
#include "LiberationMono_BoldItalic58pt7b.h"
#include "LiberationMono_BoldItalic59pt7b.h"
#include "LiberationMono_BoldItalic60pt7b.h"
#include "LiberationMono_BoldItalic61pt7b.h"
#include "LiberationMono_BoldItalic62pt7b.h"
#include "LiberationMono_BoldItalic63pt7b.h"
#include "LiberationMono_BoldItalic64pt7b.h"
#include "LiberationMono_BoldItalic65pt7b.h"
#include "LiberationMono_BoldItalic66pt7b.h"
#include "LiberationMono_BoldItalic67pt7b.h"
#include "LiberationMono_BoldItalic68pt7b.h"
#include "LiberationMono_BoldItalic69pt7b.h"
#include "LiberationMono_BoldItalic70pt7b.h"
#include "LiberationMono_BoldItalic71pt7b.h"
#include "LiberationMono_BoldItalic72pt7b.h"
