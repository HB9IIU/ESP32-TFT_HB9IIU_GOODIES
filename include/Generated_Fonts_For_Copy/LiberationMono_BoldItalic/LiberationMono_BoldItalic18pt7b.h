#ifndef _LIBERATIONMONO_BOLDITALIC18PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x18, 0xCE, 0x60, 0x19, 0xC0, 0x66, 0xCF, 0xBE,
  0x6C, 0xD9, 0x80, 0x04, 0x40, 0x88, 0x33, 0x1F, 0xF1, 0x98, 0x22, 0x0C,
  0x47, 0xFE, 0x22, 0x0C, 0xC1, 0x10, 0x22, 0x00, 0x02, 0x01, 0xF0, 0x7F,
  0x19, 0x73, 0x20, 0x78, 0x0F, 0xE0, 0x7E, 0x05, 0xCC, 0x9B, 0xA7, 0x3F,
  0xC3, 0xE0, 0x10, 0x02, 0x00, 0x38, 0x26, 0xC4, 0x4C, 0x84, 0xD8, 0x4B,
  0x07, 0x60, 0x0D, 0xC0, 0xA6, 0x12, 0x62, 0x64, 0x46, 0xCC, 0x38, 0x07,
  0x83, 0xE1, 0x98, 0x66, 0x1F, 0x0F, 0x07, 0xCF, 0x36, 0xC7, 0xB1, 0xCF,
  0xFD, 0xE7, 0x6F, 0xED, 0x80, 0x0C, 0x38, 0xE1, 0x87, 0x0C, 0x18, 0x70,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x60, 0x0C, 0x18, 0x38, 0x70,
  0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x0C, 0x38, 0xE0, 0x18,
  0x33, 0xFF, 0xE7, 0x9F, 0x92, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF,
  0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x39, 0x98, 0xCC, 0x60, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x1F,
  0xDC, 0x6C, 0x36, 0x1F, 0x6F, 0xAF, 0x87, 0xC3, 0x73, 0xBF, 0x8F, 0x80,
  0x03, 0x07, 0x8E, 0xC6, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x1F,
  0xFF, 0xF0, 0x0F, 0x87, 0xF3, 0x8C, 0xC3, 0x01, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0F, 0xFB, 0xFE, 0x1F, 0x1F, 0xDC, 0x60, 0x30, 0x38, 0xF8,
  0x7C, 0x07, 0xC3, 0xE3, 0xBF, 0xCF, 0x80, 0x01, 0xC0, 0xF0, 0x7C, 0x36,
  0x1D, 0x86, 0x63, 0x39, 0x8E, 0xFF, 0xFF, 0xF0, 0x30, 0x1C, 0x3F, 0x8F,
  0xE7, 0x01, 0xC0, 0x6F, 0x1F, 0xCE, 0x38, 0x0E, 0x03, 0xB1, 0xCF, 0xE1,
  0xF0, 0x0F, 0x1F, 0xCC, 0x6E, 0x06, 0xF7, 0xFB, 0x8F, 0xC7, 0xE3, 0x73,
  0x9F, 0x87, 0x80, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x30, 0x38, 0x1C, 0x00, 0x1F, 0x1F, 0xDC, 0x6E, 0x37, 0x39, 0xF9,
  0xFD, 0xC7, 0xC3, 0xE3, 0xBF, 0xCF, 0x80, 0x1F, 0x1F, 0xDC, 0xEC, 0x36,
  0x1B, 0x1D, 0xFE, 0x77, 0x03, 0x63, 0xBF, 0x8F, 0x00, 0x39, 0x8C, 0x00,
  0x00, 0x0C, 0xE7, 0x00, 0x0E, 0x18, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x38,
  0x61, 0x83, 0x04, 0x00, 0x00, 0x83, 0xCF, 0x9E, 0x0C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80,
  0x78, 0x0F, 0x81, 0xF0, 0x18, 0x7C, 0xF9, 0xE0, 0x80, 0x00, 0x1F, 0x0F,
  0xE7, 0x1F, 0x87, 0x01, 0x80, 0xE0, 0xE0, 0x70, 0x18, 0x00, 0x03, 0x80,
  0xC0, 0x07, 0x81, 0x08, 0x41, 0x93, 0xD2, 0x9A, 0xB3, 0x54, 0x4A, 0x8B,
  0xB3, 0x56, 0x4A, 0xDA, 0x4D, 0x8C, 0x00, 0xC6, 0x0F, 0x00, 0x03, 0x80,
  0x70, 0x1B, 0x07, 0x60, 0xCC, 0x39, 0x86, 0x31, 0xFE, 0x3F, 0xCE, 0x1D,
  0x83, 0xF0, 0x70, 0x3F, 0xC7, 0xF8, 0xE3, 0x9C, 0x63, 0x1C, 0x7F, 0x1F,
  0xE3, 0x8E, 0x70, 0xCC, 0x39, 0xFE, 0x7F, 0x80, 0x0F, 0x0F, 0xE7, 0x1D,
  0x86, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC3, 0xB8, 0xCF, 0xE1, 0xF0, 0x3F,
  0x87, 0xF8, 0xE7, 0x18, 0x73, 0x0E, 0x61, 0x9C, 0x33, 0x8E, 0x71, 0xCC,
  0x71, 0xFC, 0x7F, 0x00, 0x3F, 0xE7, 0xFC, 0xE0, 0x1C, 0x03, 0x00, 0x7F,
  0x9F, 0xE3, 0x80, 0x70, 0x0C, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF7,
  0x01, 0xC0, 0x70, 0x1F, 0xE7, 0xFB, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0x1F, 0x1F, 0xDC, 0x6C, 0x2E, 0x07, 0x7F, 0x3F, 0x87, 0xC3, 0xF1, 0xBF,
  0xCF, 0x80, 0x38, 0xE7, 0x1C, 0xE3, 0x1C, 0x63, 0x0C, 0x7F, 0x9F, 0xF3,
  0x8E, 0x71, 0x8C, 0x31, 0x8E, 0x71, 0xC0, 0x1F, 0xE7, 0xFC, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x81, 0xFE, 0x3F, 0xC0,
  0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0xC7, 0x73, 0x3F,
  0x8F, 0x00, 0x38, 0xF3, 0x9E, 0x3B, 0xC3, 0x78, 0x3F, 0x03, 0xE0, 0x7F,
  0x07, 0x70, 0x77, 0x06, 0x38, 0x63, 0x8E, 0x1C, 0x38, 0x38, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xFF, 0xFF, 0x38, 0xE7, 0x1C, 0xE7,
  0x96, 0xB6, 0xF4, 0xDF, 0x9B, 0xB3, 0x76, 0x6C, 0xD8, 0x13, 0x06, 0x60,
  0xC0, 0x3C, 0x67, 0x9C, 0xF3, 0x9E, 0x63, 0xCC, 0x7D, 0x9D, 0xB3, 0x3E,
  0x67, 0x8C, 0xF1, 0x9E, 0x71, 0xC0, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0xE1,
  0xF8, 0x6C, 0x1B, 0x0E, 0xC3, 0xB9, 0xCF, 0xE1, 0xF0, 0x3F, 0x87, 0xF8,
  0xE3, 0x9C, 0x73, 0x0E, 0x63, 0x9F, 0xE3, 0xF8, 0x70, 0x0C, 0x01, 0x80,
  0x70, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0xE1, 0xF8, 0x6C, 0x1B, 0x0E,
  0xC3, 0xB9, 0xCF, 0xE1, 0xF0, 0x38, 0x07, 0x01, 0xF0, 0x3C, 0x3F, 0xC7,
  0xFC, 0xE3, 0x98, 0x73, 0x0C, 0x7F, 0x9F, 0xC3, 0xB8, 0x63, 0x8C, 0x71,
  0x8E, 0x70, 0xE0, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x03, 0x80, 0x7E, 0x03,
  0xF0, 0x0E, 0x61, 0xDC, 0x39, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xE1, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x71,
  0xDC, 0x77, 0x1D, 0x86, 0x61, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0x39, 0xCF,
  0xE1, 0xF0, 0xE0, 0xEC, 0x19, 0x87, 0x30, 0xC7, 0x38, 0xE6, 0x1D, 0xC1,
  0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0xE0, 0x7C, 0x1F, 0x03, 0x66,
  0x6C, 0xDD, 0xBB, 0x35, 0x67, 0xAC, 0xF7, 0x1C, 0xE3, 0x9C, 0x63, 0x00,
  0x1C, 0x30, 0xE3, 0x83, 0xB8, 0x1F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xF0, 0x1D, 0x81, 0xCE, 0x1C, 0x31, 0xC1, 0xC0, 0x60, 0xEE, 0x39, 0xC6,
  0x19, 0x83, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x00, 0x1F, 0xE3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0x1F, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xF8, 0xF8, 0x60,
  0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60, 0x1F,
  0x1F, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0xF8, 0xF8, 0x07, 0x03, 0x60, 0xD8, 0x66, 0x11, 0x8C, 0x66,
  0x0D, 0x83, 0xFF, 0xE0, 0xC6, 0x0F, 0x07, 0xE3, 0x98, 0x06, 0x3F, 0x9C,
  0xE6, 0x3B, 0x9E, 0x7F, 0xDE, 0x60, 0x18, 0x06, 0x03, 0x80, 0xEE, 0x3F,
  0xCE, 0x73, 0x0D, 0xC7, 0x71, 0xDC, 0x77, 0x39, 0xFC, 0xEE, 0x00, 0x1F,
  0x1F, 0xDC, 0xFC, 0x0E, 0x06, 0x03, 0x01, 0xCE, 0xFE, 0x3E, 0x00, 0x00,
  0xC0, 0x70, 0x1C, 0xF6, 0x7F, 0x9C, 0xEE, 0x3B, 0x8E, 0xC3, 0x30, 0xCE,
  0x73, 0xFC, 0x77, 0x00, 0x1E, 0x1F, 0x9C, 0xFC, 0x3F, 0xFF, 0xFF, 0x01,
  0xC6, 0xFE, 0x3E, 0x00, 0x0F, 0x8F, 0xCE, 0x1F, 0xEF, 0xF1, 0x80, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x0E, 0xE3, 0xF8, 0xE7, 0x18,
  0xE7, 0x1C, 0xE3, 0x9C, 0x63, 0x9C, 0x7F, 0x87, 0x70, 0x0E, 0x73, 0x87,
  0xF0, 0x78, 0x00, 0x18, 0x06, 0x03, 0x80, 0xEE, 0x37, 0xCE, 0x73, 0x0D,
  0xC7, 0x71, 0xD8, 0x66, 0x19, 0x86, 0xE3, 0x80, 0x03, 0x81, 0x80, 0x03,
  0xE1, 0xF0, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x1F, 0xFF, 0xF8, 0x00,
  0xC0, 0x70, 0x00, 0x3E, 0x0F, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x61, 0xF8, 0xF8, 0x00, 0x30, 0x0C, 0x03,
  0x01, 0xC6, 0x73, 0x19, 0x86, 0xC1, 0xF0, 0xFE, 0x3B, 0x8E, 0x63, 0x1C,
  0xC7, 0x00, 0x1F, 0x0F, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x1F, 0xFF, 0xF8, 0x6C, 0xCF, 0xFD, 0xD9, 0xB3, 0x66, 0x6C,
  0xD9, 0xB3, 0x36, 0x66, 0xCC, 0xD9, 0xB0, 0x33, 0x8D, 0xF3, 0x9C, 0xC7,
  0x71, 0xDC, 0x76, 0x19, 0x86, 0x61, 0xB8, 0xE0, 0x1F, 0x3F, 0xDC, 0xFC,
  0x3E, 0x3E, 0x1F, 0x0F, 0xCE, 0xFE, 0x3E, 0x00, 0x3B, 0x8D, 0xF3, 0x9C,
  0xC3, 0x71, 0xDC, 0x77, 0x1D, 0xCE, 0x7F, 0x3B, 0x8E, 0x03, 0x80, 0xC0,
  0x30, 0x00, 0x1D, 0x9F, 0x67, 0x3B, 0x8E, 0xE3, 0xB0, 0xCC, 0x33, 0x9C,
  0xFF, 0x1D, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0x33, 0x9B, 0xCF, 0x0F,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x00, 0x1F, 0x3F, 0xD8, 0x6E,
  0x07, 0xE1, 0xF8, 0x0D, 0x86, 0xFF, 0x3E, 0x00, 0x18, 0x30, 0xFF, 0xFE,
  0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xFC, 0x7C, 0x61, 0xB0, 0xD8, 0xFC,
  0x7E, 0x3F, 0x1B, 0x0D, 0xCE, 0xFF, 0x3B, 0x80, 0xE0, 0xF8, 0x76, 0x19,
  0x8C, 0x63, 0x1D, 0x87, 0x61, 0xF0, 0x3C, 0x0E, 0x00, 0xC0, 0xD8, 0x1B,
  0x33, 0x6E, 0x4D, 0xD9, 0xEB, 0x39, 0x47, 0x38, 0xE7, 0x18, 0xC0, 0x18,
  0x71, 0xCE, 0x0D, 0xC0, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x81, 0x98, 0x31,
  0xC7, 0x0C, 0x70, 0x66, 0x1C, 0xC3, 0x18, 0xC3, 0x18, 0x76, 0x06, 0xC0,
  0xD0, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x0F, 0x01, 0xC0, 0x00, 0x3F, 0xCF,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x7F, 0xBF, 0xE0, 0x0F,
  0x8F, 0xC7, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x1C, 0x0E,
  0x06, 0x03, 0x01, 0x80, 0xF8, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x0F, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x03,
  0x83, 0xC1, 0x81, 0xC0, 0xC0, 0x60, 0x71, 0xF8, 0xF8, 0x00, 0x78, 0xFF,
  0xE3, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 12, 11, 3, -12 },
  { 9, 7, 6, 11, 3, -13 },
  { 15, 11, 12, 11, 0, -12 },
  { 32, 11, 15, 11, 0, -13 },
  { 53, 12, 12, 11, 0, -12 },
  { 71, 10, 12, 11, 0, -12 },
  { 86, 3, 6, 11, 5, -13 },
  { 89, 7, 17, 11, 3, -13 },
  { 104, 7, 17, 11, 1, -13 },
  { 119, 7, 7, 11, 3, -13 },
  { 126, 9, 10, 11, 1, -11 },
  { 138, 5, 6, 11, 1, -3 },
  { 142, 5, 2, 11, 3, -6 },
  { 144, 3, 3, 11, 3, -3 },
  { 146, 12, 13, 11, 0, -13 },
  { 166, 9, 12, 11, 1, -12 },
  { 180, 9, 12, 11, 0, -12 },
  { 194, 10, 12, 11, 0, -12 },
  { 209, 9, 12, 11, 1, -12 },
  { 223, 10, 12, 11, 0, -12 },
  { 238, 10, 12, 11, 1, -12 },
  { 253, 9, 12, 11, 1, -12 },
  { 267, 9, 12, 11, 2, -12 },
  { 281, 9, 12, 11, 1, -12 },
  { 295, 9, 12, 11, 1, -12 },
  { 309, 5, 10, 11, 3, -10 },
  { 316, 7, 13, 11, 1, -10 },
  { 328, 9, 9, 11, 1, -10 },
  { 339, 9, 7, 11, 1, -9 },
  { 347, 9, 9, 11, 1, -10 },
  { 358, 10, 12, 11, 1, -12 },
  { 373, 11, 15, 11, 0, -13 },
  { 394, 11, 12, 11, -1, -12 },
  { 411, 11, 12, 11, 0, -12 },
  { 428, 10, 12, 11, 1, -12 },
  { 443, 11, 12, 11, 0, -12 },
  { 460, 11, 12, 11, 0, -12 },
  { 477, 10, 12, 11, 1, -12 },
  { 492, 9, 12, 11, 1, -12 },
  { 506, 11, 12, 11, 0, -12 },
  { 523, 11, 12, 11, 0, -12 },
  { 540, 9, 12, 11, 1, -12 },
  { 554, 12, 12, 11, 0, -12 },
  { 572, 8, 12, 11, 1, -12 },
  { 584, 11, 12, 11, 0, -12 },
  { 601, 11, 12, 11, 0, -12 },
  { 618, 10, 12, 11, 1, -12 },
  { 633, 11, 12, 11, 0, -12 },
  { 650, 10, 16, 11, 1, -12 },
  { 670, 11, 12, 11, 0, -12 },
  { 687, 11, 12, 11, 0, -12 },
  { 704, 10, 12, 11, 2, -12 },
  { 719, 10, 12, 11, 1, -12 },
  { 734, 11, 12, 11, 1, -12 },
  { 751, 11, 12, 11, 1, -12 },
  { 768, 13, 12, 11, -1, -12 },
  { 788, 11, 12, 11, 1, -12 },
  { 805, 11, 12, 11, 0, -12 },
  { 822, 8, 17, 11, 2, -13 },
  { 839, 7, 13, 11, 2, -13 },
  { 851, 8, 17, 11, 1, -13 },
  { 868, 10, 8, 11, 0, -12 },
  { 878, 11, 1, 11, -1, 1 },
  { 880, 4, 2, 11, 5, -12 },
  { 881, 10, 10, 11, 0, -10 },
  { 894, 10, 13, 11, 0, -13 },
  { 911, 9, 10, 11, 1, -10 },
  { 923, 10, 13, 11, 1, -13 },
  { 940, 9, 10, 11, 1, -10 },
  { 952, 9, 13, 11, 2, -13 },
  { 967, 11, 14, 11, 0, -10 },
  { 987, 10, 13, 11, 0, -13 },
  { 1004, 9, 13, 11, 0, -13 },
  { 1019, 10, 17, 11, -1, -13 },
  { 1041, 10, 13, 11, 1, -13 },
  { 1058, 9, 13, 11, 0, -13 },
  { 1073, 11, 10, 11, 0, -10 },
  { 1087, 10, 10, 11, 0, -10 },
  { 1100, 9, 10, 11, 1, -10 },
  { 1112, 10, 14, 11, 0, -10 },
  { 1130, 10, 14, 11, 1, -10 },
  { 1148, 9, 10, 11, 1, -10 },
  { 1160, 9, 10, 11, 1, -10 },
  { 1172, 8, 12, 11, 2, -12 },
  { 1184, 9, 10, 11, 1, -10 },
  { 1196, 10, 10, 11, 1, -10 },
  { 1209, 11, 10, 11, 1, -10 },
  { 1223, 12, 10, 11, -1, -10 },
  { 1238, 11, 14, 11, 0, -10 },
  { 1258, 10, 10, 11, 0, -10 },
  { 1271, 9, 17, 11, 2, -13 },
  { 1291, 3, 17, 11, 4, -13 },
  { 1298, 9, 17, 11, 0, -13 },
  { 1318, 9, 3, 11, 1, -7 },
};

const GFXfont LiberationMono_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic18pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _LIBERATIONMONO_BOLDITALIC18PT7B_H_
