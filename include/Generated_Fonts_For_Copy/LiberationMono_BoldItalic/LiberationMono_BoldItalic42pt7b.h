#ifndef _LIBERATIONMONO_BOLDITALIC42PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x1F, 0x9F, 0x0F, 0xCF,
  0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x78, 0x3E, 0x3C, 0x1E, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x3C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0,
  0x70, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x0E, 0x00,
  0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x0E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xE6, 0x7F, 0x0F, 0x86, 0x3F, 0x1F, 0x86, 0x3F,
  0x1F, 0x8E, 0x3C, 0x1F, 0x8C, 0x00, 0x1F, 0x8C, 0x00, 0x1F, 0xEC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1B, 0xFC, 0x00, 0x38, 0xFC, 0x00, 0x30, 0x7C,
  0x18, 0x30, 0x7C, 0xF8, 0x30, 0x7C, 0xFC, 0x30, 0xFC, 0xFC, 0x71, 0xF8,
  0xFE, 0x73, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x3F, 0xC0, 0x1E, 0x07, 0xFE,
  0x03, 0xC0, 0xF1, 0xE0, 0x38, 0x0E, 0x1E, 0x07, 0x01, 0xE1, 0xE0, 0xE0,
  0x1E, 0x1E, 0x1E, 0x01, 0xC1, 0xE3, 0xC0, 0x1C, 0x1C, 0x78, 0x01, 0xC3,
  0xCF, 0x00, 0x1E, 0x79, 0xE0, 0x01, 0xFF, 0x9C, 0x00, 0x0F, 0xF3, 0x80,
  0x00, 0x7C, 0x70, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x01, 0xEF, 0xF8, 0x00,
  0x3D, 0xFF, 0x80, 0x07, 0x9E, 0x3C, 0x00, 0xF3, 0xC3, 0xC0, 0x0E, 0x3C,
  0x3C, 0x01, 0xC3, 0x83, 0x80, 0x38, 0x78, 0x38, 0x07, 0x87, 0x87, 0x80,
  0xF0, 0x78, 0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x3F, 0xF0, 0x78, 0x03,
  0xFE, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE1, 0xF0, 0x01, 0xF7, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1E, 0x1F,
  0xF8, 0x1E, 0x3F, 0x7C, 0x3E, 0x7E, 0x7C, 0x3C, 0x7C, 0x7E, 0x7C, 0xF8,
  0x3E, 0x78, 0xF8, 0x3F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8,
  0x0F, 0xE0, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F,
  0xF8, 0xFE, 0x0F, 0xE0, 0x3E, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C,
  0xF9, 0xF3, 0xE7, 0x8F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x71,
  0xC7, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3E, 0xF0, 0x7C, 0xF8, 0xF8, 0xFC, 0x70, 0x70, 0x10, 0x40, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x00, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x7C,
  0xFD, 0xF9, 0xF3, 0xE7, 0xE7, 0x9F, 0x9F, 0x1E, 0x7E, 0x7C, 0x79, 0xFB,
  0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF,
  0x01, 0xF1, 0xF8, 0x1E, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x40, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F,
  0xC1, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x9F, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xE1, 0xFC, 0x7E, 0x07, 0xE7,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0xF9, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFC, 0x3F, 0x9F, 0xC0, 0xFE, 0xFC,
  0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0x7E,
  0x7E, 0x07, 0xF3, 0xF8, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x01,
  0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x3F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x87, 0xF1, 0xF8,
  0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xF7, 0xC0, 0x7F, 0x3F, 0x00, 0x00,
  0xF8, 0x04, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFE, 0x0F, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFC, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x07, 0x07, 0x9D,
  0xC3, 0x87, 0xF7, 0x70, 0xE3, 0xFD, 0x9C, 0x71, 0xE3, 0xE7, 0x1C, 0x70,
  0x71, 0xC6, 0x38, 0x1C, 0x63, 0x9E, 0x0F, 0x18, 0xE7, 0x03, 0x8E, 0x31,
  0xC0, 0xE3, 0x9C, 0xE0, 0x30, 0xE7, 0x38, 0x1C, 0x31, 0xCE, 0x07, 0x1C,
  0x67, 0x83, 0x87, 0x39, 0xC0, 0xE3, 0x8E, 0x70, 0x78, 0xE3, 0x9C, 0x3C,
  0x70, 0xE7, 0x9F, 0x3C, 0x39, 0xFE, 0xFE, 0x0E, 0x3F, 0x3F, 0x03, 0x87,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x04, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0,
  0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E,
  0x00, 0xFC, 0x7E, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC,
  0x3F, 0xC7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x78, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x03, 0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F,
  0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xC3, 0xFE, 0x0F,
  0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x1F,
  0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7E,
  0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F,
  0x00, 0x41, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xBF, 0x0F, 0xFE, 0xFC, 0x3F, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF8,
  0x07, 0xCF, 0xF0, 0x7F, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x40, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE3,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x1F, 0x81,
  0xFE, 0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x1F, 0xE0, 0x1F, 0x87, 0xF8, 0x03,
  0xF1, 0xFE, 0x00, 0x7C, 0x7F, 0x80, 0x1F, 0x9F, 0xE0, 0x03, 0xF7, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0x80,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xF7, 0x87, 0x78, 0x3D,
  0xE3, 0xFE, 0x0F, 0x78, 0xFF, 0x87, 0xDE, 0x7B, 0xE1, 0xF7, 0x9E, 0xF0,
  0x7D, 0xEF, 0x3C, 0x1E, 0x7B, 0xDF, 0x07, 0x9E, 0xE7, 0xC3, 0xE7, 0xF9,
  0xF0, 0xF9, 0xFE, 0x78, 0x3E, 0x7F, 0x1E, 0x0F, 0x1F, 0xCF, 0x83, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3C, 0x1F, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0x83, 0xFC, 0x07, 0xC1, 0xFF, 0x03, 0xE0, 0xFF, 0x81, 0xF0, 0x7F,
  0xC1, 0xF8, 0x3F, 0xE0, 0xF8, 0x1F, 0xF0, 0x7C, 0x1F, 0x78, 0x3E, 0x0F,
  0xBE, 0x1F, 0x07, 0xDF, 0x1F, 0x83, 0xEF, 0x8F, 0x81, 0xF7, 0xC7, 0xC1,
  0xF9, 0xE3, 0xE0, 0xFC, 0xF9, 0xF0, 0x7C, 0x7D, 0xF8, 0x3E, 0x3E, 0xFC,
  0x1F, 0x1F, 0x7C, 0x1F, 0x8F, 0xBE, 0x0F, 0xC3, 0xDF, 0x07, 0xC1, 0xFF,
  0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0xFC, 0x0F,
  0xF0, 0x7C, 0x07, 0xF8, 0x3E, 0x03, 0xFC, 0x1F, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F,
  0x80, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xC0, 0xFF, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFE, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC,
  0x3F, 0x87, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F,
  0x87, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x01,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x83, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07,
  0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC7, 0xE3,
  0xE1, 0xF1, 0xF8, 0xF0, 0x7C, 0xFE, 0x7C, 0x1F, 0x3F, 0x9F, 0x07, 0xDF,
  0xE7, 0x81, 0xF7, 0xFB, 0xE0, 0x7B, 0xDE, 0xF8, 0x1E, 0xF7, 0xBC, 0x07,
  0xF9, 0xEF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F,
  0x80, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x1E, 0x3C, 0x00, 0x7C,
  0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x03,
  0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1F,
  0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3C, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x8F, 0xE3, 0xFE, 0x3F, 0xFE, 0xFF, 0x7F, 0xF3, 0xF9, 0xFF, 0x8F, 0xE1,
  0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE1, 0xF0, 0x0F, 0xCF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3E, 0xFF, 0xF0, 0x7F,
  0x8F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF0, 0xFF, 0x1F, 0xC1, 0xF7, 0xFF, 0x87, 0xEF, 0xFE, 0x0F,
  0xCF, 0xF8, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07,
  0xEF, 0xE0, 0x1E, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x1F, 0x87, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x7C, 0x07, 0xFE, 0xFC, 0x0F, 0xFE,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xC7, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x3F,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x3F, 0xE7, 0xC0, 0x1F, 0x87,
  0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFC, 0x3F, 0x9F, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x02, 0x07, 0xE0, 0x1F,
  0x3F, 0xC3, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x01, 0xFF, 0x3F, 0x03,
  0xFF, 0xBE, 0x07, 0xFF, 0xBE, 0x0F, 0xE1, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x8F, 0xF0, 0x3F, 0xFD, 0xF0, 0x3F, 0xFB, 0xF0, 0x1F, 0xF3, 0xF0, 0x07,
  0xC3, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xCF, 0xF8, 0x1F, 0x3F, 0xF8, 0x3E, 0xFF,
  0xF0, 0xFF, 0x87, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F,
  0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0x7C, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFD, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x9F, 0x0F, 0x03, 0xEF, 0xC7, 0xE0, 0xFF,
  0xFB, 0xFC, 0x3D, 0xFF, 0xFF, 0x0F, 0xCF, 0xE7, 0xC3, 0xE3, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87,
  0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1F, 0x1F,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x1F,
  0xF0, 0x3E, 0x7F, 0xF0, 0xFD, 0xFF, 0xE1, 0xFF, 0x0F, 0xC3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF0,
  0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFE, 0x1F, 0xC3, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0x8F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x01, 0xF9, 0xFF,
  0x00, 0xF9, 0xFF, 0x80, 0x7D, 0xFF, 0xE0, 0x7F, 0xC7, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF7, 0xFF, 0x01,
  0xF9, 0xFF, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x7C, 0x0F, 0xF3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x1F, 0xC7, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F,
  0xE1, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xF7, 0xC1, 0xFF, 0xBF, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x1F, 0x83, 0xF8, 0xFC, 0x7F, 0xC7, 0xE7, 0xFE, 0x3F, 0x7F,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x0C,
  0x01, 0xFB, 0xF0, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0xFC,
  0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC,
  0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xE3,
  0xFE, 0x3F, 0xFD, 0xF8, 0x7F, 0xE7, 0xC1, 0xFF, 0x1F, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0xF8, 0x78, 0xF8,
  0xFC, 0x3C, 0x7C, 0x7E, 0x3E, 0x3C, 0x7F, 0x1E, 0x1E, 0x3F, 0x8F, 0x0F,
  0x3D, 0xCF, 0x87, 0x9E, 0xF7, 0x83, 0xDE, 0x7B, 0xC1, 0xEF, 0x3F, 0xE0,
  0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xF0, 0x17, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0xFE, 0x00,
};

const GFXglyph LiberationMono_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 12, 28, 25, 7, -28 },
  { 43, 17, 13, 25, 7, -30 },
  { 71, 26, 28, 25, 0, -28 },
  { 162, 24, 35, 25, 1, -31 },
  { 267, 28, 28, 25, -1, -28 },
  { 365, 24, 28, 25, 0, -28 },
  { 449, 7, 13, 25, 12, -30 },
  { 461, 17, 39, 25, 6, -30 },
  { 544, 17, 39, 25, 2, -30 },
  { 627, 16, 16, 25, 7, -30 },
  { 659, 21, 21, 25, 2, -24 },
  { 715, 12, 14, 25, 2, -6 },
  { 736, 13, 5, 25, 6, -13 },
  { 745, 8, 6, 25, 7, -6 },
  { 751, 27, 30, 25, 0, -30 },
  { 853, 22, 28, 25, 2, -28 },
  { 930, 21, 28, 25, 1, -28 },
  { 1004, 24, 28, 25, 0, -28 },
  { 1088, 23, 28, 25, 1, -28 },
  { 1169, 24, 28, 25, 0, -28 },
  { 1253, 24, 28, 25, 1, -28 },
  { 1337, 21, 28, 25, 3, -28 },
  { 1411, 21, 28, 25, 5, -28 },
  { 1485, 23, 28, 25, 1, -28 },
  { 1566, 22, 28, 25, 2, -28 },
  { 1643, 11, 23, 25, 7, -23 },
  { 1675, 15, 31, 25, 3, -23 },
  { 1734, 21, 23, 25, 2, -25 },
  { 1795, 21, 16, 25, 2, -22 },
  { 1837, 21, 23, 25, 2, -25 },
  { 1898, 22, 28, 25, 3, -28 },
  { 1975, 26, 36, 25, 0, -30 },
  { 2092, 25, 28, 25, -2, -28 },
  { 2180, 24, 28, 25, 1, -28 },
  { 2264, 23, 28, 25, 2, -28 },
  { 2345, 24, 28, 25, 1, -28 },
  { 2429, 25, 28, 25, 1, -28 },
  { 2517, 25, 28, 25, 1, -28 },
  { 2605, 22, 28, 25, 2, -28 },
  { 2682, 25, 28, 25, 1, -28 },
  { 2770, 24, 28, 25, 1, -28 },
  { 2854, 22, 28, 25, 2, -28 },
  { 2931, 27, 28, 25, 1, -28 },
  { 3026, 20, 28, 25, 2, -28 },
  { 3096, 26, 28, 25, 0, -28 },
  { 3187, 25, 28, 25, 1, -28 },
  { 3275, 23, 28, 25, 2, -28 },
  { 3356, 24, 28, 25, 1, -28 },
  { 3440, 23, 36, 25, 2, -28 },
  { 3544, 25, 28, 25, 1, -28 },
  { 3632, 25, 28, 25, 0, -28 },
  { 3720, 23, 28, 25, 4, -28 },
  { 3801, 24, 28, 25, 2, -28 },
  { 3885, 25, 28, 25, 3, -28 },
  { 3973, 26, 28, 25, 2, -28 },
  { 4064, 30, 28, 25, -2, -28 },
  { 4169, 25, 28, 25, 3, -28 },
  { 4257, 26, 28, 25, 0, -28 },
  { 4348, 20, 39, 25, 4, -30 },
  { 4446, 15, 30, 25, 6, -30 },
  { 4503, 20, 39, 25, 1, -30 },
  { 4601, 23, 18, 25, 1, -29 },
  { 4653, 26, 2, 25, -3, 3 },
  { 4660, 9, 6, 25, 11, -30 },
  { 4667, 22, 23, 25, 1, -23 },
  { 4731, 23, 30, 25, 1, -30 },
  { 4818, 21, 23, 25, 2, -23 },
  { 4879, 24, 30, 25, 2, -30 },
  { 4969, 21, 23, 25, 2, -23 },
  { 5030, 23, 30, 25, 4, -30 },
  { 5117, 24, 32, 25, 1, -23 },
  { 5213, 23, 30, 25, 1, -30 },
  { 5300, 22, 30, 25, 0, -30 },
  { 5383, 22, 39, 25, -1, -30 },
  { 5491, 25, 30, 25, 1, -30 },
  { 5585, 22, 30, 25, 0, -30 },
  { 5668, 26, 23, 25, -1, -23 },
  { 5743, 23, 23, 25, 1, -23 },
  { 5810, 22, 23, 25, 2, -23 },
  { 5874, 25, 32, 25, -1, -23 },
  { 5974, 22, 32, 25, 2, -23 },
  { 6062, 21, 23, 25, 3, -23 },
  { 6123, 22, 23, 25, 1, -23 },
  { 6187, 17, 29, 25, 5, -29 },
  { 6249, 22, 23, 25, 2, -23 },
  { 6313, 24, 23, 25, 3, -23 },
  { 6382, 25, 23, 25, 2, -23 },
  { 6454, 27, 23, 25, -1, -23 },
  { 6532, 28, 32, 25, -1, -23 },
  { 6644, 22, 23, 25, 1, -23 },
  { 6708, 21, 39, 25, 4, -30 },
  { 6811, 5, 39, 25, 10, -30 },
  { 6836, 22, 39, 25, 0, -30 },
  { 6944, 22, 7, 25, 2, -17 },
};

const GFXfont LiberationMono_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic42pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _LIBERATIONMONO_BOLDITALIC42PT7B_H_
