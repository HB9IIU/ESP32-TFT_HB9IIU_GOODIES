#ifndef _LIBERATIONMONO_BOLDITALIC15PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x66, 0x40, 0xCC, 0xDB, 0x6D, 0xA6, 0x90, 0x08, 0x84,
  0x86, 0x4F, 0xF1, 0x21, 0x13, 0xFC, 0x88, 0x48, 0x24, 0x00, 0x04, 0x0F,
  0x8D, 0x64, 0xB7, 0x81, 0xF0, 0x3C, 0x16, 0xCB, 0x35, 0x9F, 0x02, 0x00,
  0x38, 0x92, 0x44, 0xB1, 0x78, 0x7C, 0x02, 0xC1, 0x58, 0x96, 0x4D, 0x21,
  0xC0, 0x0E, 0x13, 0x13, 0x16, 0x38, 0x79, 0xCB, 0xCE, 0xCE, 0x7B, 0x69,
  0x6C, 0x0C, 0x63, 0x0C, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x80,
  0x18, 0x61, 0xC3, 0x0C, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x63, 0x00, 0x19,
  0x47, 0xCC, 0x79, 0x20, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x36,
  0x4C, 0x80, 0xF8, 0xF0, 0x00, 0x80, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01,
  0x80, 0xC0, 0x20, 0x18, 0x0C, 0x00, 0x1E, 0x66, 0x63, 0xC7, 0xDE, 0xD6,
  0xC6, 0xC4, 0xCC, 0x78, 0x06, 0x1E, 0x2E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0xFF, 0x0F, 0x19, 0xCC, 0x60, 0x60, 0x70, 0x70, 0x70, 0x60, 0x60,
  0x7F, 0x80, 0x1F, 0x19, 0xCC, 0x60, 0x60, 0xC0, 0x18, 0x0D, 0xC6, 0x66,
  0x1E, 0x00, 0x03, 0x07, 0x0F, 0x1B, 0x36, 0x66, 0xFF, 0x06, 0x06, 0x04,
  0x3F, 0x98, 0x0C, 0x0F, 0xC6, 0x30, 0x18, 0x0D, 0xC6, 0x66, 0x1E, 0x00,
  0x1E, 0x26, 0x62, 0x40, 0xFC, 0xE6, 0xC6, 0xC6, 0xCC, 0x78, 0xFE, 0x18,
  0x30, 0xC3, 0x0E, 0x18, 0x70, 0xC1, 0x80, 0x1F, 0x19, 0xCC, 0xE6, 0x61,
  0xC3, 0x19, 0x8C, 0xC6, 0x66, 0x1E, 0x00, 0x3C, 0x66, 0x66, 0xC7, 0xE6,
  0x7E, 0x06, 0xC4, 0xCC, 0x78, 0x6C, 0x00, 0x36, 0x18, 0xC0, 0x00, 0x00,
  0xC6, 0x62, 0x30, 0x02, 0x1D, 0xF7, 0x08, 0x1C, 0x1F, 0x07, 0x02, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x81, 0xC1, 0xE0, 0x70, 0x21, 0xDE, 0x70, 0x80,
  0x3E, 0x67, 0xC3, 0x07, 0x0E, 0x18, 0x30, 0x00, 0x30, 0x70, 0x0F, 0x08,
  0xC8, 0x25, 0xB5, 0x2A, 0x96, 0x9B, 0x4A, 0xAD, 0x5B, 0x20, 0x08, 0xC7,
  0x80, 0x07, 0x03, 0x83, 0xC1, 0x21, 0x98, 0xCC, 0xFE, 0x43, 0x61, 0xF0,
  0xC0, 0x3F, 0x19, 0xCC, 0x6E, 0x67, 0xE3, 0x19, 0x8E, 0xC6, 0x63, 0x7F,
  0x00, 0x1E, 0x67, 0x63, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC, 0x78, 0x3E,
  0x19, 0x8C, 0xEE, 0x36, 0x1B, 0x19, 0x8C, 0xC6, 0x66, 0x7E, 0x00, 0x3F,
  0x98, 0x0C, 0x0E, 0x07, 0xF3, 0x01, 0x80, 0xC0, 0x60, 0x7F, 0x80, 0x3F,
  0x98, 0x0C, 0x06, 0x03, 0x03, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x1E,
  0x66, 0x63, 0xC0, 0xC0, 0xDE, 0xC6, 0xC6, 0xC6, 0x78, 0x31, 0x98, 0xCC,
  0x6E, 0x67, 0xF3, 0x19, 0x8C, 0xCE, 0x67, 0x63, 0x00, 0x3F, 0x86, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x3F, 0x00, 0x1F, 0x06, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0xCC, 0xCC, 0x70, 0x31, 0xCC, 0xE3, 0x71, 0xF8,
  0x7C, 0x1F, 0x06, 0xE1, 0x98, 0x67, 0x31, 0xC0, 0x30, 0xE1, 0x83, 0x06,
  0x0C, 0x38, 0x70, 0xC1, 0xFC, 0x31, 0x9D, 0xDE, 0xEF, 0xF7, 0xDA, 0xE9,
  0x65, 0x86, 0xC3, 0x61, 0x80, 0x39, 0x9C, 0xCE, 0x6D, 0x26, 0xB3, 0x79,
  0xBC, 0xDE, 0x4F, 0x63, 0x00, 0x1E, 0x67, 0x63, 0xC3, 0xC3, 0xC7, 0xC6,
  0xC6, 0xCC, 0x78, 0x3F, 0x18, 0xCC, 0x6E, 0x36, 0x33, 0xF1, 0x80, 0xC0,
  0x60, 0x60, 0x00, 0x1E, 0x67, 0x63, 0xC3, 0xC3, 0xC7, 0xC6, 0xC6, 0xCC,
  0x78, 0x30, 0x30, 0x1C, 0x3F, 0x18, 0xCC, 0x6E, 0x37, 0x33, 0xF1, 0x98,
  0xCC, 0x67, 0x61, 0x80, 0x1F, 0x19, 0xDC, 0x6E, 0x03, 0xE0, 0x78, 0x0D,
  0x86, 0xE3, 0x3E, 0x00, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x00, 0x63, 0x63, 0x63, 0xE7, 0xC6, 0xC6, 0xC6, 0xC6,
  0xCC, 0x78, 0xC1, 0xF1, 0x98, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x78,
  0x18, 0x00, 0xC1, 0xE0, 0xF0, 0xDB, 0x6D, 0xB7, 0xD3, 0xB9, 0xDC, 0xCC,
  0x66, 0x00, 0x18, 0xC3, 0x38, 0x36, 0x07, 0x80, 0x60, 0x1C, 0x06, 0xC1,
  0xD8, 0x73, 0x8C, 0x30, 0xE3, 0xB1, 0x99, 0x87, 0x83, 0xC1, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x00, 0x3F, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0,
  0xE0, 0x60, 0x7F, 0x80, 0x1E, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x60,
  0xC1, 0x83, 0x06, 0x1F, 0x00, 0xC1, 0x06, 0x18, 0x20, 0xC3, 0x04, 0x18,
  0x60, 0x80, 0x1F, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x78, 0x0E, 0x0E, 0x1A, 0x33, 0x23, 0x63, 0x41, 0xFF,
  0x80, 0xCC, 0x1E, 0x33, 0x03, 0x3F, 0x66, 0xE6, 0xEE, 0x77, 0x30, 0x30,
  0x30, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x63, 0x66, 0xDC, 0x3C, 0xCF, 0x1E,
  0x0C, 0x18, 0xF3, 0x3C, 0x03, 0x03, 0x03, 0x3B, 0x66, 0xC6, 0xC6, 0xC6,
  0xCE, 0xCC, 0xFC, 0x3C, 0xCF, 0x1F, 0xFC, 0x18, 0x33, 0x3C, 0x0F, 0x0C,
  0x06, 0x1F, 0xE3, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x00, 0x1D,
  0x99, 0xD8, 0xCC, 0x66, 0x33, 0x19, 0x9C, 0xFC, 0x06, 0x63, 0x1E, 0x00,
  0x30, 0x30, 0x30, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x63, 0x63, 0xC6, 0x06,
  0x00, 0x00, 0x3C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0xFF, 0x07, 0x00,
  0x00, 0x3E, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0xF0,
  0x18, 0x18, 0x0C, 0x06, 0x73, 0x71, 0xE1, 0xF0, 0xF8, 0x66, 0x33, 0x19,
  0xC0, 0x1E, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0xFF,
  0x7B, 0xB6, 0xDB, 0x69, 0x3C, 0x96, 0xCB, 0x6D, 0xB6, 0x3F, 0x33, 0x73,
  0x63, 0x63, 0x63, 0x63, 0xC6, 0x3C, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0x3C,
  0x3F, 0x33, 0x73, 0x63, 0x63, 0x63, 0x66, 0xDC, 0xC0, 0xC0, 0xC0, 0x3B,
  0x66, 0xC6, 0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0x0C, 0x0C, 0x0C, 0x6F, 0x70,
  0x70, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x1E, 0x33, 0x20, 0x3E, 0x1F, 0x03,
  0x62, 0x7C, 0x30, 0x8F, 0xD8, 0x63, 0x0C, 0x30, 0xC3, 0xE0, 0x67, 0xE6,
  0xC6, 0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0xC3, 0x61, 0xB9, 0x8D, 0x86, 0xC3,
  0xC1, 0xE0, 0xE0, 0x81, 0xC0, 0xA6, 0xD7, 0x4A, 0xE7, 0x73, 0x31, 0x98,
  0x31, 0x99, 0x87, 0x83, 0x81, 0xC1, 0xF1, 0x99, 0x8E, 0x61, 0xB0, 0xCC,
  0xC6, 0xC3, 0x61, 0xA0, 0xF0, 0x30, 0x18, 0x18, 0x38, 0x00, 0x3F, 0x07,
  0x0E, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0x0F, 0x18, 0x18, 0x18, 0x10, 0x30,
  0xC0, 0x70, 0x30, 0x20, 0x60, 0x60, 0x60, 0x38, 0xFF, 0xFC, 0x1E, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x07, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0xF0,
  0xF1, 0x1E,
};

const GFXglyph LiberationMono_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 10, 9, 3, -10 },
  { 6, 6, 5, 9, 3, -11 },
  { 10, 9, 10, 9, 0, -10 },
  { 22, 9, 12, 9, 0, -11 },
  { 36, 10, 10, 9, 0, -10 },
  { 49, 8, 10, 9, 0, -10 },
  { 59, 3, 5, 9, 4, -11 },
  { 61, 6, 14, 9, 2, -11 },
  { 72, 6, 14, 9, 1, -11 },
  { 83, 6, 6, 9, 2, -11 },
  { 88, 7, 7, 9, 1, -9 },
  { 95, 4, 5, 9, 1, -2 },
  { 98, 5, 1, 9, 2, -5 },
  { 99, 2, 2, 9, 3, -2 },
  { 100, 10, 11, 9, 0, -11 },
  { 114, 8, 10, 9, 1, -10 },
  { 124, 8, 10, 9, 0, -10 },
  { 134, 9, 10, 9, 0, -10 },
  { 146, 9, 10, 9, 0, -10 },
  { 158, 8, 10, 9, 0, -10 },
  { 168, 9, 10, 9, 0, -10 },
  { 180, 8, 10, 9, 1, -10 },
  { 190, 7, 10, 9, 2, -10 },
  { 199, 9, 10, 9, 0, -10 },
  { 211, 8, 10, 9, 1, -10 },
  { 221, 3, 8, 9, 3, -8 },
  { 224, 5, 11, 9, 1, -8 },
  { 231, 7, 9, 9, 1, -10 },
  { 239, 7, 5, 9, 1, -7 },
  { 244, 7, 9, 9, 1, -10 },
  { 252, 8, 10, 9, 1, -10 },
  { 262, 9, 13, 9, 0, -11 },
  { 277, 9, 10, 9, -1, -10 },
  { 289, 9, 10, 9, 0, -10 },
  { 301, 8, 10, 9, 1, -10 },
  { 311, 9, 10, 9, 0, -10 },
  { 323, 9, 10, 9, 0, -10 },
  { 335, 9, 10, 9, 0, -10 },
  { 347, 8, 10, 9, 1, -10 },
  { 357, 9, 10, 9, 0, -10 },
  { 369, 9, 10, 9, 0, -10 },
  { 381, 8, 10, 9, 1, -10 },
  { 391, 10, 10, 9, 0, -10 },
  { 404, 7, 10, 9, 1, -10 },
  { 413, 9, 10, 9, 0, -10 },
  { 425, 9, 10, 9, 0, -10 },
  { 437, 8, 10, 9, 1, -10 },
  { 447, 9, 10, 9, 0, -10 },
  { 459, 8, 13, 9, 1, -10 },
  { 472, 9, 10, 9, 0, -10 },
  { 484, 9, 10, 9, 0, -10 },
  { 496, 9, 10, 9, 1, -10 },
  { 508, 8, 10, 9, 1, -10 },
  { 518, 9, 10, 9, 1, -10 },
  { 530, 9, 10, 9, 1, -10 },
  { 542, 11, 10, 9, -1, -10 },
  { 556, 9, 10, 9, 1, -10 },
  { 568, 9, 10, 9, 0, -10 },
  { 580, 7, 14, 9, 1, -11 },
  { 593, 6, 11, 9, 2, -11 },
  { 602, 8, 14, 9, 0, -11 },
  { 616, 8, 7, 9, 0, -10 },
  { 623, 9, 1, 9, -1, 1 },
  { 625, 3, 2, 9, 4, -11 },
  { 626, 8, 8, 9, 0, -8 },
  { 634, 8, 11, 9, 0, -11 },
  { 645, 7, 8, 9, 1, -8 },
  { 652, 8, 11, 9, 1, -11 },
  { 663, 7, 8, 9, 1, -8 },
  { 670, 9, 11, 9, 1, -11 },
  { 683, 9, 11, 9, 0, -8 },
  { 696, 8, 11, 9, 0, -11 },
  { 707, 8, 11, 9, 0, -11 },
  { 718, 8, 14, 9, 0, -11 },
  { 732, 9, 11, 9, 0, -11 },
  { 745, 8, 11, 9, 0, -11 },
  { 756, 9, 8, 9, 0, -8 },
  { 765, 8, 8, 9, 0, -8 },
  { 773, 7, 8, 9, 1, -8 },
  { 780, 8, 11, 9, 0, -8 },
  { 791, 8, 11, 9, 1, -8 },
  { 802, 8, 8, 9, 1, -8 },
  { 810, 8, 8, 9, 0, -8 },
  { 818, 6, 10, 9, 2, -10 },
  { 826, 8, 8, 9, 1, -8 },
  { 834, 9, 8, 9, 1, -8 },
  { 843, 9, 8, 9, 1, -8 },
  { 852, 9, 8, 9, 0, -8 },
  { 861, 9, 11, 9, 0, -8 },
  { 874, 8, 8, 9, 0, -8 },
  { 882, 8, 14, 9, 1, -11 },
  { 896, 1, 14, 9, 4, -11 },
  { 898, 8, 14, 9, 0, -11 },
  { 912, 8, 2, 9, 1, -6 },
};

const GFXfont LiberationMono_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic15pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _LIBERATIONMONO_BOLDITALIC15PT7B_H_
