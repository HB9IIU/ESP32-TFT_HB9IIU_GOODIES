#ifndef _LIBERATIONMONO_BOLDITALIC39PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x80, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xE7, 0x87, 0xDF, 0x0F,
  0xBE, 0x1F, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x03, 0x80,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x0C, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x30, 0x38, 0x00, 0x70, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xF3, 0x7F, 0x1F, 0x8C, 0x7C, 0x7C, 0x31, 0xF1, 0xF1, 0x80,
  0x07, 0xC6, 0x00, 0x1F, 0xD8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0x7F, 0x00, 0x0C,
  0x7E, 0x00, 0x61, 0xFB, 0xE1, 0x87, 0xCF, 0x86, 0x1F, 0x3E, 0x18, 0x7C,
  0xFE, 0x67, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF0,
  0x03, 0xC1, 0xFE, 0x00, 0xE0, 0xFF, 0xC0, 0x70, 0x3C, 0xF0, 0x38, 0x1E,
  0x1C, 0x1C, 0x07, 0x07, 0x0E, 0x01, 0xC3, 0xC7, 0x80, 0x70, 0xE3, 0xC0,
  0x1C, 0x39, 0xE0, 0x07, 0x1E, 0x70, 0x01, 0xFF, 0x38, 0x00, 0x7F, 0x9C,
  0x00, 0x0F, 0xCE, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x03, 0xDF, 0xE0, 0x01,
  0xEF, 0xFC, 0x00, 0xF3, 0x8F, 0x00, 0x39, 0xE3, 0xC0, 0x1C, 0x70, 0xF0,
  0x0E, 0x1C, 0x3C, 0x07, 0x07, 0x0E, 0x03, 0x83, 0xC3, 0x81, 0xE0, 0x71,
  0xE0, 0xF0, 0x1F, 0xF0, 0x78, 0x07, 0xF8, 0x1C, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3C, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE7, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x3C, 0x7F,
  0xC1, 0xE3, 0xFF, 0x87, 0x9F, 0x3E, 0x3C, 0x78, 0x7C, 0xF3, 0xE1, 0xF7,
  0x8F, 0x83, 0xFE, 0x3C, 0x07, 0xF0, 0xF0, 0x1F, 0x83, 0xE0, 0x7F, 0x0F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF9, 0xFC, 0x7F, 0x01, 0xE0, 0x3E,
  0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x81,
  0x0E, 0x13, 0x9C, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x07, 0xC0, 0x1F,
  0xC0, 0x7F, 0xC1, 0xE7, 0x87, 0x8F, 0x87, 0x0E, 0x04, 0x10, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x0E, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x7C, 0xF9, 0xF7, 0xEF, 0xDF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF1,
  0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x7E, 0x01, 0xF7, 0xC7, 0x9F, 0x7C, 0xF3, 0xF7, 0xCF, 0x3F, 0xFC, 0xF3,
  0xEF, 0xCF, 0x3E, 0xFC, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0xFC, 0x0F, 0x87, 0xE3, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x1F, 0xF8, 0x0F, 0xFF, 0x81, 0xFD, 0xF8, 0x1F, 0x9F, 0x01, 0xC1, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xE1, 0xF8, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF8, 0x3F,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF9,
  0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x01, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFE, 0x1F, 0xC3, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x3F,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xC3,
  0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE3,
  0xF0, 0x7E, 0xFF, 0x87, 0xDF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7E,
  0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xE7,
  0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC,
  0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x83, 0xF8, 0x7E, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xF0,
  0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7E,
  0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xBE, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0xF8,
  0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x3E, 0x3F,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x1F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x01,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x78, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x87, 0xF7, 0xE0, 0x3F, 0x7C,
  0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x06, 0x07, 0x00, 0x07, 0x06, 0x0F,
  0x3F, 0x0E, 0x1F, 0xB7, 0x0C, 0x71, 0xF7, 0x1C, 0x71, 0xE7, 0x18, 0xE1,
  0xE7, 0x39, 0xC1, 0xE7, 0x39, 0xC1, 0xC7, 0x33, 0x81, 0xC6, 0x73, 0x81,
  0xC6, 0x73, 0x83, 0x8E, 0x67, 0x03, 0x8E, 0x67, 0x03, 0x0C, 0xE7, 0x07,
  0x1C, 0xE7, 0x07, 0x18, 0xE7, 0x0E, 0x38, 0xE7, 0x1E, 0x30, 0xE7, 0x36,
  0x60, 0xE7, 0xE7, 0xE0, 0xE3, 0xC3, 0x80, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x38, 0x03, 0x80, 0x3E, 0x0F, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x1E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x0F, 0x83, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8,
  0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x0F, 0xBF, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x81, 0xFC, 0x3E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xE0, 0x3F,
  0x8F, 0x80, 0x7E, 0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x00, 0x7E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x8F, 0xC0, 0xFC, 0xFC,
  0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0x83, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0E, 0x3E, 0x00, 0xFD, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFC, 0x7F, 0x0F, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0x87, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E,
  0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7C,
  0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F,
  0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x3C, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xFF, 0x7E, 0x1F, 0xFB, 0xE1,
  0xFF, 0xDF, 0x0F, 0xFE, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7F, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8,
  0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x80, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x60, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x87, 0xE0,
  0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xF0, 0x3F, 0x80, 0xF8, 0x3F, 0x80, 0x7C,
  0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x1F, 0x3F, 0x80, 0x0F,
  0xBF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF8, 0x07, 0xC0, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xF0, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0E, 0xF0, 0x7F, 0x87, 0xF0, 0x3F,
  0xC7, 0xF8, 0x3F, 0xE3, 0xBC, 0x1E, 0xF3, 0xDE, 0x0F, 0x79, 0xDF, 0x07,
  0xBD, 0xEF, 0x83, 0xDE, 0xF7, 0x83, 0xEF, 0x73, 0xC1, 0xE3, 0xF9, 0xE0,
  0xF1, 0xF9, 0xF0, 0x78, 0xFC, 0xF8, 0x3C, 0x7C, 0x78, 0x1E, 0x3E, 0x3C,
  0x1F, 0x1E, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x3E, 0x1F, 0xC0, 0x7C, 0x3F, 0x81, 0xF0, 0x7F,
  0x83, 0xE0, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F, 0xF8,
  0x7C, 0x1F, 0xF8, 0xF8, 0x3D, 0xF1, 0xF0, 0x7B, 0xE3, 0xE1, 0xF3, 0xC7,
  0xC3, 0xE7, 0x8F, 0x07, 0xCF, 0x3E, 0x0F, 0x9F, 0x7C, 0x1F, 0x3E, 0xF8,
  0x7C, 0x3D, 0xF0, 0xF8, 0x7B, 0xC1, 0xF0, 0xF7, 0x83, 0xE1, 0xFF, 0x07,
  0xC3, 0xFE, 0x1F, 0x07, 0xFC, 0x3E, 0x07, 0xF8, 0x7C, 0x0F, 0xE0, 0xF8,
  0x1F, 0xC1, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0xF8,
  0x7E, 0x07, 0xE1, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x81, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x07,
  0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x1F, 0x8F,
  0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0xF8,
  0x7E, 0x07, 0xE1, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xF8, 0x1F, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8,
  0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xF1, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7E, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xCF, 0xE0, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0x87,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F,
  0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x78, 0x7C,
  0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0x78, 0xF8, 0xF8, 0x79, 0xFC, 0xF0,
  0x79, 0xFC, 0xF0, 0xFB, 0xFD, 0xF0, 0xFB, 0xFD, 0xE0, 0xFB, 0xBD, 0xE0,
  0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x0F,
  0xC3, 0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0x7C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x7C, 0x07,
  0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1F,
  0x1E, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x00,
  0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x83, 0xE1,
  0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xF0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0xCF, 0xFF, 0x7C, 0xFF, 0xE7, 0xF7, 0xFC,
  0x7F, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x0F, 0x9F, 0xE0, 0xFD, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xC7, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01,
  0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xE1, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3E, 0x7F, 0x81, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0xFE, 0x1F,
  0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x7E, 0x03, 0xFC,
  0xF8, 0x0F, 0xFD, 0xF0, 0x3F, 0xFB, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F,
  0x87, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x1F, 0x03, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xEF, 0x80, 0xFF, 0x9F, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xE0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7C,
  0xFE, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0xC3,
  0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7F,
  0x1F, 0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0xFE, 0x07, 0xF9, 0xF0, 0x0F, 0x87,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x1E, 0x03, 0xE0, 0xF8, 0x1F, 0x83,
  0xF0, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x0F, 0x9F, 0xF0, 0xFD,
  0xFF, 0x87, 0xDF, 0xFE, 0x3F, 0xC7, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC,
  0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x7E,
  0x01, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xF9, 0xF8, 0x03,
  0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0x0F, 0x1E, 0x1E, 0x0F, 0x7E, 0x7F, 0x0F, 0x7F, 0xFF, 0x0F, 0x9F,
  0x9F, 0x0F, 0x9F, 0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x1E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x0F, 0x87, 0xC0, 0xFC, 0xFF, 0x87, 0xCF, 0xFC,
  0x3E, 0xFF, 0xF1, 0xFE, 0x3F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0,
  0x3F, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC,
  0x3F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x0F,
  0xCF, 0xF0, 0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x8F, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00,
  0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xF3, 0xFE, 0x03, 0xE3, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0xFC, 0x0F,
  0xF3, 0xE0, 0x7F, 0xEF, 0x83, 0xFF, 0xBE, 0x1F, 0xC7, 0xF8, 0x7E, 0x0F,
  0xE3, 0xF0, 0x3F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x03, 0xF8, 0x7E, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0x7C,
  0x0F, 0xFB, 0xF0, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xF1, 0xF1, 0xFE, 0x1F, 0x3F, 0xE1,
  0xF7, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x1F, 0x0F, 0x80,
  0x7C, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x3E,
  0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7,
  0xC0, 0x7E, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xFE, 0xF8, 0xFF, 0xCF,
  0x87, 0xF8, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF,
  0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xF0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x0F,
  0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDE, 0x0F, 0x0F, 0x3C, 0x3E, 0x1E,
  0x78, 0x7C, 0x78, 0xF1, 0xF8, 0xF1, 0xE3, 0xF1, 0xE3, 0xCE, 0xE7, 0x87,
  0x9D, 0xCF, 0x0F, 0x7B, 0x9E, 0x1E, 0xE7, 0x78, 0x3F, 0xCF, 0xF0, 0x7F,
  0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0x80,
  0xF8, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80,
  0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x0B, 0xFF, 0xC1, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE8, 0x0F, 0xFF, 0x00, 0x0F, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 11, 26, 23, 7, -26 },
  { 37, 15, 12, 23, 7, -28 },
  { 60, 24, 26, 23, 0, -26 },
  { 138, 22, 32, 23, 1, -29 },
  { 226, 26, 26, 23, -1, -26 },
  { 311, 22, 26, 23, 0, -26 },
  { 383, 7, 12, 23, 11, -28 },
  { 394, 15, 36, 23, 6, -28 },
  { 462, 16, 36, 23, 2, -28 },
  { 534, 15, 15, 23, 6, -28 },
  { 563, 19, 20, 23, 2, -23 },
  { 611, 11, 13, 23, 2, -6 },
  { 629, 12, 5, 23, 6, -12 },
  { 637, 7, 6, 23, 7, -6 },
  { 643, 25, 28, 23, 0, -28 },
  { 731, 20, 26, 23, 2, -26 },
  { 796, 20, 26, 23, 1, -26 },
  { 861, 23, 26, 23, 0, -26 },
  { 936, 22, 26, 23, 1, -26 },
  { 1008, 22, 26, 23, 0, -26 },
  { 1080, 22, 26, 23, 1, -26 },
  { 1152, 20, 26, 23, 2, -26 },
  { 1217, 20, 26, 23, 4, -26 },
  { 1282, 22, 26, 23, 1, -26 },
  { 1354, 20, 26, 23, 2, -26 },
  { 1419, 9, 21, 23, 7, -21 },
  { 1443, 14, 28, 23, 3, -21 },
  { 1492, 19, 21, 23, 2, -23 },
  { 1542, 19, 15, 23, 2, -20 },
  { 1578, 19, 21, 23, 2, -23 },
  { 1628, 20, 26, 23, 3, -26 },
  { 1693, 24, 33, 23, 0, -28 },
  { 1792, 23, 26, 23, -2, -26 },
  { 1867, 22, 26, 23, 1, -26 },
  { 1939, 21, 26, 23, 2, -26 },
  { 2008, 22, 26, 23, 1, -26 },
  { 2080, 23, 26, 23, 1, -26 },
  { 2155, 23, 26, 23, 1, -26 },
  { 2230, 21, 26, 23, 2, -26 },
  { 2299, 23, 26, 23, 1, -26 },
  { 2374, 22, 26, 23, 1, -26 },
  { 2446, 21, 26, 23, 1, -26 },
  { 2515, 25, 26, 23, 1, -26 },
  { 2597, 18, 26, 23, 2, -26 },
  { 2656, 25, 26, 23, 0, -26 },
  { 2738, 23, 26, 23, 1, -26 },
  { 2813, 22, 26, 23, 1, -26 },
  { 2885, 22, 26, 23, 1, -26 },
  { 2957, 22, 34, 23, 1, -26 },
  { 3051, 23, 26, 23, 1, -26 },
  { 3126, 23, 26, 23, 0, -26 },
  { 3201, 22, 26, 23, 3, -26 },
  { 3273, 22, 26, 23, 2, -26 },
  { 3345, 23, 26, 23, 3, -26 },
  { 3420, 24, 26, 23, 2, -26 },
  { 3498, 28, 26, 23, -2, -26 },
  { 3589, 23, 26, 23, 3, -26 },
  { 3664, 24, 26, 23, 0, -26 },
  { 3742, 18, 36, 23, 4, -28 },
  { 3823, 15, 28, 23, 5, -28 },
  { 3876, 19, 36, 23, 1, -28 },
  { 3962, 21, 17, 23, 1, -27 },
  { 4007, 24, 2, 23, -3, 2 },
  { 4013, 9, 5, 23, 10, -28 },
  { 4019, 20, 21, 23, 1, -21 },
  { 4072, 21, 28, 23, 1, -28 },
  { 4146, 20, 21, 23, 2, -21 },
  { 4199, 23, 28, 23, 1, -28 },
  { 4280, 20, 21, 23, 2, -21 },
  { 4333, 21, 28, 23, 4, -28 },
  { 4407, 22, 29, 23, 1, -21 },
  { 4487, 21, 28, 23, 1, -28 },
  { 4561, 21, 28, 23, 0, -28 },
  { 4635, 21, 36, 23, -1, -28 },
  { 4730, 23, 28, 23, 1, -28 },
  { 4811, 21, 28, 23, 0, -28 },
  { 4885, 24, 21, 23, -1, -21 },
  { 4948, 21, 21, 23, 1, -21 },
  { 5004, 21, 21, 23, 1, -21 },
  { 5060, 23, 29, 23, -1, -21 },
  { 5144, 22, 29, 23, 1, -21 },
  { 5224, 20, 21, 23, 3, -21 },
  { 5277, 21, 21, 23, 1, -21 },
  { 5333, 17, 26, 23, 4, -26 },
  { 5389, 20, 21, 23, 2, -21 },
  { 5442, 22, 21, 23, 3, -21 },
  { 5500, 23, 21, 23, 2, -21 },
  { 5561, 25, 21, 23, -1, -21 },
  { 5627, 26, 29, 23, -1, -21 },
  { 5722, 21, 21, 23, 1, -21 },
  { 5778, 20, 36, 23, 3, -28 },
  { 5868, 5, 37, 23, 9, -28 },
  { 5892, 20, 36, 23, 0, -28 },
  { 5982, 21, 6, 23, 2, -16 },
};

const GFXfont LiberationMono_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic39pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _LIBERATIONMONO_BOLDITALIC39PT7B_H_
