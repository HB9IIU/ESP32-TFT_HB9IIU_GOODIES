#ifndef _LIBERATIONMONO_BOLDITALIC7PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xB4, 0x27, 0x5F, 0xA0, 0x37, 0x63, 0xE4, 0x46, 0x98,
  0xEB, 0x00, 0x25, 0x6A, 0xF0, 0xC0, 0x4A, 0x49, 0x00, 0x24, 0x92, 0x80,
  0x48, 0x00, 0x2F, 0x20, 0x60, 0xC0, 0x80, 0x11, 0x08, 0x88, 0x00, 0x25,
  0x79, 0x60, 0x26, 0x22, 0xF0, 0x35, 0x24, 0xF0, 0x35, 0x21, 0xE0, 0x13,
  0x5F, 0x20, 0x74, 0x71, 0xE0, 0x34, 0x79, 0x60, 0xE5, 0x48, 0x35, 0x69,
  0xE0, 0x25, 0x71, 0xE0, 0x42, 0x42, 0x80, 0x3C, 0x60, 0xF0, 0xF0, 0xC3,
  0x68, 0x75, 0xC8, 0x7B, 0xFB, 0xEE, 0x26, 0x5F, 0x90, 0x75, 0x69, 0xF0,
  0x35, 0x88, 0x60, 0x65, 0x59, 0xE0, 0x74, 0x78, 0xF0, 0x74, 0x74, 0x80,
  0x25, 0xB9, 0x60, 0x55, 0x79, 0xA0, 0x72, 0x22, 0xE0, 0x31, 0x12, 0xE0,
  0x5B, 0x99, 0x4B, 0x00, 0x44, 0x44, 0xF0, 0x55, 0xB9, 0x90, 0x55, 0x7B,
  0xA0, 0x25, 0x99, 0xE0, 0x65, 0x78, 0x80, 0x25, 0x99, 0xE6, 0x75, 0x7A,
  0x90, 0x35, 0x61, 0xE0, 0xF4, 0x44, 0x80, 0x55, 0x59, 0xE0, 0x9A, 0xAC,
  0xC0, 0x0C, 0xAD, 0xEA, 0x00, 0x52, 0x88, 0xC9, 0x00, 0x9A, 0xC4, 0x80,
  0x71, 0x24, 0xF0, 0x6A, 0x49, 0x00, 0x91, 0x24, 0x62, 0x22, 0x26, 0x25,
  0x90, 0x78, 0x80, 0x61, 0xEF, 0x47, 0x59, 0xE0, 0x64, 0x86, 0x17, 0x59,
  0xE0, 0x65, 0xAE, 0x7E, 0x48, 0x75, 0x97, 0xE0, 0x47, 0x59, 0x90, 0x26,
  0x22, 0xF0, 0x06, 0x22, 0x2C, 0x45, 0x66, 0xA0, 0x62, 0x22, 0xF0, 0x7B,
  0xBD, 0x75, 0x99, 0x75, 0x9E, 0x75, 0x9E, 0x80, 0x75, 0x9E, 0x20, 0x74,
  0x44, 0x74, 0x3E, 0x5E, 0x4C, 0x55, 0x9E, 0x55, 0x66, 0x85, 0xBD, 0x40,
  0x56, 0x6A, 0x55, 0x66, 0xC0, 0x72, 0x4E, 0x6A, 0x49, 0x80, 0xFE, 0x62,
  0x22, 0x2C, 0xF0,
};

const GFXglyph LiberationMono_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 6, 4, 0, -5 },
  { 10, 5, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 3, 6, 4, 1, -5 },
  { 21, 3, 6, 4, 0, -5 },
  { 24, 3, 3, 4, 1, -5 },
  { 26, 4, 3, 4, 0, -4 },
  { 28, 2, 2, 4, 0, -1 },
  { 29, 2, 1, 4, 1, -2 },
  { 30, 1, 1, 4, 1, -1 },
  { 31, 5, 5, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 3, 5, 4, 1, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 2, 5, 4, 1, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 3, 5, 4, 1, -5 },
  { 75, 4, 6, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 5, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 6, 4, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 1, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 4, 5, 4, 1, -5 },
  { 145, 5, 5, 4, 0, -5 },
  { 149, 5, 5, 4, 0, -5 },
  { 153, 4, 5, 4, 1, -5 },
  { 156, 4, 5, 4, 0, -5 },
  { 159, 3, 6, 4, 1, -5 },
  { 162, 3, 5, 4, 1, -5 },
  { 164, 4, 6, 4, 0, -5 },
  { 167, 4, 3, 4, 0, -5 },
  { 169, 5, 1, 4, -1, 0 },
  { 170, 1, 1, 4, 2, -5 },
  { 171, 4, 4, 4, 0, -4 },
  { 173, 4, 5, 4, 0, -5 },
  { 176, 4, 4, 4, 0, -4 },
  { 178, 4, 5, 4, 0, -5 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 3, 5, 4, 1, -5 },
  { 185, 4, 5, 4, 0, -4 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 4, 5, 4, 0, -5 },
  { 194, 4, 6, 4, 0, -5 },
  { 197, 4, 5, 4, 0, -5 },
  { 200, 4, 5, 4, 0, -5 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 5, 4, 0, -4 },
  { 212, 4, 5, 4, 0, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 3, 5, 4, 1, -5 },
  { 221, 4, 4, 4, 0, -4 },
  { 223, 4, 4, 4, 0, -4 },
  { 225, 5, 4, 4, 0, -4 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 5, 4, 0, -4 },
  { 233, 4, 4, 4, 0, -4 },
  { 235, 3, 6, 4, 1, -5 },
  { 238, 1, 7, 4, 2, -5 },
  { 239, 4, 6, 4, 0, -5 },
  { 242, 4, 1, 4, 0, -3 },
};

const GFXfont LiberationMono_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic7pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _LIBERATIONMONO_BOLDITALIC7PT7B_H_
