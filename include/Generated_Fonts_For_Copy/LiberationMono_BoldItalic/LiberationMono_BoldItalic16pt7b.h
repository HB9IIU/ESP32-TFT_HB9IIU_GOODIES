#ifndef _LIBERATIONMONO_BOLDITALIC16PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x36, 0x66, 0x66, 0x0C, 0xC0, 0xCF, 0x3C, 0xB6, 0x98, 0x04,
  0x82, 0x20, 0x99, 0xFF, 0x13, 0x04, 0x82, 0x23, 0xFE, 0x64, 0x11, 0x04,
  0x80, 0x02, 0x07, 0xC3, 0xF8, 0xD6, 0x34, 0x0F, 0x01, 0xF0, 0x2E, 0x09,
  0xBA, 0xE7, 0xF0, 0xF8, 0x10, 0x00, 0x38, 0x52, 0x24, 0x91, 0x28, 0x76,
  0x03, 0x01, 0xB8, 0x5A, 0x24, 0x91, 0x28, 0x70, 0x0F, 0x0F, 0x86, 0x42,
  0x61, 0xC3, 0xCD, 0xE5, 0x9E, 0xCE, 0x7F, 0xDE, 0xE0, 0x6D, 0xA4, 0x0C,
  0x30, 0x61, 0x83, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x06, 0x0C, 0x1C,
  0x00, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x8E, 0x31, 0x8E,
  0x00, 0x32, 0xDF, 0xDC, 0xD2, 0x40, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x36, 0x6C, 0x80, 0x7F, 0xC0, 0xFB, 0x00, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00,
  0x1E, 0x3F, 0x63, 0x63, 0xFB, 0xDB, 0xC7, 0xC6, 0xC6, 0xFC, 0x78, 0x07,
  0x0E, 0x3E, 0x36, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x7F, 0xFF, 0x0F, 0x0F,
  0xCC, 0x60, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x7F, 0xBF, 0xC0, 0x0F,
  0x1F, 0xCC, 0x60, 0x30, 0xF0, 0x78, 0x0E, 0x07, 0xE3, 0x3F, 0x8F, 0x00,
  0x03, 0x83, 0xC3, 0xC3, 0x61, 0x31, 0x99, 0x8D, 0xFF, 0xFF, 0x83, 0x01,
  0x80, 0x3F, 0x7F, 0x60, 0x7E, 0x7E, 0xE7, 0x07, 0x07, 0xC6, 0xFC, 0x78,
  0x1E, 0x3F, 0x73, 0x60, 0xFE, 0xFE, 0xE7, 0xC7, 0xC6, 0xFE, 0x78, 0xFF,
  0xFE, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0x1E, 0x7F,
  0x63, 0x63, 0x7E, 0x7E, 0xC6, 0xC7, 0xC6, 0xFE, 0x78, 0x1E, 0x7F, 0x63,
  0xE3, 0xE7, 0x7F, 0x7F, 0x06, 0xCE, 0xFC, 0x78, 0x77, 0x60, 0x00, 0xEC,
  0xC0, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x0E, 0x31, 0x86, 0x30, 0x01, 0x0F,
  0x3C, 0xF0, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0x0F, 0x7C, 0xE0, 0x80, 0x1E, 0x7F,
  0x63, 0x03, 0x07, 0x0E, 0x18, 0x30, 0x00, 0x30, 0x30, 0x07, 0x06, 0x23,
  0x0C, 0x9D, 0x4B, 0x54, 0xD7, 0x2A, 0x8A, 0xA4, 0xA9, 0x4B, 0xE2, 0x00,
  0x42, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0xD8, 0x36, 0x19, 0x86, 0x63, 0xF8,
  0xFE, 0x71, 0x98, 0x7E, 0x1C, 0x3F, 0x9F, 0xCC, 0x66, 0x37, 0xF3, 0xF9,
  0x86, 0xC3, 0x63, 0xBF, 0xBF, 0x80, 0x1E, 0x1F, 0x9C, 0xFC, 0x4C, 0x06,
  0x03, 0x01, 0x84, 0xC6, 0x7F, 0x1E, 0x00, 0x3F, 0x1F, 0xCC, 0xE6, 0x37,
  0x1B, 0x8D, 0x86, 0xC7, 0x67, 0x3F, 0x3F, 0x00, 0x3F, 0xCF, 0xF3, 0x00,
  0xC0, 0x7F, 0x1F, 0xC6, 0x01, 0x80, 0x60, 0x1F, 0xCF, 0xF0, 0x3F, 0xCF,
  0xF3, 0x00, 0xC0, 0x30, 0x0F, 0xE7, 0xF9, 0x80, 0x60, 0x18, 0x06, 0x00,
  0x1E, 0x3F, 0x73, 0xE0, 0xC0, 0xCF, 0xCF, 0xC3, 0xC6, 0xFE, 0x78, 0x39,
  0xCC, 0x63, 0x18, 0xC6, 0x7F, 0x9F, 0xE6, 0x39, 0x8C, 0x63, 0x18, 0xCE,
  0x70, 0x3F, 0xCF, 0xE0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x1F, 0xCF, 0xF0, 0x1F, 0x1F, 0x07, 0x07, 0x06, 0x06, 0x06, 0x4E, 0xCC,
  0xFC, 0x78, 0x31, 0xC6, 0x70, 0xDC, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x83,
  0x30, 0x67, 0x0C, 0x63, 0x8E, 0x00, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18,
  0x70, 0xE1, 0xFF, 0xF8, 0x39, 0xCE, 0x73, 0xBD, 0xEA, 0x7F, 0x9B, 0x66,
  0xD9, 0x36, 0xC1, 0x30, 0x4C, 0x30, 0x38, 0xCE, 0x73, 0x98, 0xF6, 0x6D,
  0x9B, 0x66, 0xD9, 0xB4, 0x67, 0x19, 0xCC, 0x70, 0x1E, 0x3F, 0x63, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFC, 0x78, 0x3F, 0x0F, 0xE3, 0x1C, 0xC6,
  0x71, 0x9F, 0xE7, 0xE1, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x1E, 0x3F, 0x63,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0x78, 0x38, 0x3E, 0x1E, 0x3F,
  0x8F, 0xF3, 0x1C, 0xC7, 0x71, 0x9F, 0xE7, 0xE1, 0x98, 0x67, 0x18, 0xCE,
  0x38, 0x0F, 0x0F, 0xE3, 0x1D, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x06, 0xE3,
  0xBF, 0xC3, 0xE0, 0x7F, 0xFF, 0xC7, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x00, 0x63, 0xB1, 0xD8, 0xCC, 0x6E, 0x37, 0x3B, 0x1D,
  0x8C, 0xCE, 0x7E, 0x1E, 0x00, 0xE1, 0xF8, 0x66, 0x39, 0x8C, 0x67, 0x19,
  0x86, 0xC1, 0xB0, 0x68, 0x0E, 0x03, 0x00, 0xC0, 0xF0, 0x6C, 0x1B, 0x66,
  0xDB, 0x36, 0xCF, 0xF3, 0xB8, 0xEE, 0x33, 0x8C, 0xC0, 0x18, 0x61, 0xCC,
  0x0D, 0x80, 0xF8, 0x07, 0x00, 0x60, 0x0F, 0x01, 0xB0, 0x3B, 0x87, 0x18,
  0x61, 0xC0, 0xE1, 0x98, 0xE6, 0x30, 0xD8, 0x3C, 0x0F, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0x3F, 0xCF, 0xF0, 0x38, 0x1C, 0x0E, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x3F, 0xCF, 0xF0, 0x1F, 0x1F, 0x18, 0x18, 0x38, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x78, 0x78, 0xC1, 0x06, 0x18,
  0x20, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0x3E, 0x7C, 0x18, 0x60, 0xC1, 0x83,
  0x06, 0x18, 0x30, 0x60, 0xC1, 0x9F, 0x3C, 0x00, 0x0E, 0x07, 0x86, 0xC2,
  0x63, 0x13, 0x0D, 0x06, 0xFF, 0xC0, 0xE2, 0x1F, 0x1F, 0x8C, 0xC0, 0x63,
  0xF3, 0x19, 0x9D, 0xF7, 0x73, 0x00, 0x38, 0x1C, 0x0C, 0x06, 0xE3, 0xF9,
  0x8D, 0xC6, 0xC3, 0x63, 0xB1, 0x9F, 0xDF, 0xC0, 0x1E, 0x7F, 0x63, 0xC0,
  0xC0, 0xC0, 0xC6, 0xFE, 0x78, 0x01, 0x81, 0xC0, 0xC7, 0x67, 0xF7, 0x3B,
  0x1D, 0x8C, 0xC6, 0x67, 0x3F, 0x9E, 0xC0, 0x1E, 0x7F, 0xE3, 0xFF, 0xFF,
  0xC0, 0xC0, 0xFE, 0x78, 0x0F, 0x8F, 0xC6, 0x0F, 0xE7, 0xF1, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x00, 0x1D, 0x8F, 0xE3, 0x39, 0xC6, 0x61,
  0x98, 0xC6, 0x31, 0xFC, 0x3B, 0x01, 0xCF, 0xE1, 0xF0, 0x38, 0x18, 0x0C,
  0x06, 0xE3, 0xF9, 0x8D, 0xC6, 0xC7, 0x63, 0x31, 0x98, 0xDC, 0x60, 0x07,
  0x06, 0x00, 0x3E, 0x3E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0xFF, 0xFF, 0x03,
  0x03, 0x00, 0x1E, 0x3E, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C,
  0xF8, 0xF0, 0x30, 0x38, 0x1C, 0x0C, 0x66, 0x63, 0x61, 0xE1, 0xF8, 0xEC,
  0x66, 0x33, 0x98, 0xC0, 0x1F, 0x1E, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C,
  0x0C, 0x0C, 0xFF, 0xFF, 0x6D, 0xBF, 0xDB, 0x2D, 0xB4, 0xDE, 0x6F, 0x27,
  0xB2, 0xD9, 0x00, 0x37, 0x1F, 0xCC, 0x6E, 0x36, 0x3B, 0x19, 0x8C, 0xC6,
  0xE3, 0x00, 0x3E, 0x7F, 0xE3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0x78, 0x37,
  0x1F, 0xCC, 0x6E, 0x36, 0x1B, 0x1D, 0x8C, 0xFE, 0xFE, 0x60, 0x30, 0x18,
  0x00, 0x3B, 0x7F, 0xE7, 0xC7, 0xC6, 0xC6, 0xCE, 0xFE, 0xF6, 0x0C, 0x0C,
  0x0C, 0x77, 0x7F, 0x78, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0x3E, 0x7F,
  0x60, 0x70, 0x7E, 0x0E, 0x46, 0xFE, 0x7C, 0x30, 0x63, 0xF7, 0xE6, 0x0C,
  0x18, 0x70, 0xC1, 0xF1, 0xE0, 0x63, 0x63, 0xE3, 0xC7, 0xC6, 0xC6, 0xCE,
  0xF6, 0xE6, 0xC1, 0xF1, 0xB8, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x38,
  0x00, 0xC1, 0xE0, 0xF6, 0x5B, 0x6B, 0xB5, 0x53, 0xA9, 0x9C, 0xCC, 0x00,
  0x31, 0x8C, 0xE1, 0xF0, 0x78, 0x1C, 0x07, 0x83, 0x61, 0x9C, 0xC3, 0x00,
  0x70, 0xDC, 0x63, 0x18, 0xCC, 0x33, 0x0D, 0x83, 0x60, 0x70, 0x18, 0x0E,
  0x0F, 0x03, 0x80, 0x3F, 0x9F, 0xC0, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFE,
  0xFF, 0x00, 0x0F, 0x87, 0x87, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0xE0, 0xF0,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x1E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07, 0x07, 0x0C, 0x0C, 0x0C, 0x18,
  0xF8, 0xF0, 0x71, 0xFF, 0x8F,
};

const GFXglyph LiberationMono_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 11, 10, 3, -11 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 10, 13, 10, 0, -12 },
  { 42, 10, 11, 10, 0, -11 },
  { 56, 9, 11, 10, 0, -11 },
  { 69, 3, 5, 10, 4, -12 },
  { 71, 7, 15, 10, 2, -12 },
  { 85, 6, 15, 10, 1, -12 },
  { 97, 6, 6, 10, 3, -12 },
  { 102, 8, 8, 10, 1, -9 },
  { 110, 4, 5, 10, 1, -2 },
  { 113, 5, 2, 10, 2, -5 },
  { 115, 3, 3, 10, 3, -3 },
  { 117, 10, 12, 10, 0, -12 },
  { 132, 8, 11, 10, 1, -11 },
  { 143, 8, 11, 10, 0, -11 },
  { 154, 9, 11, 10, 0, -11 },
  { 167, 9, 11, 10, 0, -11 },
  { 180, 9, 11, 10, 0, -11 },
  { 193, 8, 11, 10, 1, -11 },
  { 204, 8, 11, 10, 1, -11 },
  { 215, 8, 11, 10, 2, -11 },
  { 226, 8, 11, 10, 1, -11 },
  { 237, 8, 11, 10, 1, -11 },
  { 248, 4, 9, 10, 3, -9 },
  { 253, 6, 12, 10, 1, -9 },
  { 262, 8, 9, 10, 1, -10 },
  { 271, 8, 6, 10, 1, -8 },
  { 277, 8, 9, 10, 1, -10 },
  { 286, 8, 11, 10, 1, -11 },
  { 297, 10, 14, 10, 0, -12 },
  { 315, 10, 11, 10, -1, -11 },
  { 329, 9, 11, 10, 0, -11 },
  { 342, 9, 11, 10, 1, -11 },
  { 355, 9, 11, 10, 0, -11 },
  { 368, 10, 11, 10, 0, -11 },
  { 382, 10, 11, 10, 0, -11 },
  { 396, 8, 11, 10, 1, -11 },
  { 407, 10, 11, 10, 0, -11 },
  { 421, 10, 11, 10, 0, -11 },
  { 435, 8, 11, 10, 1, -11 },
  { 446, 11, 11, 10, 0, -11 },
  { 462, 7, 11, 10, 1, -11 },
  { 472, 10, 11, 10, 0, -11 },
  { 486, 10, 11, 10, 0, -11 },
  { 500, 8, 11, 10, 1, -11 },
  { 511, 10, 11, 10, 0, -11 },
  { 525, 8, 14, 10, 1, -11 },
  { 539, 10, 11, 10, 0, -11 },
  { 553, 10, 11, 10, 0, -11 },
  { 567, 9, 11, 10, 1, -11 },
  { 580, 9, 11, 10, 1, -11 },
  { 593, 10, 11, 10, 1, -11 },
  { 607, 10, 11, 10, 1, -11 },
  { 621, 12, 11, 10, -1, -11 },
  { 638, 10, 11, 10, 1, -11 },
  { 652, 10, 11, 10, 0, -11 },
  { 666, 8, 15, 10, 1, -12 },
  { 681, 6, 12, 10, 2, -12 },
  { 690, 7, 15, 10, 1, -12 },
  { 704, 9, 7, 10, 0, -11 },
  { 712, 10, 1, 10, -1, 1 },
  { 714, 4, 2, 10, 4, -11 },
  { 715, 9, 9, 10, 0, -9 },
  { 726, 9, 12, 10, 0, -12 },
  { 740, 8, 9, 10, 1, -9 },
  { 749, 9, 12, 10, 1, -12 },
  { 763, 8, 9, 10, 1, -9 },
  { 772, 9, 12, 10, 1, -12 },
  { 786, 10, 12, 10, 0, -9 },
  { 801, 9, 12, 10, 0, -12 },
  { 815, 8, 12, 10, 0, -12 },
  { 827, 8, 15, 10, 0, -12 },
  { 842, 9, 12, 10, 1, -12 },
  { 856, 8, 12, 10, 0, -12 },
  { 868, 9, 9, 10, 0, -9 },
  { 879, 9, 9, 10, 0, -9 },
  { 890, 8, 9, 10, 1, -9 },
  { 899, 9, 12, 10, 0, -9 },
  { 913, 8, 12, 10, 1, -9 },
  { 925, 8, 9, 10, 1, -9 },
  { 934, 8, 9, 10, 1, -9 },
  { 943, 7, 11, 10, 2, -11 },
  { 953, 8, 9, 10, 1, -9 },
  { 962, 9, 9, 10, 1, -9 },
  { 973, 9, 9, 10, 1, -9 },
  { 984, 10, 9, 10, 0, -9 },
  { 996, 10, 12, 10, 0, -9 },
  { 1011, 9, 9, 10, 0, -9 },
  { 1022, 9, 15, 10, 1, -12 },
  { 1039, 2, 16, 10, 4, -12 },
  { 1043, 8, 15, 10, 0, -12 },
  { 1058, 8, 3, 10, 1, -7 },
};

const GFXfont LiberationMono_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic16pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _LIBERATIONMONO_BOLDITALIC16PT7B_H_
