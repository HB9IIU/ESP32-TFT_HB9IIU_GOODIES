#ifndef _LIBERATIONMONO_BOLDITALIC29PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x00, 0x00, 0x78, 0x78, 0xF8, 0xF0, 0x78, 0xE7, 0x9E, 0x71,
  0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x80, 0x00, 0xC1,
  0x80, 0x30, 0xE0, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x07, 0xFF, 0xF3,
  0xFF, 0xF8, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x30,
  0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0x81, 0x86, 0x00, 0xC1, 0x80, 0x30, 0xE0,
  0x1C, 0x30, 0x06, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x60, 0x03, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFF, 0x3E, 0x5F, 0x3C, 0xCF, 0x3C, 0xC0, 0x3C, 0xC0, 0x3F,
  0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xBE, 0x01, 0x1E, 0xE1,
  0x1E, 0xF3, 0x1E, 0xF3, 0x3C, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x80, 0x60, 0xFC, 0x0C, 0x1C, 0xE1, 0xC1, 0x8E,
  0x38, 0x38, 0xE7, 0x03, 0x8C, 0xE0, 0x38, 0xCC, 0x03, 0x9D, 0x80, 0x1F,
  0xB0, 0x01, 0xF6, 0xF8, 0x00, 0xDF, 0xC0, 0x1F, 0x9C, 0x03, 0xB9, 0xC0,
  0x73, 0x1C, 0x0E, 0x31, 0xC1, 0xC3, 0x18, 0x18, 0x33, 0x83, 0x03, 0xF0,
  0x60, 0x1E, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0x8E, 0x07,
  0x0E, 0x07, 0x1C, 0x07, 0x78, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x87, 0x3F,
  0x87, 0x73, 0xCE, 0xF1, 0xDE, 0xE1, 0xFC, 0xE0, 0xF8, 0xF0, 0xF8, 0xFF,
  0xFF, 0x7F, 0xDF, 0x3F, 0x0F, 0x7B, 0xDE, 0xE7, 0x3B, 0xDC, 0xE0, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x38, 0x37, 0x7F,
  0xFF, 0xFF, 0x87, 0x81, 0xF8, 0x77, 0x9C, 0x71, 0x08, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0F, 0x87, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE0, 0x00, 0x7F, 0xBF, 0xFF, 0xE0, 0x7B, 0xFF, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x03, 0xDE, 0x07,
  0xF8, 0x1E, 0xF3, 0xBD, 0xE7, 0x7B, 0xDE, 0xF7, 0xB9, 0xEF, 0x07, 0x9E,
  0x0F, 0x3C, 0x3C, 0x78, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x00,
  0x78, 0x07, 0xE0, 0x7F, 0x0F, 0xFC, 0x3E, 0xF0, 0xE3, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFF, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x3C, 0x0F,
  0x04, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xF8,
  0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xDE, 0x03, 0x9E, 0x07, 0x1E, 0x0E, 0x1C, 0x1E, 0x3C,
  0x3C, 0x3C, 0x78, 0x3C, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3D, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x10, 0x3C, 0xF0, 0x3C,
  0xF8, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xF8,
  0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xEF, 0x00, 0x1E, 0x00, 0x3D, 0xF0, 0xF7,
  0xF9, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3C, 0x1E,
  0x7C, 0x78, 0x7F, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x1E, 0x3E,
  0x1F, 0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x3E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x01, 0xF8,
  0x0F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0xBE,
  0x0F, 0x3C, 0x3E, 0x7F, 0xFC, 0xFF, 0x78, 0x7C, 0xF0, 0x03, 0xC0, 0x07,
  0xBC, 0x1E, 0x7C, 0x7C, 0x7F, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x1E, 0x3C,
  0x79, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x3E, 0x78,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x03, 0xF8, 0x3F, 0xE1, 0xFE,
  0x1F, 0xF0, 0x3F, 0x00, 0x70, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x07, 0x00, 0x3E, 0x03, 0xFC,
  0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xF8, 0xFF, 0xFB, 0xE1, 0xF7, 0x81, 0xFE, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xC0, 0x38, 0x38, 0x1C, 0x06, 0x0E, 0x01, 0x83, 0x1D, 0xB1,
  0x9F, 0x6C, 0x66, 0x73, 0x33, 0x1C, 0xCD, 0xC7, 0x36, 0x61, 0x89, 0xB8,
  0x66, 0x6C, 0x19, 0x9B, 0x0C, 0x6C, 0xC3, 0x33, 0x31, 0xCC, 0xCC, 0x63,
  0x33, 0x39, 0x8C, 0xFB, 0xC3, 0x3C, 0xE0, 0x60, 0x00, 0x18, 0x06, 0x07,
  0x87, 0x80, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x1C,
  0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF,
  0xF8, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x3C, 0x3C, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x87,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x18, 0xF8, 0x1E, 0xF8, 0x3C, 0x7C,
  0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC3, 0xE3, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F,
  0x3E, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0,
  0xF1, 0xF0, 0xF8, 0xF0, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x3E, 0x0F, 0x3C, 0x0E,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0xFE, 0xF8, 0xFE, 0xF1, 0xFE,
  0xF0, 0x1E, 0xF8, 0x1E, 0xF8, 0x1C, 0x7C, 0x3C, 0x7F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xC0, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x1E,
  0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F,
  0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x0F, 0x8F, 0x81, 0xE3,
  0xE0, 0x3C, 0xF8, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x1F,
  0x03, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x7C, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0x87, 0xC7,
  0xE1, 0xF1, 0xF8, 0xFC, 0x7E, 0x37, 0x1F, 0x9F, 0x87, 0xE7, 0xE3, 0xBB,
  0xB8, 0xEE, 0xEE, 0x3B, 0xB7, 0x8E, 0xFD, 0xC3, 0xBE, 0x71, 0xE7, 0x9C,
  0x71, 0xC7, 0x1C, 0x73, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x0E, 0x38,
  0x03, 0x8E, 0x01, 0xE0, 0x0F, 0x83, 0xC3, 0xE0, 0xE0, 0xF8, 0x38, 0x7F,
  0x1E, 0x1F, 0xC7, 0x87, 0x71, 0xE1, 0xDC, 0x70, 0x77, 0x1C, 0x3D, 0xCF,
  0x0F, 0x7B, 0xC3, 0xCE, 0xF0, 0xF3, 0xB8, 0x38, 0xEE, 0x1E, 0x3B, 0x87,
  0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0x7E, 0x1C, 0x1F, 0x07, 0x07, 0xC0, 0x01,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3C, 0xF8, 0x3C, 0xF8, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x3E, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFE, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3C,
  0xF8, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x78,
  0x78, 0x1E, 0x3E, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3C,
  0x78, 0x0F, 0x1F, 0x07, 0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1E, 0x07,
  0x87, 0x81, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF1,
  0xE0, 0x78, 0xF0, 0x20, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x3D, 0xF8,
  0x3C, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07,
  0x8F, 0x07, 0xC7, 0x83, 0xC7, 0xC1, 0xE3, 0xE1, 0xF0, 0xF1, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xBE, 0x01, 0xE7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0,
  0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x0F,
  0x70, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80,
  0x78, 0xF3, 0x8F, 0x1C, 0x71, 0xC3, 0x9F, 0x38, 0x73, 0xEF, 0x0E, 0xFD,
  0xC1, 0xDF, 0xB8, 0x3F, 0x7F, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x1F, 0x3F,
  0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x00, 0x0F,
  0x01, 0xF0, 0xF8, 0x3E, 0x07, 0x83, 0xC0, 0x7C, 0x78, 0x03, 0xCF, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x1F, 0x1E,
  0x03, 0xE1, 0xE0, 0x3C, 0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0x9E, 0x03, 0xC7, 0x81, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x9E,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0E, 0xE0, 0x3D, 0xC0, 0x73, 0x81,
  0xC7, 0x03, 0x8F, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x39, 0xC0, 0x7F, 0x80,
  0x7E, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xF8, 0xF0, 0x70, 0x70, 0x03, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xC0, 0x07, 0x83, 0xFF, 0x1F,
  0xFE, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x1F, 0x9F, 0xEF,
  0xFF, 0xDF, 0x3E, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x3C, 0x1E, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E,
  0x7C, 0x1E, 0x7E, 0x3C, 0x7F, 0xFC, 0x7B, 0xF8, 0x79, 0xE0, 0x03, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF9, 0xF1, 0xF3, 0xC1, 0xEF, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xC7, 0xC1, 0xE7, 0x87, 0x8F, 0xFE,
  0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x3E, 0x78, 0x3F, 0xBC, 0x3F, 0xFC, 0x3E, 0x3E, 0x3E,
  0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x7C, 0x7C, 0x7E, 0x1F, 0xFE, 0x0F, 0xEF, 0x03, 0xE7,
  0x80, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0xF3, 0xC1, 0xEF, 0x01,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x87, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0x80, 0x0F, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x03, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3E, 0x3F, 0x3C, 0x1E, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0xF8, 0x3C, 0x78,
  0x7C, 0x78, 0xFC, 0x7F, 0xFC, 0x7F, 0xBC, 0x3E, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0xF1, 0xF0, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xCF, 0x8F, 0x7F, 0x9F, 0xFF,
  0x3F, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x0F, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x78,
  0x78, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0xC0, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x39, 0xC7, 0x1D, 0xF7, 0xCF, 0xFF, 0xE7, 0x9E, 0x73, 0x8E, 0x39, 0xC7,
  0x1D, 0xE7, 0x9E, 0xE3, 0x8E, 0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x71, 0xDE,
  0x79, 0xEE, 0x3C, 0xF7, 0x1C, 0x73, 0x8E, 0x39, 0xC7, 0x1C, 0x3C, 0x7C,
  0x7B, 0xFC, 0xFF, 0xF9, 0xF8, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x1E, 0x78, 0x3C, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF1, 0xF7,
  0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xF7, 0x81, 0xEF, 0x87, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0x1E,
  0x07, 0xBF, 0x83, 0xFF, 0xE1, 0xF9, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC7, 0xC1, 0xE3,
  0xF1, 0xE1, 0xFF, 0xF0, 0xF7, 0xF0, 0x79, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0xCF, 0x0F,
  0xEF, 0x1F, 0xFE, 0x3E, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0xFF,
  0xF8, 0x7F, 0x78, 0x3E, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x7E, 0x79, 0xFC, 0xF7, 0xF1, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF9, 0xE0, 0xF3, 0xC1, 0x07, 0x80, 0x0F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xF0, 0x81, 0xEF, 0x07, 0xDF,
  0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x07,
  0xFF, 0x3F, 0xFB, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0x1F, 0xF0,
  0x7F, 0x80, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0x78, 0x3C, 0x78, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x39, 0xE0, 0x39, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x70, 0x03, 0xDC, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xCF, 0x3C, 0xE3, 0x9F, 0x38,
  0xE6, 0xCE, 0x3B, 0xB7, 0x0E, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x0F, 0x83, 0xC1, 0xC0, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x1E,
  0x3E, 0x03, 0xC7, 0x80, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0x9E, 0x01, 0xE3,
  0xC0, 0x7C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x01, 0xE3, 0xC0,
  0x7C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0x38, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1E, 0xE0, 0x03, 0xDC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x0F, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0xFF,
  0x81, 0xFE, 0x03, 0xF8, 0x00, 0x1E, 0x01, 0x7F, 0xC3, 0x7F, 0xFE, 0x43,
  0xFE, 0x80, 0x7C,
};

const GFXglyph LiberationMono_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 19, 17, 5, -19 },
  { 20, 12, 9, 17, 5, -21 },
  { 34, 18, 19, 17, 0, -19 },
  { 77, 16, 23, 17, 1, -21 },
  { 123, 20, 19, 17, -1, -19 },
  { 171, 16, 19, 17, 0, -19 },
  { 209, 5, 9, 17, 8, -21 },
  { 215, 12, 27, 17, 4, -21 },
  { 256, 11, 27, 17, 2, -21 },
  { 294, 11, 11, 17, 5, -21 },
  { 310, 15, 15, 17, 1, -17 },
  { 339, 9, 9, 17, 1, -4 },
  { 350, 9, 3, 17, 4, -9 },
  { 354, 5, 4, 17, 5, -4 },
  { 357, 19, 21, 17, 0, -21 },
  { 407, 15, 19, 17, 2, -19 },
  { 443, 14, 19, 17, 1, -19 },
  { 477, 17, 19, 17, 0, -19 },
  { 518, 16, 19, 17, 1, -19 },
  { 556, 16, 19, 17, 0, -19 },
  { 594, 16, 19, 17, 1, -19 },
  { 632, 15, 19, 17, 2, -19 },
  { 668, 15, 19, 17, 3, -19 },
  { 704, 16, 19, 17, 1, -19 },
  { 742, 15, 19, 17, 1, -19 },
  { 778, 7, 16, 17, 5, -16 },
  { 792, 10, 21, 17, 2, -16 },
  { 819, 15, 15, 17, 1, -17 },
  { 848, 15, 11, 17, 1, -15 },
  { 869, 15, 15, 17, 1, -17 },
  { 898, 15, 19, 17, 2, -19 },
  { 934, 18, 25, 17, 0, -21 },
  { 991, 17, 19, 17, -1, -19 },
  { 1032, 17, 19, 17, 0, -19 },
  { 1073, 16, 19, 17, 1, -19 },
  { 1111, 17, 19, 17, 0, -19 },
  { 1152, 18, 19, 17, 0, -19 },
  { 1195, 17, 19, 17, 1, -19 },
  { 1236, 16, 19, 17, 1, -19 },
  { 1274, 18, 19, 17, 0, -19 },
  { 1317, 16, 19, 17, 1, -19 },
  { 1355, 16, 19, 17, 1, -19 },
  { 1393, 19, 19, 17, 0, -19 },
  { 1439, 14, 19, 17, 1, -19 },
  { 1473, 18, 19, 17, 0, -19 },
  { 1516, 18, 19, 17, 0, -19 },
  { 1559, 16, 19, 17, 1, -19 },
  { 1597, 17, 19, 17, 0, -19 },
  { 1638, 16, 25, 17, 1, -19 },
  { 1688, 18, 19, 17, 0, -19 },
  { 1731, 17, 19, 17, 0, -19 },
  { 1772, 17, 19, 17, 2, -19 },
  { 1813, 17, 19, 17, 1, -19 },
  { 1854, 18, 19, 17, 2, -19 },
  { 1897, 19, 19, 17, 1, -19 },
  { 1943, 20, 19, 17, -1, -19 },
  { 1991, 18, 19, 17, 2, -19 },
  { 2034, 18, 19, 17, 0, -19 },
  { 2077, 13, 27, 17, 3, -21 },
  { 2121, 11, 21, 17, 4, -21 },
  { 2150, 14, 27, 17, 1, -21 },
  { 2198, 15, 13, 17, 1, -20 },
  { 2223, 18, 1, 17, -2, 2 },
  { 2226, 7, 4, 17, 7, -21 },
  { 2230, 15, 16, 17, 1, -16 },
  { 2260, 16, 21, 17, 0, -21 },
  { 2302, 15, 16, 17, 1, -16 },
  { 2332, 17, 21, 17, 1, -21 },
  { 2377, 15, 16, 17, 1, -16 },
  { 2407, 16, 21, 17, 3, -21 },
  { 2449, 16, 22, 17, 1, -16 },
  { 2493, 15, 21, 17, 1, -21 },
  { 2533, 15, 21, 17, 0, -21 },
  { 2573, 16, 27, 17, -1, -21 },
  { 2627, 17, 21, 17, 1, -21 },
  { 2672, 15, 21, 17, 0, -21 },
  { 2712, 17, 16, 17, 0, -16 },
  { 2746, 15, 16, 17, 1, -16 },
  { 2776, 15, 16, 17, 1, -16 },
  { 2806, 17, 22, 17, -1, -16 },
  { 2853, 16, 22, 17, 1, -16 },
  { 2897, 15, 16, 17, 2, -16 },
  { 2927, 15, 16, 17, 1, -16 },
  { 2957, 13, 20, 17, 3, -20 },
  { 2990, 16, 16, 17, 1, -16 },
  { 3022, 16, 16, 17, 2, -16 },
  { 3054, 18, 16, 17, 1, -16 },
  { 3090, 19, 16, 17, -1, -16 },
  { 3128, 19, 22, 17, -1, -16 },
  { 3181, 16, 16, 17, 0, -16 },
  { 3213, 15, 27, 17, 2, -21 },
  { 3264, 4, 27, 17, 7, -21 },
  { 3278, 15, 27, 17, 0, -21 },
  { 3329, 16, 5, 17, 1, -12 },
};

const GFXfont LiberationMono_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic29pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _LIBERATIONMONO_BOLDITALIC29PT7B_H_
