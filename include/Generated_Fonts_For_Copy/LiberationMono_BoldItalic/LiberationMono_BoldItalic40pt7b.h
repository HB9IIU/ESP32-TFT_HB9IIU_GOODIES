#ifndef _LIBERATIONMONO_BOLDITALIC40PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x80, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78,
  0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0,
  0xE0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x70,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xE6, 0x7E,
  0x1F, 0x8C, 0x7E, 0x3E, 0x18, 0xFC, 0x7C, 0x31, 0x00, 0xF8, 0xE0, 0x01,
  0xFD, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xCF, 0xE0, 0x01, 0x8F, 0xC0, 0x03,
  0x0F, 0x9F, 0x0E, 0x1F, 0x3E, 0x18, 0x3E, 0x7E, 0x30, 0xF8, 0xFE, 0x67,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x01,
  0xC0, 0xFF, 0x80, 0x78, 0x3F, 0xF0, 0x1E, 0x07, 0x9E, 0x07, 0x81, 0xE1,
  0xC1, 0xE0, 0x3C, 0x38, 0x38, 0x07, 0x07, 0x0E, 0x00, 0xE1, 0xE3, 0x80,
  0x1C, 0x38, 0xE0, 0x03, 0x8F, 0x38, 0x00, 0x7F, 0xCF, 0x00, 0x0F, 0xF3,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0x7F, 0xC0,
  0x01, 0xCF, 0xF8, 0x00, 0x73, 0xC7, 0x00, 0x1C, 0x70, 0xE0, 0x07, 0x1E,
  0x1C, 0x01, 0xC3, 0x83, 0x80, 0x78, 0x70, 0xF0, 0x1E, 0x0E, 0x1E, 0x07,
  0x81, 0xE7, 0x81, 0xE0, 0x3F, 0xF0, 0x78, 0x03, 0xFC, 0x0E, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC7,
  0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8,
  0x01, 0xE7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xC3, 0xFF, 0x07, 0x8F, 0xFE, 0x1E, 0x3F, 0x3E, 0x3C, 0x7C,
  0x7C, 0xF1, 0xF0, 0x7D, 0xE3, 0xE0, 0xFF, 0x87, 0xC0, 0xFF, 0x0F, 0x81,
  0xFC, 0x1F, 0x01, 0xFC, 0x3F, 0x0F, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xF9,
  0xFC, 0x3F, 0xC0, 0xF8, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C, 0x78,
  0xF1, 0xE7, 0x8F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x21, 0xE0, 0x39, 0xEE, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0x7C, 0x38, 0x70,
  0x10, 0x40, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x7E, 0xFD, 0xF3, 0xEF,
  0xDF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01,
  0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0xF3, 0xE7, 0xC7, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xCF, 0xDF, 0x9E, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F,
  0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8, 0x3F, 0x0F, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x1F, 0x9F, 0x81, 0xE1, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xF1, 0xF8,
  0x0F, 0xC0, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00,
  0x7C, 0xFC, 0x03, 0xF3, 0xF8, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xE0, 0x7C, 0x07, 0x80,
  0xF8, 0x1E, 0x01, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x7E,
  0x01, 0xF7, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3,
  0xF8, 0x3F, 0x8F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE1, 0xC0,
  0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE1, 0xF8, 0x3F, 0x87, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x87, 0xC0,
  0xFC, 0x7E, 0x03, 0xC3, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x0F,
  0xBF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xC3, 0xF1, 0xF8, 0x0F,
  0xCF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0xC7, 0xC0, 0xFC, 0x3F, 0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x03,
  0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3F, 0x0F, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF8,
  0x7F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF1, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8,
  0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x07, 0xE3, 0xF0, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0x7C, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x1F,
  0x8F, 0xC0, 0xF8, 0x7E, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF8,
  0x7F, 0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3E, 0x3C, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x06, 0x07,
  0x3B, 0x07, 0x0F, 0xDD, 0xC7, 0x0E, 0x6C, 0xE3, 0x8E, 0x1E, 0x61, 0x8E,
  0x0F, 0x31, 0xC6, 0x07, 0x18, 0xE7, 0x03, 0x9C, 0x63, 0x03, 0x8E, 0x73,
  0x81, 0xC7, 0x39, 0xC0, 0xE3, 0x1D, 0xE0, 0xE3, 0x8C, 0xE0, 0x71, 0xC6,
  0x70, 0x70, 0xC7, 0x38, 0x38, 0xE3, 0x9C, 0x3C, 0x61, 0xCE, 0x1E, 0x70,
  0xE7, 0x1E, 0x70, 0x71, 0xFB, 0xF0, 0x38, 0xF0, 0xF0, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0x7E,
  0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x7E, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xC3, 0xFC, 0x3E, 0x07,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF1,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x3F, 0x8F, 0xC0, 0xFC,
  0xFC, 0x07, 0xE7, 0xE0, 0x1E, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFB, 0xF0, 0xFF, 0xDF,
  0x8F, 0xFE, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xF9, 0xF8, 0x07,
  0xCF, 0xC0, 0x3E, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x80, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0xF0, 0x1F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xFC, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0,
  0x0F, 0x83, 0xF8, 0x03, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x7F,
  0x00, 0x1F, 0xBF, 0x80, 0x07, 0xDF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xBC,
  0x1F, 0xE3, 0xFE, 0x1F, 0xF1, 0xDE, 0x0F, 0x7D, 0xEF, 0x07, 0x9E, 0xE7,
  0x83, 0xCF, 0xF3, 0xC1, 0xE7, 0x7B, 0xE1, 0xF3, 0xB9, 0xE0, 0xF1, 0xFC,
  0xF0, 0x78, 0xFC, 0x78, 0x3C, 0x7E, 0x3C, 0x1E, 0x3E, 0x3E, 0x1F, 0x1F,
  0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x00,
  0x07, 0xE0, 0x3E, 0x1F, 0xE0, 0x7C, 0x3F, 0xC0, 0xF8, 0x7F, 0x81, 0xF0,
  0xFF, 0x03, 0xE1, 0xFE, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F,
  0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7D, 0xE3, 0xE1, 0xF3, 0xC7, 0xC3, 0xE7,
  0xCF, 0x87, 0xCF, 0x9F, 0x0F, 0x9F, 0x3E, 0x1F, 0x1E, 0xF8, 0x7E, 0x3D,
  0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC1, 0xFE,
  0x1F, 0x83, 0xFC, 0x3E, 0x07, 0xF8, 0x7C, 0x0F, 0xF0, 0xF8, 0x1F, 0xE1,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x00,
  0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x7E, 0x0F, 0xE1, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFC, 0x1F, 0xE1, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x7C,
  0x03, 0xF1, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x1F, 0xC1,
  0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xE1, 0xFC,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFC,
  0x0F, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFE, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x30, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFE, 0x00, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC3, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x7C,
  0x3E, 0x3E, 0x3E, 0x1E, 0x3F, 0x1E, 0x0F, 0x1F, 0x9F, 0x07, 0x9F, 0xCF,
  0x83, 0xCF, 0xE7, 0x83, 0xEF, 0xF7, 0xC1, 0xF7, 0xFB, 0xE0, 0xFF, 0x9D,
  0xE0, 0x7F, 0xCE, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3E, 0x01,
  0xF8, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x8F,
  0xC0, 0x1F, 0x8F, 0x80, 0x0F, 0x9F, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0,
  0x07, 0x8F, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x83, 0xC0,
  0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x00, 0x0F, 0xF8, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80,
  0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8,
  0xFC, 0x1F, 0xC7, 0xE1, 0xFE, 0x3F, 0xFD, 0xF1, 0xFF, 0xCF, 0xE7, 0xFC,
  0x7F, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF1, 0xF0, 0x0F, 0x9F, 0xF0, 0x3E, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xF8,
  0xFE, 0x1F, 0xC1, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E,
  0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x7E,
  0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xE3, 0xFF, 0xFF, 0x0F, 0xDF, 0xF8, 0x3E, 0x7F, 0xC0, 0xF8, 0x7C, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83,
  0xF3, 0xF0, 0x3F, 0x3F, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xCF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xE1, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xFE, 0x7C, 0x07, 0xFE,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x1F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xF7, 0xE0, 0x3F, 0xE7, 0xC0, 0x0F, 0x87, 0xC0, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xF3, 0xE0,
  0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xE0, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x7E, 0x03, 0xFC, 0xF8, 0x1F, 0xFD, 0xF0, 0x3F, 0xFB,
  0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0x80, 0x7C,
  0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0x01, 0xFF,
  0x7E, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0xFC, 0x0F, 0x9F, 0xF0, 0x7D, 0xFF, 0xC7, 0xFF, 0xFE, 0x3E, 0xC3, 0xF1,
  0xFC, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x01,
  0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F,
  0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE7, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0,
  0x7C, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x1E, 0x1E,
  0x07, 0x9F, 0x9F, 0x83, 0xDF, 0xDF, 0xE1, 0xFB, 0xF9, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F,
  0x0F, 0x0F, 0x0F, 0x8F, 0x87, 0x87, 0x87, 0xC7, 0xC3, 0xC3, 0xC3, 0xE1,
  0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x7C,
  0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x8F, 0x87,
  0x87, 0x87, 0xC7, 0xC3, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0xFC, 0xFF, 0x87,
  0xEF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF6, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x03,
  0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E,
  0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0,
  0x7E, 0x7C, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80,
  0x7E, 0x7C, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x1F, 0x00, 0xFC,
  0x7E, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x03, 0xE7, 0xFC, 0x07,
  0xEF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0x7F, 0xC0, 0x3E, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFF, 0x1F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF9,
  0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xF1, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x7F,
  0x87, 0xFF, 0xFE, 0x1F, 0xFD, 0xF0, 0x3F, 0xE7, 0xC0, 0x3E, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x07,
  0xF1, 0xF1, 0xFF, 0x1F, 0x3F, 0xF1, 0xF7, 0xFF, 0x1F, 0x7F, 0xE1, 0xFF,
  0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0xF8,
  0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC3, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0xC7,
  0xF1, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x07, 0xFC, 0xF8, 0x1F, 0x87,
  0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C,
  0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x78, 0x3C, 0xF0, 0xF8, 0x7C, 0xF0,
  0xF8, 0x78, 0xF0, 0xF8, 0x78, 0xF1, 0xF8, 0xF0, 0xF1, 0xF8, 0xF0, 0xF3,
  0xBC, 0xF0, 0xF3, 0xBD, 0xE0, 0xF7, 0x3D, 0xE0, 0xF7, 0x1D, 0xE0, 0xFF,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0B, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 11, 26, 24, 7, -26 },
  { 37, 16, 13, 24, 7, -29 },
  { 63, 25, 26, 24, 0, -26 },
  { 145, 23, 32, 24, 1, -29 },
  { 237, 27, 26, 24, -1, -26 },
  { 325, 23, 26, 24, 0, -26 },
  { 400, 7, 13, 24, 11, -29 },
  { 412, 16, 37, 24, 6, -29 },
  { 486, 16, 37, 24, 2, -29 },
  { 560, 16, 15, 24, 6, -29 },
  { 590, 20, 20, 24, 2, -23 },
  { 640, 12, 13, 24, 2, -6 },
  { 660, 12, 5, 24, 6, -13 },
  { 668, 7, 6, 24, 7, -6 },
  { 674, 26, 29, 24, 0, -29 },
  { 769, 21, 26, 24, 2, -26 },
  { 838, 20, 26, 24, 1, -26 },
  { 903, 23, 26, 24, 0, -26 },
  { 978, 22, 26, 24, 1, -26 },
  { 1050, 23, 26, 24, 0, -26 },
  { 1125, 22, 26, 24, 1, -26 },
  { 1197, 21, 26, 24, 2, -26 },
  { 1266, 19, 26, 24, 5, -26 },
  { 1328, 22, 26, 24, 1, -26 },
  { 1400, 21, 26, 24, 2, -26 },
  { 1469, 10, 22, 24, 7, -22 },
  { 1497, 14, 29, 24, 3, -22 },
  { 1548, 20, 21, 24, 2, -24 },
  { 1601, 20, 15, 24, 2, -21 },
  { 1639, 20, 21, 24, 2, -24 },
  { 1692, 21, 26, 24, 3, -26 },
  { 1761, 25, 35, 24, 0, -29 },
  { 1871, 24, 26, 24, -2, -26 },
  { 1949, 23, 26, 24, 1, -26 },
  { 2024, 22, 26, 24, 2, -26 },
  { 2096, 22, 26, 24, 1, -26 },
  { 2168, 24, 26, 24, 1, -26 },
  { 2246, 24, 26, 24, 1, -26 },
  { 2324, 21, 26, 24, 2, -26 },
  { 2393, 23, 26, 24, 1, -26 },
  { 2468, 23, 26, 24, 1, -26 },
  { 2543, 22, 26, 24, 1, -26 },
  { 2615, 26, 26, 24, 1, -26 },
  { 2700, 19, 26, 24, 2, -26 },
  { 2762, 25, 26, 24, 0, -26 },
  { 2844, 23, 26, 24, 1, -26 },
  { 2919, 23, 26, 24, 1, -26 },
  { 2994, 23, 26, 24, 1, -26 },
  { 3069, 23, 34, 24, 1, -26 },
  { 3167, 23, 26, 24, 1, -26 },
  { 3242, 24, 26, 24, 0, -26 },
  { 3320, 23, 26, 24, 3, -26 },
  { 3395, 23, 26, 24, 2, -26 },
  { 3470, 24, 26, 24, 3, -26 },
  { 3548, 25, 26, 24, 2, -26 },
  { 3630, 28, 26, 24, -2, -26 },
  { 3721, 24, 26, 24, 3, -26 },
  { 3799, 25, 26, 24, 0, -26 },
  { 3881, 19, 37, 24, 4, -29 },
  { 3969, 15, 29, 24, 5, -29 },
  { 4024, 19, 37, 24, 1, -29 },
  { 4112, 21, 17, 24, 1, -28 },
  { 4157, 25, 2, 24, -3, 2 },
  { 4164, 9, 5, 24, 10, -28 },
  { 4170, 21, 22, 24, 1, -22 },
  { 4228, 22, 29, 24, 1, -29 },
  { 4308, 20, 22, 24, 2, -22 },
  { 4363, 24, 29, 24, 1, -29 },
  { 4450, 20, 22, 24, 2, -22 },
  { 4505, 22, 29, 24, 4, -29 },
  { 4585, 23, 30, 24, 1, -22 },
  { 4672, 21, 29, 24, 1, -29 },
  { 4749, 21, 29, 24, 0, -29 },
  { 4826, 21, 37, 24, -1, -29 },
  { 4924, 23, 29, 24, 1, -29 },
  { 5008, 21, 29, 24, 0, -29 },
  { 5085, 25, 22, 24, -1, -22 },
  { 5154, 21, 22, 24, 1, -22 },
  { 5212, 22, 22, 24, 1, -22 },
  { 5273, 24, 30, 24, -1, -22 },
  { 5363, 22, 30, 24, 1, -22 },
  { 5446, 20, 22, 24, 3, -22 },
  { 5501, 21, 22, 24, 1, -22 },
  { 5559, 17, 28, 24, 4, -28 },
  { 5619, 21, 22, 24, 2, -22 },
  { 5677, 22, 22, 24, 3, -22 },
  { 5738, 24, 22, 24, 2, -22 },
  { 5804, 26, 22, 24, -1, -22 },
  { 5876, 26, 30, 24, -1, -22 },
  { 5974, 21, 22, 24, 1, -22 },
  { 6032, 21, 37, 24, 3, -29 },
  { 6130, 6, 38, 24, 9, -29 },
  { 6159, 21, 37, 24, 0, -29 },
  { 6257, 21, 6, 24, 2, -16 },
};

const GFXfont LiberationMono_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic40pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _LIBERATIONMONO_BOLDITALIC40PT7B_H_
