#ifndef _LIBERATIONMONO_BOLDITALIC45PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00,
  0x70, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0xF0, 0x1C, 0x00, 0x1C,
  0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x07, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x07, 0x81, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xF3, 0x3F, 0x83, 0xF0, 0xC7, 0xF0, 0xF8, 0x70, 0xFC,
  0x7E, 0x1C, 0x00, 0x1F, 0x87, 0x00, 0x07, 0xF1, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x1F, 0xC0,
  0x01, 0x83, 0xF0, 0x10, 0x60, 0xFC, 0xFC, 0x18, 0x3F, 0x3F, 0x0E, 0x0F,
  0x8F, 0xC3, 0x87, 0xE3, 0xFC, 0xC7, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3C, 0x0F, 0xF8, 0x01, 0xE0, 0x7F, 0xF0, 0x0F,
  0x03, 0xE3, 0xC0, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0x38, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x78, 0x07, 0x83, 0xC3, 0xC0, 0x1E, 0x0E, 0x1E, 0x00, 0x78,
  0x78, 0xF0, 0x01, 0xE1, 0xE7, 0x80, 0x07, 0x8F, 0x3C, 0x00, 0x1F, 0xFD,
  0xE0, 0x00, 0x3F, 0xEF, 0x00, 0x00, 0x7E, 0x38, 0x00, 0x00, 0x01, 0xE7,
  0xE0, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x79, 0xFF, 0x80, 0x03, 0xCF, 0x1E,
  0x00, 0x1E, 0x78, 0x78, 0x00, 0xF1, 0xE1, 0xE0, 0x07, 0x87, 0x87, 0x80,
  0x1C, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xE0, 0x3C,
  0x0F, 0x0F, 0x01, 0xE0, 0x3E, 0x7C, 0x0F, 0x00, 0x7F, 0xE0, 0x78, 0x01,
  0xFF, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC0,
  0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0x78,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1E, 0x1F, 0xF8, 0x1F, 0x3F, 0xFE, 0x0F, 0x1F,
  0x9F, 0x0F, 0x9F, 0x8F, 0xC7, 0x9F, 0x87, 0xE7, 0xCF, 0x81, 0xFF, 0xC7,
  0xC0, 0x7F, 0xE3, 0xE0, 0x3F, 0xE1, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0x7F, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC3,
  0xF8, 0x7F, 0x80, 0xFC, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x30, 0xF1, 0x8F, 0x3D, 0xE7, 0xFF, 0xF9, 0xFF, 0xFF,
  0x7F, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0x7C, 0x1F,
  0x9F, 0x87, 0xC3, 0xE0, 0xE0, 0xE0, 0x10, 0x20, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFE, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x3E, 0x7E,
  0x7F, 0x3E, 0x7E, 0x7E, 0x3C, 0x7E, 0x7E, 0x3C, 0x7E, 0x7E, 0x7C, 0xFE,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1C, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x00, 0xC0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0x7F,
  0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF3, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x30, 0x07,
  0xF3, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0,
  0x38, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x07, 0xE7, 0xFE, 0x0F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0x83, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xFC, 0x7E, 0x00,
  0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80,
  0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFE, 0xFC, 0x0F, 0xFC, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x3C, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x87, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x87,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFE,
  0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x0E, 0x03, 0x83, 0xC7, 0xE0, 0x70, 0xFE, 0xEF, 0x07,
  0x1F, 0xEE, 0x70, 0xE3, 0xE6, 0xE7, 0x0E, 0x38, 0x3C, 0xF1, 0xC7, 0x83,
  0xCE, 0x1C, 0xF0, 0x38, 0xE3, 0x8E, 0x03, 0x8E, 0x39, 0xE0, 0x78, 0xE3,
  0x9C, 0x07, 0x0E, 0x79, 0xC0, 0x70, 0xC7, 0x3C, 0x0E, 0x1C, 0x73, 0x80,
  0xE1, 0xC7, 0x38, 0x1E, 0x1C, 0x73, 0x81, 0xC3, 0x8E, 0x38, 0x3C, 0x38,
  0xE3, 0x83, 0xC7, 0x0E, 0x38, 0x78, 0xF0, 0xE3, 0x8F, 0x8E, 0x0E, 0x3F,
  0xDF, 0xC0, 0xE3, 0xF9, 0xF8, 0x0F, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x03, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xF3, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0xFE, 0x7E, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x1F, 0x9F, 0xC0, 0x0C, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x07, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xFE, 0x03, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x0F, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87,
  0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x0F,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3E, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFE, 0xFE, 0x1F, 0xFE, 0xFE, 0x1F, 0xFE, 0xFC,
  0x1F, 0xFE, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE,
  0x00, 0xFC, 0xFF, 0x00, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7F,
  0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07,
  0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x80,
  0x7E, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x01, 0xF8,
  0x7F, 0x80, 0x0F, 0xC7, 0xF8, 0x00, 0x7E, 0x7F, 0x80, 0x07, 0xF7, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFF,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC3, 0xDE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x7B,
  0xE0, 0xFF, 0xC7, 0xBC, 0x0F, 0x3C, 0xF7, 0xC1, 0xF3, 0xCF, 0x7C, 0x1F,
  0x3D, 0xE7, 0xC1, 0xF3, 0xDE, 0x7C, 0x1F, 0x3D, 0xE7, 0xC1, 0xF3, 0xFC,
  0xF8, 0x3E, 0x3F, 0xCF, 0x83, 0xE3, 0xF8, 0xF8, 0x3E, 0x3F, 0x8F, 0x83,
  0xE3, 0xF0, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0x07, 0xF8, 0x07, 0xC1, 0xFE, 0x01, 0xF0, 0x7F, 0x80, 0xFC,
  0x1F, 0xE0, 0x3F, 0x07, 0xFC, 0x0F, 0xC3, 0xFF, 0x03, 0xE0, 0xFF, 0xC0,
  0xF8, 0x3F, 0xF0, 0x7E, 0x0F, 0xFC, 0x1F, 0x83, 0xFF, 0x87, 0xE1, 0xFB,
  0xE1, 0xF0, 0x7E, 0xF8, 0x7C, 0x1F, 0xBE, 0x3F, 0x07, 0xCF, 0x8F, 0xC1,
  0xF3, 0xE3, 0xF0, 0xFC, 0xFC, 0xFC, 0x3F, 0x1F, 0x3E, 0x0F, 0xC7, 0xCF,
  0x83, 0xF1, 0xF7, 0xE0, 0xF8, 0x7D, 0xF8, 0x7E, 0x1F, 0xFE, 0x1F, 0x83,
  0xFF, 0x07, 0xE0, 0xFF, 0xC1, 0xF8, 0x3F, 0xF0, 0x7C, 0x0F, 0xFC, 0x1F,
  0x03, 0xFF, 0x0F, 0xC0, 0xFF, 0x83, 0xF0, 0x1F, 0xE0, 0xFC, 0x07, 0xF8,
  0x3E, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x3F, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x7F,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0,
  0x7E, 0x03, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xDF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF0, 0x7C, 0x7F,
  0x1F, 0x07, 0xC7, 0xF1, 0xF0, 0x7C, 0xFF, 0x3E, 0x07, 0xCF, 0xF3, 0xE0,
  0x7D, 0xFF, 0x3E, 0x07, 0xDE, 0xF7, 0xC0, 0x7F, 0xEF, 0x7C, 0x07, 0xFC,
  0xF7, 0xC0, 0x7F, 0xCF, 0x78, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF1, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x7C, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0xFF, 0xCF,
  0xFF, 0xDF, 0xEF, 0xFF, 0x3F, 0xDF, 0xFC, 0x7F, 0x8F, 0xC0, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7, 0xFC, 0x0F, 0xDF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x81, 0xF8, 0x7F,
  0xC7, 0xF8, 0x7F, 0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0xFC, 0xFF, 0xC0, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80,
  0x3F, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xF0,
  0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC3, 0xF8, 0x7F, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xF3, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xF8, 0x1F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F,
  0xC0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x3F, 0xFE, 0xFC,
  0x07, 0xFF, 0x3F, 0x00, 0xFF, 0x8F, 0xC0, 0x0F, 0x83, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE,
  0x0F, 0xC3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00,
  0x7E, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xE7, 0xE0, 0x3F,
  0xFD, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0x83, 0xF8, 0x1F, 0xE0,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x1F, 0xF0, 0x3F, 0xFE, 0xFC,
  0x07, 0xFF, 0x7F, 0x01, 0xFF, 0x9F, 0x80, 0x1F, 0x87, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7,
  0xFE, 0x0F, 0xCF, 0xFF, 0x0F, 0xDF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xF8,
  0x7F, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xC0, 0x7F,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFE, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xF0,
  0x7E, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x8F, 0x83, 0xC0, 0x79,
  0xF8, 0xFE, 0x0F, 0xBF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xE7, 0xF3,
  0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8,
  0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7,
  0xFE, 0x0F, 0xCF, 0xFE, 0x0F, 0xDF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xF8,
  0x7F, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE, 0x1F, 0xE3, 0xF0, 0x1F,
  0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF8,
  0x0F, 0xC7, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x7F, 0xC0, 0x3F,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xC1, 0xFE, 0x07, 0xF0,
  0x7F, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xEF, 0xFE, 0x03, 0xF3, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xFF, 0x3F, 0x07, 0xFF,
  0x3F, 0x0F, 0xFF, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0x81, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00,
  0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFB, 0xF0, 0x3F, 0xE7,
  0xF0, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC1, 0xFE, 0x1F, 0x8F,
  0xFC, 0x3F, 0x3F, 0xF8, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x1F,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xF0, 0x7F, 0xF3, 0xF0, 0x3F, 0xE3,
  0xF0, 0x1F, 0x83, 0xF0, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x3E, 0x0F, 0x83, 0xE7, 0xC1, 0xF0,
  0x78, 0xF8, 0x7E, 0x1F, 0x1F, 0x0F, 0xC3, 0xE3, 0xE3, 0xF8, 0x78, 0x7C,
  0x7F, 0x1F, 0x0F, 0x9E, 0xF3, 0xC1, 0xF3, 0xDE, 0x78, 0x3E, 0xF3, 0xDF,
  0x07, 0xDE, 0x7B, 0xC0, 0xFF, 0x8F, 0x78, 0x1E, 0xF1, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x03, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xF8,
};

const GFXglyph LiberationMono_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 12, 30, 27, 8, -30 },
  { 46, 18, 14, 27, 8, -33 },
  { 78, 27, 30, 27, 1, -30 },
  { 180, 26, 37, 27, 1, -33 },
  { 301, 30, 30, 27, -1, -30 },
  { 414, 25, 30, 27, 0, -30 },
  { 508, 8, 14, 27, 13, -33 },
  { 522, 17, 42, 27, 7, -33 },
  { 612, 17, 42, 27, 3, -33 },
  { 702, 18, 17, 27, 7, -33 },
  { 741, 23, 23, 27, 2, -26 },
  { 808, 13, 15, 27, 2, -7 },
  { 833, 13, 5, 27, 7, -14 },
  { 842, 8, 7, 27, 8, -7 },
  { 849, 29, 33, 27, 0, -33 },
  { 969, 24, 30, 27, 2, -30 },
  { 1059, 23, 30, 27, 1, -30 },
  { 1146, 26, 30, 27, 0, -30 },
  { 1244, 25, 30, 27, 1, -30 },
  { 1338, 25, 30, 27, 0, -30 },
  { 1432, 25, 30, 27, 1, -30 },
  { 1526, 23, 30, 27, 3, -30 },
  { 1613, 22, 30, 27, 5, -30 },
  { 1696, 24, 30, 27, 2, -30 },
  { 1786, 24, 30, 27, 2, -30 },
  { 1876, 11, 24, 27, 8, -24 },
  { 1909, 16, 32, 27, 3, -24 },
  { 1973, 23, 25, 27, 2, -27 },
  { 2045, 23, 17, 27, 2, -23 },
  { 2094, 23, 25, 27, 2, -27 },
  { 2166, 24, 30, 27, 3, -30 },
  { 2256, 28, 39, 27, 0, -33 },
  { 2393, 27, 30, 27, -2, -30 },
  { 2495, 25, 30, 27, 1, -30 },
  { 2589, 25, 30, 27, 2, -30 },
  { 2683, 25, 30, 27, 1, -30 },
  { 2777, 27, 30, 27, 1, -30 },
  { 2879, 27, 30, 27, 1, -30 },
  { 2981, 24, 30, 27, 2, -30 },
  { 3071, 26, 30, 27, 1, -30 },
  { 3169, 26, 30, 27, 1, -30 },
  { 3267, 24, 30, 27, 2, -30 },
  { 3357, 29, 30, 27, 1, -30 },
  { 3466, 21, 30, 27, 2, -30 },
  { 3545, 28, 30, 27, 0, -30 },
  { 3650, 26, 30, 27, 1, -30 },
  { 3748, 25, 30, 27, 2, -30 },
  { 3842, 26, 30, 27, 1, -30 },
  { 3940, 25, 39, 27, 2, -30 },
  { 4062, 26, 30, 27, 1, -30 },
  { 4160, 27, 30, 27, 0, -30 },
  { 4262, 25, 30, 27, 4, -30 },
  { 4356, 26, 30, 27, 2, -30 },
  { 4454, 26, 30, 27, 4, -30 },
  { 4552, 28, 30, 27, 2, -30 },
  { 4657, 32, 30, 27, -2, -30 },
  { 4777, 26, 30, 27, 4, -30 },
  { 4875, 28, 30, 27, 0, -30 },
  { 4980, 21, 42, 27, 4, -33 },
  { 5091, 17, 33, 27, 6, -33 },
  { 5162, 22, 42, 27, 1, -33 },
  { 5278, 24, 20, 27, 1, -31 },
  { 5338, 27, 2, 27, -3, 3 },
  { 5345, 11, 6, 27, 11, -32 },
  { 5354, 23, 24, 27, 1, -24 },
  { 5423, 24, 33, 27, 1, -33 },
  { 5522, 23, 24, 27, 2, -24 },
  { 5591, 26, 33, 27, 2, -33 },
  { 5699, 23, 24, 27, 2, -24 },
  { 5768, 25, 33, 27, 4, -33 },
  { 5872, 26, 33, 27, 1, -24 },
  { 5980, 24, 33, 27, 1, -33 },
  { 6079, 24, 33, 27, 0, -33 },
  { 6178, 24, 42, 27, -1, -33 },
  { 6304, 26, 33, 27, 1, -33 },
  { 6412, 24, 33, 27, 0, -33 },
  { 6511, 28, 24, 27, -1, -24 },
  { 6595, 24, 24, 27, 1, -24 },
  { 6667, 23, 24, 27, 2, -24 },
  { 6736, 26, 33, 27, -1, -24 },
  { 6844, 24, 33, 27, 2, -24 },
  { 6943, 23, 24, 27, 3, -24 },
  { 7012, 24, 24, 27, 1, -24 },
  { 7084, 19, 30, 27, 5, -30 },
  { 7156, 24, 24, 27, 2, -24 },
  { 7228, 26, 24, 27, 3, -24 },
  { 7306, 27, 24, 27, 2, -24 },
  { 7387, 29, 24, 27, -1, -24 },
  { 7474, 29, 33, 27, -1, -24 },
  { 7594, 24, 24, 27, 1, -24 },
  { 7666, 23, 42, 27, 4, -33 },
  { 7787, 5, 43, 27, 11, -33 },
  { 7814, 23, 42, 27, 0, -33 },
  { 7935, 24, 7, 27, 2, -18 },
};

const GFXfont LiberationMono_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic45pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _LIBERATIONMONO_BOLDITALIC45PT7B_H_
