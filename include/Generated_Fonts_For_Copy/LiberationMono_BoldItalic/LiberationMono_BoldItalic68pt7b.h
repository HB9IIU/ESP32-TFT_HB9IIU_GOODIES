#ifndef _LIBERATIONMONO_BOLDITALIC68PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x3F,
  0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x1C, 0xFF, 0xF0, 0x1F, 0xF8, 0x78, 0x7F, 0xE0, 0x3F, 0xE0, 0xF0,
  0x7F, 0xC0, 0xFF, 0x81, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0x03, 0x80, 0x07, 0xFC, 0x1E, 0x00, 0x00, 0x0F, 0xF8, 0x3C,
  0x00, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x00,
  0x7F, 0xFD, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1C, 0x7F, 0xF8, 0x00, 0x00, 0x38, 0x3F, 0xF8, 0x00, 0x00,
  0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x7F,
  0x80, 0xF8, 0x07, 0x00, 0xFF, 0x1F, 0xF0, 0x0E, 0x03, 0xFE, 0x3F, 0xE0,
  0x3C, 0x07, 0xFC, 0x7F, 0xE0, 0x78, 0x0F, 0xF8, 0x7F, 0xC0, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC1, 0xC0, 0xFF, 0xC1, 0xFF, 0xE3, 0x8F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x1E, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xE7,
  0xFC, 0x0F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x1F, 0xF0, 0x1F, 0xF3, 0xF8, 0x3F, 0xC0,
  0x1F, 0xEF, 0xE0, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x1F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xC1, 0xF8,
  0x18, 0xFC, 0x7E, 0x3F, 0x3F, 0xDF, 0xBF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFD, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0xFF, 0x03, 0xF0, 0x3F, 0x00, 0x38, 0x07, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFE,
  0x3F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0xCF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F, 0xE7, 0xFE, 0x3F,
  0x87, 0xFC, 0xFF, 0x87, 0xF0, 0xFF, 0x9F, 0xF0, 0xFE, 0x1F, 0xF3, 0xFE,
  0x1F, 0xC7, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0xDF, 0xF8, 0xFE, 0x1F, 0xF3,
  0xFF, 0x1F, 0xC3, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x1E, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFF,
  0xC0, 0x1F, 0xF3, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x7F, 0xC0, 0x7F, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xFC, 0xFF, 0x80, 0x0F,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0x1F, 0x7C, 0x07, 0xC0, 0xFF,
  0xE7, 0x9F, 0x03, 0xE0, 0x7F, 0xFB, 0xE7, 0xC0, 0xF8, 0x3F, 0x0E, 0xF9,
  0xF0, 0x7C, 0x1F, 0x81, 0xBC, 0x7C, 0x1F, 0x07, 0xC0, 0x7F, 0x1F, 0x07,
  0x83, 0xE0, 0x1F, 0x87, 0x83, 0xE1, 0xF0, 0x07, 0xE1, 0xE0, 0xF0, 0x7C,
  0x01, 0xF8, 0x78, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x1F, 0x0F, 0x80, 0x3F,
  0x0F, 0x87, 0x87, 0xC0, 0x0F, 0x83, 0xC1, 0xE1, 0xF0, 0x03, 0xE0, 0xF0,
  0xF8, 0xF8, 0x01, 0xF8, 0x3C, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x0F, 0x0F,
  0x80, 0x1F, 0x07, 0x83, 0xC7, 0xE0, 0x0F, 0x81, 0xE1, 0xF1, 0xF0, 0x03,
  0xE0, 0xF8, 0x7C, 0x7C, 0x01, 0xF8, 0x3C, 0x1F, 0x1F, 0x00, 0x7C, 0x0F,
  0x07, 0x87, 0xC0, 0x3F, 0x07, 0xC1, 0xE3, 0xF0, 0x0F, 0x81, 0xE0, 0x78,
  0xF8, 0x07, 0xE0, 0xF8, 0x3E, 0x3E, 0x01, 0xF8, 0x3C, 0x0F, 0x8F, 0x80,
  0xFC, 0x1F, 0x03, 0xE3, 0xF0, 0x77, 0x0F, 0x80, 0xF8, 0x7C, 0x79, 0xC7,
  0xC0, 0x3E, 0x1F, 0xFE, 0x7F, 0xE0, 0x0F, 0x87, 0xFF, 0x1F, 0xF0, 0x03,
  0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x02, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x3F, 0x81, 0xFF, 0x80, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x83, 0xFF, 0x00, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x01, 0xE0, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x7F,
  0xE0, 0x7F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF,
  0xEF, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xFC, 0x0F,
  0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xF7, 0xF0, 0x0F,
  0xFF, 0xE0, 0x7E, 0xFE, 0x01, 0xFD, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF,
  0x83, 0xF7, 0xF0, 0x07, 0xF7, 0xF0, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x1F,
  0x9F, 0xC0, 0x3F, 0xDF, 0xC7, 0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0xFC, 0xFF,
  0x00, 0xFE, 0x3F, 0x1F, 0x9F, 0xC0, 0x1F, 0xC7, 0xE7, 0xF3, 0xF8, 0x03,
  0xF8, 0xFC, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xBF, 0x9F, 0xE0, 0x1F, 0xE3,
  0xF7, 0xE3, 0xFC, 0x03, 0xF8, 0x7E, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC1, 0xFC, 0x01,
  0xFC, 0x1F, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x1F, 0xEF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF7, 0xF8, 0x1F, 0xF0,
  0x07, 0xFB, 0xFC, 0x0F, 0xF8, 0x07, 0xFD, 0xFE, 0x07, 0xF8, 0x03, 0xFE,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x1F, 0xC1,
  0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x7F, 0x80,
  0x3F, 0xE3, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xCF, 0xF8, 0x03, 0xFC, 0x1F, 0xE7,
  0xF8, 0x03, 0xFE, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x07, 0xF9, 0xFE, 0x00,
  0xFF, 0x83, 0xFC, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0xBF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC, 0x03, 0xFC,
  0x7F, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0x3F, 0x80, 0x3F, 0xCF, 0xDF,
  0xDF, 0xE0, 0x0F, 0xF7, 0xF7, 0xF7, 0xF8, 0x03, 0xFD, 0xFD, 0xFD, 0xFC,
  0x00, 0xFF, 0x7E, 0x7F, 0x7F, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x0F,
  0xEF, 0xC7, 0xFF, 0xE0, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0x0F, 0xDF, 0xF0, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0,
  0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0xC0,
  0x07, 0xFC, 0x7F, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0xFC, 0x01, 0xFF, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE7, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xFC,
  0x00, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x81,
  0xFF, 0x80, 0x03, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xFF, 0xC7, 0xFC, 0x00,
  0x7F, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF9, 0xFF, 0x00, 0x0F,
  0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x40, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0x9F,
  0xF0, 0x03, 0xFF, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFC, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0x80, 0x0F, 0xFF,
  0xF9, 0xFF, 0x00, 0x1F, 0xFF, 0xE3, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xFF, 0x80,
  0x3F, 0xE3, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF,
  0xFF, 0xC0, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00,
  0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0x80,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFE, 0x3F, 0xC0, 0xFF,
  0x80, 0x7F, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0x3F, 0xF8, 0xFF, 0xF0, 0x3F,
  0xBF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF,
  0x71, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x1F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x01,
  0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xC3,
  0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0x01,
  0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x83, 0xFF,
  0xC0, 0x01, 0xFF, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xFF, 0xC0, 0x07,
  0xFD, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF,
  0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xFE,
  0x00, 0x7F, 0xCF, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0xFF, 0xE0, 0x03, 0xFF,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xBF,
  0xE0, 0x0F, 0xFF, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF,
  0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0x3F, 0xFF, 0xE0, 0x7F, 0xDF,
  0xFF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x81, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x10, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x38, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x30, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF,
  0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xDF, 0x0F, 0xE0, 0x3F, 0x87, 0xEF, 0x87, 0xF0, 0x1F, 0xC3, 0xF7,
  0xE3, 0xF8, 0x0F, 0xE3, 0xF3, 0xF3, 0xF8, 0x07, 0xF1, 0xF9, 0xF9, 0xFC,
  0x03, 0xF9, 0xF8, 0xFC, 0xFE, 0x01, 0xFC, 0xF8, 0x7E, 0xFE, 0x00, 0xFE,
  0xFC, 0x3F, 0x7F, 0x00, 0x7F, 0xFC, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x07,
  0xDF, 0x80, 0x1F, 0xBE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0x3F, 0xFF, 0xF8, 0x00, 0x37, 0xFF, 0xFF, 0xF0, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0x80, 0x7F, 0xFF, 0xFE, 0xE0, 0x00, 0xFF, 0xFF, 0xE8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph LiberationMono_BoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 19, 45, 41, 12, -45 },
  { 108, 28, 21, 41, 11, -49 },
  { 182, 41, 45, 41, 1, -45 },
  { 413, 39, 56, 41, 1, -50 },
  { 686, 45, 47, 41, -1, -46 },
  { 951, 39, 46, 41, -1, -45 },
  { 1176, 12, 21, 41, 19, -49 },
  { 1208, 27, 63, 41, 10, -49 },
  { 1421, 27, 63, 41, 4, -49 },
  { 1634, 26, 25, 41, 11, -49 },
  { 1716, 34, 35, 41, 3, -40 },
  { 1865, 20, 22, 41, 3, -10 },
  { 1920, 21, 8, 41, 10, -22 },
  { 1941, 12, 10, 41, 12, -10 },
  { 1956, 45, 50, 41, -1, -49 },
  { 2238, 35, 47, 41, 4, -46 },
  { 2444, 35, 45, 41, 1, -45 },
  { 2641, 38, 46, 41, 1, -46 },
  { 2860, 37, 47, 41, 2, -46 },
  { 3078, 37, 45, 41, 1, -45 },
  { 3287, 38, 46, 41, 2, -45 },
  { 3506, 35, 47, 41, 4, -46 },
  { 3712, 33, 45, 41, 8, -45 },
  { 3898, 37, 47, 41, 2, -46 },
  { 4116, 36, 47, 41, 3, -46 },
  { 4328, 17, 36, 41, 12, -36 },
  { 4405, 24, 48, 41, 5, -36 },
  { 4549, 34, 37, 41, 3, -41 },
  { 4707, 34, 25, 41, 3, -35 },
  { 4814, 34, 37, 41, 3, -41 },
  { 4972, 35, 46, 41, 5, -46 },
  { 5174, 42, 58, 41, 0, -49 },
  { 5479, 40, 45, 41, -3, -45 },
  { 5704, 39, 45, 41, 1, -45 },
  { 5924, 38, 47, 41, 3, -46 },
  { 6148, 39, 45, 41, 1, -45 },
  { 6368, 41, 45, 41, 1, -45 },
  { 6599, 40, 45, 41, 2, -45 },
  { 6824, 36, 47, 41, 3, -46 },
  { 7036, 40, 45, 41, 1, -45 },
  { 7261, 39, 45, 41, 2, -45 },
  { 7481, 37, 46, 41, 2, -45 },
  { 7694, 44, 45, 41, 1, -45 },
  { 7942, 31, 45, 41, 4, -45 },
  { 8117, 43, 45, 41, 0, -45 },
  { 8359, 41, 45, 41, 1, -45 },
  { 8590, 38, 47, 41, 2, -46 },
  { 8814, 40, 45, 41, 1, -45 },
  { 9039, 38, 59, 41, 2, -46 },
  { 9320, 40, 45, 41, 1, -45 },
  { 9545, 40, 47, 41, 0, -46 },
  { 9780, 38, 45, 41, 6, -45 },
  { 9994, 39, 46, 41, 3, -45 },
  { 10219, 41, 45, 41, 5, -45 },
  { 10450, 42, 45, 41, 4, -45 },
  { 10687, 48, 45, 41, -3, -45 },
  { 10957, 41, 45, 41, 5, -45 },
  { 11188, 43, 45, 41, -1, -45 },
  { 11430, 32, 63, 41, 6, -49 },
  { 11682, 25, 50, 41, 9, -49 },
  { 11839, 33, 63, 41, 2, -49 },
  { 12099, 37, 30, 41, 1, -47 },
  { 12238, 42, 3, 41, -5, 4 },
  { 12254, 16, 9, 41, 17, -48 },
  { 12272, 35, 38, 41, 2, -37 },
  { 12439, 37, 50, 41, 1, -49 },
  { 12671, 35, 38, 41, 3, -37 },
  { 12838, 39, 50, 41, 3, -49 },
  { 13082, 35, 38, 41, 3, -37 },
  { 13249, 37, 50, 41, 6, -50 },
  { 13481, 39, 51, 41, 1, -37 },
  { 13730, 37, 49, 41, 1, -49 },
  { 13957, 36, 49, 41, 0, -49 },
  { 14178, 37, 63, 41, -2, -49 },
  { 14470, 39, 49, 41, 2, -49 },
  { 14709, 36, 49, 41, 0, -49 },
  { 14930, 41, 37, 41, -1, -37 },
  { 15120, 37, 37, 41, 1, -37 },
  { 15292, 35, 38, 41, 3, -37 },
  { 15459, 39, 51, 41, -1, -37 },
  { 15708, 37, 51, 41, 3, -37 },
  { 15944, 34, 37, 41, 5, -37 },
  { 16102, 36, 38, 41, 2, -37 },
  { 16273, 28, 46, 41, 8, -45 },
  { 16434, 36, 37, 41, 3, -36 },
  { 16601, 38, 36, 41, 5, -36 },
  { 16772, 41, 36, 41, 3, -36 },
  { 16957, 44, 36, 41, -2, -36 },
  { 17155, 44, 50, 41, -1, -36 },
  { 17430, 37, 36, 41, 1, -36 },
  { 17597, 35, 63, 41, 6, -49 },
  { 17873, 9, 64, 41, 16, -49 },
  { 17945, 35, 63, 41, 0, -49 },
  { 18221, 36, 11, 41, 3, -28 },
};

const GFXfont LiberationMono_BoldItalic68pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic68pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic68pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _LIBERATIONMONO_BOLDITALIC68PT7B_H_
