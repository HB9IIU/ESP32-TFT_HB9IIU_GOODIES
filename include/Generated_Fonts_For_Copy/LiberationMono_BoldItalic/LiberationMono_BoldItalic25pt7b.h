#ifndef _LIBERATIONMONO_BOLDITALIC25PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE0, 0x00,
  0x0E, 0x1C, 0x38, 0x79, 0xDC, 0x77, 0x1D, 0xCE, 0x73, 0x98, 0xEE, 0x3B,
  0x8C, 0x01, 0x86, 0x03, 0x18, 0x0C, 0x30, 0x18, 0xC3, 0xFF, 0xE7, 0xFF,
  0xC1, 0x0C, 0x06, 0x18, 0x0C, 0x60, 0x30, 0xC1, 0xFF, 0xF7, 0xFF, 0xC3,
  0x0C, 0x06, 0x30, 0x18, 0x60, 0x31, 0x80, 0x00, 0x40, 0x00, 0x80, 0x0F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0x9B, 0xCF, 0x26, 0x1E, 0x40, 0x1F, 0x80,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0B, 0xE0, 0x13, 0xDE, 0x67, 0x9E, 0xCE, 0x3F,
  0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0x18, 0x00, 0x30, 0x00, 0x0F, 0x01, 0x8F,
  0xC1, 0x86, 0x61, 0x86, 0x31, 0x83, 0x19, 0x81, 0x9D, 0x80, 0xFD, 0x80,
  0x3D, 0x80, 0x01, 0x9E, 0x01, 0xDF, 0x01, 0xD9, 0xC0, 0xCC, 0xE0, 0xCE,
  0x60, 0xC7, 0x30, 0xC1, 0xF0, 0xC0, 0xF0, 0x01, 0xF0, 0x1F, 0xE0, 0x73,
  0x83, 0x8E, 0x0E, 0x30, 0x3B, 0x80, 0xFC, 0x07, 0xC7, 0x3F, 0x1D, 0xDC,
  0xEE, 0x3B, 0x38, 0xFC, 0xE1, 0xE3, 0x87, 0xCF, 0xFF, 0xCF, 0x8F, 0x77,
  0x77, 0xEE, 0xEE, 0x03, 0x83, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0,
  0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x00, 0x0E, 0x03,
  0x84, 0xC9, 0xFF, 0x7F, 0x8F, 0x87, 0x73, 0x9C, 0x62, 0x00, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x1E, 0x38, 0xF1, 0xC3,
  0x0E, 0x18, 0x60, 0xFF, 0xFF, 0xF8, 0x7B, 0x9C, 0xE0, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x7F,
  0x87, 0xFE, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xEC, 0xEE, 0x67, 0x77, 0x7F,
  0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x1E, 0x3F, 0xF1, 0xFF, 0x03, 0xE0, 0x01,
  0xE0, 0x3E, 0x07, 0xC3, 0xFC, 0x3D, 0xC3, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x1F, 0xF0, 0xFF, 0xC7, 0x87, 0x1C, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFC, 0x07, 0xE0, 0x7F, 0xC7, 0xFE, 0x78, 0x73, 0x83, 0x80,
  0x3C, 0x1F, 0xC0, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x1D, 0xC0, 0xEF, 0x0F,
  0x7F, 0xF1, 0xFF, 0x07, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xB8, 0x1C, 0xE0, 0xE7, 0x87, 0x1C, 0x38, 0x71, 0xC1, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1F, 0xFC, 0x7F,
  0xE1, 0xFF, 0x8F, 0x00, 0x38, 0x00, 0xEF, 0x83, 0xFF, 0x1F, 0xFC, 0x78,
  0xF8, 0x01, 0xE0, 0x07, 0x38, 0x1C, 0xF1, 0xF3, 0xFF, 0x87, 0xFC, 0x0F,
  0xC0, 0x07, 0xC1, 0xFF, 0x3F, 0xF3, 0xC7, 0x78, 0x07, 0x7C, 0xFF, 0xEF,
  0xFE, 0xF0, 0xEE, 0x0F, 0xE0, 0xEE, 0x0E, 0xF1, 0xEF, 0xFC, 0x7F, 0x83,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0x07, 0xE0, 0x7F, 0xC7, 0x1E, 0x78, 0x73, 0x83, 0x9C, 0x3C, 0xF1,
  0xC3, 0xFC, 0x1F, 0xE3, 0xC7, 0xBC, 0x1D, 0xE0, 0xEE, 0x0F, 0x78, 0x71,
  0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0xBC,
  0x1D, 0xE1, 0xEF, 0x1F, 0x7F, 0xF9, 0xFF, 0x87, 0x9C, 0x01, 0xEF, 0x1E,
  0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x1C, 0x38, 0x71, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE3, 0x87, 0x0E, 0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0,
  0x60, 0x60, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C,
  0x03, 0x80, 0x1F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7C, 0x00, 0xE0, 0x1F, 0x07, 0xF9, 0xFE, 0x3F, 0x81,
  0xE0, 0x0C, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFE, 0xF0, 0xFF, 0x07,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1C, 0x38,
  0x60, 0x31, 0x80, 0x63, 0x3B, 0x4C, 0xFE, 0x93, 0x99, 0x6E, 0x36, 0xD8,
  0x4D, 0x31, 0x96, 0xC2, 0x6D, 0x8C, 0xDB, 0x3B, 0x37, 0xFC, 0x67, 0x30,
  0xC0, 0x00, 0xC0, 0x01, 0xC1, 0x81, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x01, 0xCE, 0x07,
  0x1E, 0x0E, 0x1C, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0x81, 0xCF, 0x03,
  0x9C, 0x07, 0xF8, 0x0F, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF1,
  0xC1, 0xC7, 0x87, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0xF8, 0x70, 0x79, 0xE0,
  0x73, 0xC1, 0xE7, 0x83, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xE0,
  0x3F, 0xE1, 0xFF, 0x8F, 0x8F, 0x78, 0x3D, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x02, 0x3C, 0x1E, 0xF8, 0xF1, 0xFF, 0x87, 0xFC,
  0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x38, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0xC3,
  0xC7, 0x8F, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0x1F, 0xFE,
  0x7F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1F, 0xFE, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F,
  0x1E, 0x78, 0x39, 0xE0, 0x07, 0x00, 0x3C, 0x7E, 0xF3, 0xFB, 0xCF, 0xEF,
  0x07, 0xBC, 0x1C, 0xF8, 0xF1, 0xFF, 0xC7, 0xFE, 0x07, 0xC0, 0x1E, 0x0E,
  0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xF1, 0xC1, 0xC7, 0x87, 0x8F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x70, 0x71, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x1C, 0x1C, 0x78, 0x38, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xC0, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x03, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x0C, 0x39, 0xE3, 0xCF, 0x1E, 0x7F, 0xE1, 0xFE, 0x07, 0xC0, 0x1E, 0x0F,
  0x0F, 0x0F, 0x07, 0x8F, 0x03, 0x8F, 0x01, 0xCF, 0x01, 0xEF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0x78, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0xC1, 0xC1, 0xE1, 0xE0, 0xF8, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1F, 0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3F, 0x6E, 0x3F, 0x6C, 0x37, 0xFC,
  0x73, 0xDC, 0x73, 0xDC, 0x73, 0x9C, 0x73, 0x98, 0x60, 0x38, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x38, 0x1F, 0x0E, 0x3E, 0x1C, 0x7C, 0x38, 0xF8, 0xF1,
  0xF9, 0xC7, 0x73, 0x8E, 0xE7, 0x1D, 0xCE, 0x3B, 0xBC, 0x73, 0xF1, 0xE7,
  0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x3C, 0x78, 0x78, 0x03, 0xE0,
  0x3F, 0xE1, 0xFF, 0x8F, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F,
  0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xF1, 0xF3, 0xFF, 0x87, 0xFC,
  0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF1, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x3F, 0xE1,
  0xFF, 0x8F, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3B,
  0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xF1, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0,
  0x0E, 0x00, 0x3C, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF8, 0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1F, 0xFE,
  0x3F, 0xF0, 0x7F, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x8F, 0x0F, 0x0F, 0x1C,
  0x1E, 0x78, 0x3C, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF3, 0xC1,
  0xC7, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF7,
  0x81, 0xEF, 0x87, 0x8F, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x39, 0xE0, 0xE7,
  0x87, 0x9E, 0x1E, 0x70, 0x79, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xF1, 0xE3,
  0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83,
  0xC7, 0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x3C, 0xF0, 0x79, 0xC0, 0xF7, 0x80,
  0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x70,
  0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x73, 0x9C, 0x73, 0x9C, 0x77,
  0x9C, 0x77, 0xB8, 0x6F, 0xB8, 0x6D, 0xB0, 0xFD, 0xF0, 0xF9, 0xF0, 0xF9,
  0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xC0, 0x0E, 0x07, 0x87, 0x87, 0x81,
  0xC3, 0x80, 0xF3, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x01, 0xCF, 0x01, 0xC7, 0x81, 0xE1,
  0xE1, 0xE0, 0xF1, 0xE0, 0x38, 0xF0, 0x1C, 0xE0, 0x79, 0xE1, 0xE3, 0xC7,
  0x83, 0x8E, 0x07, 0xB8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x07, 0xF0, 0xFF, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xF0, 0xFF, 0x00, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0x60, 0x0F, 0xF0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xDC, 0x06, 0x30, 0x38,
  0xE1, 0xC3, 0x86, 0x0E, 0x38, 0x19, 0xC0, 0x77, 0x01, 0xC0, 0xFF, 0xFE,
  0xF0, 0xE1, 0xC0, 0x07, 0xC1, 0xFF, 0x3C, 0xF3, 0x87, 0x00, 0x70, 0x0F,
  0x1F, 0xF7, 0xFE, 0xF0, 0xEF, 0x0E, 0xE1, 0xEE, 0x3E, 0xFE, 0xF7, 0x8F,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0xF0, 0x77, 0xE1, 0xE3,
  0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x0F, 0x38, 0x39, 0xE0,
  0xE7, 0x87, 0x9F, 0x3C, 0x77, 0xE1, 0xCF, 0x00, 0x07, 0xE0, 0xFF, 0x8F,
  0x1E, 0x70, 0xF7, 0x86, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83,
  0xBC, 0x3C, 0xE3, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x0F, 0x3C, 0x7E, 0xE3, 0xCF, 0x9E, 0x1E, 0x70, 0x79, 0xC1,
  0xEF, 0x07, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0x7E,
  0xE0, 0xF3, 0x80, 0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0xF7, 0x83, 0xB8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x1C, 0xE1, 0xC7, 0xFC,
  0x0F, 0x80, 0x01, 0xFC, 0x1F, 0xF0, 0xF0, 0x03, 0x80, 0x7F, 0xFB, 0xFF,
  0xC1, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x07, 0xDE,
  0x1F, 0xFC, 0x78, 0xF0, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0F, 0x3C,
  0x1C, 0x78, 0x38, 0xF0, 0x71, 0xE1, 0xE1, 0xE7, 0xC3, 0xFF, 0x83, 0xCE,
  0x00, 0x1C, 0x78, 0x78, 0x79, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0xF8, 0x77, 0xF1, 0xFF, 0xC7, 0x8F,
  0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x87,
  0x9C, 0x1E, 0x70, 0x71, 0xC1, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x7F,
  0x83, 0xFC, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x3C, 0xF1, 0xE3, 0x8F, 0x0E, 0x78, 0x3B, 0xC1, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7B, 0xC1, 0xCF, 0x0F, 0x1E, 0x3C, 0x78, 0xF0, 0xE3, 0x83,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0x3B, 0x9C, 0x6F, 0x7C, 0xE7,
  0x39, 0xCE, 0x77, 0x18, 0xEE, 0x71, 0x9C, 0xE7, 0x39, 0xCE, 0x63, 0x9D,
  0xC6, 0x3B, 0x9C, 0x67, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x1C, 0xF8,
  0x77, 0xF1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x0E,
  0x78, 0x39, 0xE0, 0xE7, 0x87, 0x9C, 0x1E, 0x70, 0x71, 0xC1, 0xC0, 0x07,
  0xE0, 0xFF, 0x8F, 0x1E, 0xF0, 0xF7, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x77, 0x83, 0xBC, 0x3D, 0xE3, 0xC7, 0xFC, 0x1F, 0x80, 0x1C, 0xF0,
  0x77, 0xE1, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x0F,
  0x78, 0x39, 0xE0, 0xE7, 0x87, 0x9F, 0x3C, 0x77, 0xE1, 0xCF, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x38, 0x7E, 0xE3,
  0xCF, 0x9E, 0x1E, 0x70, 0x79, 0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0x7E, 0xE0, 0xF3, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0xF3, 0xBF, 0x3F, 0xF3, 0xE0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0xE0, 0xFF, 0x8E, 0x1E, 0x70, 0x77, 0x80, 0x1F,
  0x80, 0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x03, 0xB8, 0x1D, 0xE1, 0xC7, 0xFC,
  0x1F, 0xC0, 0x0C, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xCE, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xFE, 0x3F, 0x00,
  0x38, 0x39, 0xC1, 0xDE, 0x0E, 0xF0, 0xF7, 0x87, 0xB8, 0x39, 0xC1, 0xCE,
  0x0E, 0xF0, 0xF7, 0x87, 0xBC, 0x79, 0xFF, 0xC7, 0xEE, 0x3C, 0x70, 0xE0,
  0x3F, 0x81, 0xEF, 0x07, 0x3C, 0x3C, 0xF0, 0xE1, 0xC7, 0x87, 0x1C, 0x1C,
  0xF0, 0x73, 0x81, 0xDE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x37, 0x18, 0xEE, 0x71, 0xDC, 0xF3, 0x3B,
  0x6E, 0x76, 0xDC, 0xED, 0xB1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F, 0x1E,
  0x1C, 0x38, 0x00, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1C, 0x07, 0x38, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E,
  0x70, 0x3C, 0x78, 0x38, 0x38, 0x70, 0x3C, 0x1C, 0x07, 0x8F, 0x07, 0x87,
  0x83, 0x83, 0xC3, 0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1E, 0xF0,
  0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x01, 0xF8, 0x1F, 0xC1, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1F,
  0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0x7F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x7F, 0x03,
  0xF0, 0x00, 0x3E, 0x0B, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 16, 15, 4, -16 },
  { 15, 10, 8, 15, 4, -18 },
  { 25, 15, 16, 15, 0, -16 },
  { 55, 15, 20, 15, 0, -18 },
  { 93, 17, 16, 15, -1, -16 },
  { 127, 14, 16, 15, 0, -16 },
  { 155, 4, 8, 15, 7, -18 },
  { 159, 9, 23, 15, 4, -18 },
  { 185, 10, 23, 15, 1, -18 },
  { 214, 10, 9, 15, 4, -18 },
  { 226, 13, 13, 15, 1, -15 },
  { 248, 7, 8, 15, 1, -4 },
  { 255, 7, 3, 15, 4, -8 },
  { 258, 5, 4, 15, 4, -4 },
  { 261, 16, 18, 15, 0, -18 },
  { 297, 13, 16, 15, 1, -16 },
  { 323, 12, 16, 15, 1, -16 },
  { 347, 14, 16, 15, 0, -16 },
  { 375, 13, 16, 15, 1, -16 },
  { 401, 14, 16, 15, 0, -16 },
  { 429, 14, 16, 15, 1, -16 },
  { 457, 12, 16, 15, 2, -16 },
  { 481, 12, 16, 15, 3, -16 },
  { 505, 13, 16, 15, 1, -16 },
  { 531, 13, 16, 15, 1, -16 },
  { 557, 7, 14, 15, 4, -14 },
  { 570, 9, 18, 15, 2, -14 },
  { 591, 13, 13, 15, 1, -15 },
  { 613, 13, 10, 15, 1, -13 },
  { 630, 13, 13, 15, 1, -15 },
  { 652, 13, 16, 15, 2, -16 },
  { 678, 15, 21, 15, 0, -18 },
  { 718, 15, 16, 15, -1, -16 },
  { 748, 15, 16, 15, 0, -16 },
  { 778, 14, 16, 15, 1, -16 },
  { 806, 15, 16, 15, 0, -16 },
  { 836, 15, 16, 15, 0, -16 },
  { 866, 14, 16, 15, 1, -16 },
  { 894, 14, 16, 15, 1, -16 },
  { 922, 15, 16, 15, 0, -16 },
  { 952, 14, 16, 15, 1, -16 },
  { 980, 13, 16, 15, 1, -16 },
  { 1006, 17, 16, 15, 0, -16 },
  { 1040, 12, 16, 15, 1, -16 },
  { 1064, 16, 16, 15, 0, -16 },
  { 1096, 15, 16, 15, 0, -16 },
  { 1126, 14, 16, 15, 1, -16 },
  { 1154, 15, 16, 15, 0, -16 },
  { 1184, 14, 21, 15, 1, -16 },
  { 1221, 15, 16, 15, 0, -16 },
  { 1251, 15, 16, 15, 0, -16 },
  { 1281, 14, 16, 15, 2, -16 },
  { 1309, 14, 16, 15, 1, -16 },
  { 1337, 15, 16, 15, 2, -16 },
  { 1367, 16, 16, 15, 1, -16 },
  { 1399, 17, 16, 15, -1, -16 },
  { 1433, 15, 16, 15, 2, -16 },
  { 1463, 15, 16, 15, 0, -16 },
  { 1493, 12, 23, 15, 2, -18 },
  { 1528, 10, 18, 15, 3, -18 },
  { 1551, 12, 23, 15, 1, -18 },
  { 1586, 14, 11, 15, 0, -17 },
  { 1606, 15, 1, 15, -2, 2 },
  { 1608, 6, 3, 15, 6, -17 },
  { 1611, 12, 14, 15, 1, -14 },
  { 1632, 14, 18, 15, 0, -18 },
  { 1664, 13, 14, 15, 1, -14 },
  { 1687, 14, 18, 15, 1, -18 },
  { 1719, 13, 14, 15, 1, -14 },
  { 1742, 14, 18, 15, 2, -18 },
  { 1774, 15, 19, 15, 0, -14 },
  { 1810, 14, 18, 15, 0, -18 },
  { 1842, 13, 18, 15, 0, -18 },
  { 1872, 14, 23, 15, -1, -18 },
  { 1913, 14, 18, 15, 1, -18 },
  { 1945, 13, 18, 15, 0, -18 },
  { 1975, 15, 14, 15, 0, -14 },
  { 2002, 14, 14, 15, 0, -14 },
  { 2027, 13, 14, 15, 1, -14 },
  { 2050, 14, 19, 15, 0, -14 },
  { 2084, 14, 19, 15, 1, -14 },
  { 2118, 12, 14, 15, 2, -14 },
  { 2139, 13, 14, 15, 1, -14 },
  { 2162, 10, 17, 15, 3, -17 },
  { 2184, 13, 14, 15, 1, -14 },
  { 2207, 14, 14, 15, 2, -14 },
  { 2232, 15, 14, 15, 1, -14 },
  { 2259, 16, 14, 15, -1, -14 },
  { 2287, 17, 19, 15, -1, -14 },
  { 2328, 14, 14, 15, 0, -14 },
  { 2353, 13, 23, 15, 2, -18 },
  { 2391, 3, 24, 15, 6, -18 },
  { 2400, 13, 23, 15, 0, -18 },
  { 2438, 13, 4, 15, 1, -10 },
};

const GFXfont LiberationMono_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic25pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _LIBERATIONMONO_BOLDITALIC25PT7B_H_
