#ifndef _LIBERATIONMONO_BOLDITALIC33PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x0F,
  0x87, 0xC0, 0x78, 0xFB, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x73,
  0xC7, 0x9C, 0x3C, 0xE1, 0xE7, 0x0E, 0x00, 0x00, 0x30, 0x60, 0x07, 0x06,
  0x00, 0x60, 0xE0, 0x0E, 0x0C, 0x00, 0xC1, 0xC0, 0x1C, 0x18, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x03, 0x83, 0x00, 0x30, 0x70, 0x07, 0x06, 0x00, 0x70,
  0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x18,
  0x38, 0x01, 0x83, 0x80, 0x38, 0x30, 0x03, 0x07, 0x00, 0x70, 0x60, 0x06,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3E, 0x6F, 0x87, 0x8C, 0xF1, 0xF1, 0x1F, 0x3E, 0x60, 0x07,
  0xCC, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xE0, 0x06, 0x7C, 0x00, 0xC7, 0x8E, 0x10, 0xF3, 0xC6, 0x1E, 0x78,
  0xC7, 0xCF, 0x99, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x1C, 0x3F, 0x80,
  0xE0, 0xE7, 0x07, 0x07, 0x1C, 0x38, 0x1C, 0x70, 0xC0, 0xE1, 0xC7, 0x03,
  0x87, 0x38, 0x0E, 0x39, 0xC0, 0x38, 0xEE, 0x00, 0x7F, 0x70, 0x00, 0xFB,
  0x80, 0x00, 0x1C, 0xF8, 0x00, 0x67, 0xF0, 0x03, 0xB9, 0xC0, 0x1D, 0xC7,
  0x00, 0xE7, 0x1C, 0x07, 0x1C, 0x70, 0x38, 0x71, 0xC1, 0xC1, 0xC7, 0x0E,
  0x07, 0x38, 0x30, 0x1F, 0xC1, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x01, 0xE3, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xE3,
  0xC0, 0x1D, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x07, 0x1F, 0xE0,
  0xE7, 0xDE, 0x3C, 0xF3, 0xC7, 0x3C, 0x3D, 0xE7, 0x87, 0xF8, 0xF0, 0x7E,
  0x1E, 0x07, 0xC3, 0xE1, 0xFC, 0x7F, 0xFF, 0xE7, 0xFE, 0xFC, 0x7F, 0x07,
  0x80, 0x3D, 0xF7, 0x9E, 0x79, 0xE7, 0x1C, 0xF3, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x67, 0x77, 0xFF, 0xFF,
  0xFC, 0x7F, 0x03, 0xF0, 0x3F, 0xC3, 0xCF, 0x1C, 0x70, 0x41, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7B, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF9,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xBC, 0xE7, 0xFE, 0x73,
  0xDF, 0x39, 0xEF, 0xBD, 0xF7, 0x80, 0xFB, 0xC0, 0x79, 0xE0, 0x7C, 0xF0,
  0x3E, 0x7C, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C,
  0x38, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xC0,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x07,
  0xCF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x7F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xE0,
  0x3E, 0xF8, 0x0F, 0x3F, 0x0F, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x03, 0xCF,
  0x80, 0xF1, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x3E,
  0x1F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7B, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x1F, 0x3F, 0x0F,
  0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x70, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0xF8, 0x3D, 0xFF, 0x1F, 0xFF, 0x9F, 0x87, 0xEF,
  0x81, 0xF7, 0xC0, 0xFB, 0xC0, 0x7D, 0xE0, 0x3C, 0xF8, 0x3E, 0x7C, 0x3F,
  0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3E, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1F,
  0x0F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xF8, 0x3E, 0x1F, 0x1F, 0x03,
  0xE7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0xC3, 0xE1,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xBC, 0x07, 0xDF, 0x07, 0xCF, 0x87, 0xE7, 0xFF, 0xF1, 0xFF,
  0xF8, 0x3E, 0x78, 0x00, 0x7C, 0x70, 0x3C, 0x7C, 0x7E, 0x3F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x78, 0xF8, 0xF8, 0xF8,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x00, 0x01, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0,
  0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xFE,
  0x3F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xE0, 0xFB, 0xE0, 0x3D, 0xE0,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFC, 0x01, 0xE1, 0xE0, 0x38, 0x06, 0x07, 0x00, 0x70, 0x60, 0x03,
  0x0C, 0x3D, 0xB1, 0xC7, 0xDB, 0x18, 0xE7, 0xB1, 0x9C, 0x73, 0x33, 0x87,
  0x33, 0x30, 0x73, 0x77, 0x06, 0x36, 0x70, 0xE7, 0x66, 0x0C, 0x66, 0xE0,
  0xC6, 0xEE, 0x1C, 0x6E, 0xE1, 0x8C, 0xCE, 0x38, 0xCC, 0xE3, 0x98, 0xCE,
  0x7B, 0x8E, 0xFD, 0xF0, 0xE7, 0x9E, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0xE0, 0x38, 0x3C, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x07,
  0xBC, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03,
  0xC3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0x03,
  0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x0F, 0xBE, 0x07, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xF1,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0x07, 0xC0, 0x7C, 0xFC, 0x0F, 0x8F,
  0xC7, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0xFE,
  0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xE0, 0x7C, 0x3C, 0x0F, 0x8F, 0x87, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x30, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC7, 0xFD, 0xE1, 0xFF, 0xF8, 0x7F, 0xBE, 0x3F, 0xEF, 0x80,
  0x7B, 0xE0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8,
  0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3C, 0x7E, 0x01, 0xF3, 0xF0,
  0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3C, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x77, 0x3B, 0xC3, 0xB9, 0xDC, 0x3D, 0xDE, 0xE1,
  0xEE, 0xEF, 0x0F, 0x77, 0x78, 0x73, 0xF3, 0xC3, 0x9F, 0x9C, 0x1C, 0xF8,
  0xE1, 0xE3, 0xCF, 0x0F, 0x1C, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1C, 0x1C,
  0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x07, 0xC0,
  0xF0, 0xFC, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x1F, 0x0F, 0xE1, 0xE0, 0xFE,
  0x1E, 0x1E, 0xE1, 0xE1, 0xEF, 0x1E, 0x1E, 0xF3, 0xE1, 0xEF, 0x3C, 0x1E,
  0xF3, 0xC3, 0xEF, 0x3C, 0x3C, 0x73, 0xC3, 0xC7, 0xBC, 0x3C, 0x7F, 0x83,
  0xC7, 0xF8, 0x3C, 0x7F, 0x87, 0xC3, 0xF8, 0x78, 0x3F, 0x87, 0x83, 0xF0,
  0x78, 0x3F, 0x07, 0x83, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x1F, 0x8F, 0xCF, 0xC1, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C,
  0x03, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x3F, 0x0F, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xF0, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F,
  0x8F, 0xCF, 0xC1, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xDF, 0x01,
  0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x1F, 0x3F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xFC, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xF1, 0xF0,
  0x1F, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC3,
  0x80, 0x3C, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x1E,
  0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E,
  0x3C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x7E, 0x70, 0xF7, 0xEF, 0x0F, 0xEE,
  0xF0, 0xFE, 0xEE, 0x0F, 0xEE, 0xE0, 0xFC, 0xFE, 0x0F, 0xC7, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF0,
  0x00, 0xF3, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xC7, 0xC0,
  0x0F, 0x87, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC1, 0xF0, 0x78, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x1E, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x39, 0xE0, 0x3C, 0x70, 0x1C,
  0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0E, 0x03, 0x8F, 0x01, 0xEF, 0x00, 0xF7,
  0x00, 0x7F, 0x80, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x1E,
  0x0F, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x1F, 0x07,
  0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE3, 0xF9, 0xFF, 0xFF, 0x7F,
  0x9F, 0x9F, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF3, 0xE0, 0x7B, 0xFC, 0x1F, 0xFF,
  0x8F, 0xE3, 0xE3, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0,
  0x7C, 0xFE, 0x3E, 0x3F, 0xFF, 0x0F, 0x3F, 0x83, 0xC7, 0xC0, 0x00, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xF0, 0x3D, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07,
  0x81, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0xF8, 0xF0, 0x7F, 0xBE, 0x1F, 0xFF, 0xC3, 0xE3,
  0xF8, 0xF8, 0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03,
  0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F,
  0x87, 0xC7, 0xE0, 0xFF, 0xBC, 0x1F, 0xE7, 0x80, 0xF9, 0xF0, 0x00, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0,
  0x1E, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x79, 0xF0, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0xFF, 0x78,
  0x3F, 0xEF, 0x0F, 0xC7, 0xE1, 0xE0, 0xFC, 0x7C, 0x0F, 0x8F, 0x01, 0xE3,
  0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xDE, 0x03,
  0xE3, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x0F, 0x03, 0xC1, 0xF1, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF1, 0xF0, 0x79,
  0xFE, 0x1E, 0xFF, 0x8F, 0xE3, 0xE3, 0xF0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07,
  0x8F, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xC7,
  0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE3, 0xC0,
  0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF0, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x83,
  0xC3, 0xC0, 0x78, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0xF1, 0xE1, 0xDF, 0x3E, 0x3F, 0xF7, 0xE3, 0xE7, 0xDF,
  0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x71, 0xE3, 0x8F, 0x1E, 0x78, 0xF1,
  0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xC7, 0x0E, 0x3C, 0x71, 0xE3, 0xCF, 0x1E,
  0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x38, 0xF1, 0xC3, 0x8E, 0x3C, 0x78, 0x1E,
  0x1F, 0x07, 0x9F, 0xE1, 0xEF, 0xF8, 0xFE, 0x3E, 0x3F, 0x07, 0xCF, 0x81,
  0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9,
  0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF0,
  0x1E, 0x3C, 0x07, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C,
  0x3E, 0x3E, 0x07, 0x8F, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x07,
  0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x07, 0xC7,
  0xC3, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0x8F, 0x80,
  0x79, 0xFC, 0x07, 0xBF, 0xE0, 0xFE, 0x3E, 0x0F, 0xC1, 0xE0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x8F, 0x83, 0xFF,
  0xF0, 0x3C, 0xFE, 0x03, 0xC7, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE3, 0xC1, 0xFD, 0xF1, 0xFF, 0xFC, 0x7C, 0x7E, 0x3E, 0x0F, 0x8F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xCF, 0x80,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0xC7, 0xE1, 0xFF, 0x78,
  0x7F, 0xBE, 0x07, 0xCF, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x1F, 0x8F,
  0x3F, 0xC7, 0xBF, 0xE3, 0xDF, 0xF1, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xE0, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x78, 0xFF, 0xFC, 0x7F, 0xF8,
  0x0F, 0xF0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x03,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x00, 0x1E, 0x07, 0xC7, 0x81,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0x78,
  0x1F, 0x3E, 0x0F, 0x87, 0xC7, 0xE1, 0xFF, 0x78, 0x7F, 0x9E, 0x0F, 0x8F,
  0x80, 0xF8, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0xC0,
  0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F,
  0x80, 0xF1, 0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0xF7, 0x00,
  0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0xE1, 0xE7, 0x0E, 0x1C, 0x71,
  0xF1, 0xC7, 0x1F, 0x3C, 0x73, 0xF3, 0x87, 0x37, 0x38, 0x77, 0x77, 0x87,
  0x67, 0x70, 0x7E, 0x77, 0x07, 0xC7, 0xF0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0x0F, 0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xF0,
  0xF8, 0x07, 0x8F, 0x80, 0x3E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x7C,
  0x07, 0xC3, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x3C, 0x03, 0xE0, 0xF0,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x3C,
  0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xF8,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE8, 0x0F, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 22, 20, 6, -22 },
  { 26, 13, 10, 20, 6, -24 },
  { 43, 20, 22, 20, 0, -22 },
  { 98, 19, 27, 20, 1, -24 },
  { 163, 22, 22, 20, -1, -22 },
  { 224, 19, 22, 20, 0, -22 },
  { 277, 6, 10, 20, 9, -24 },
  { 285, 13, 31, 20, 5, -24 },
  { 336, 13, 31, 20, 2, -24 },
  { 387, 13, 12, 20, 5, -24 },
  { 407, 16, 18, 20, 2, -20 },
  { 443, 10, 11, 20, 1, -5 },
  { 457, 10, 4, 20, 5, -11 },
  { 462, 5, 5, 20, 6, -5 },
  { 466, 21, 24, 20, 0, -24 },
  { 529, 17, 22, 20, 2, -22 },
  { 576, 16, 22, 20, 1, -22 },
  { 620, 19, 22, 20, 0, -22 },
  { 673, 18, 22, 20, 1, -22 },
  { 723, 19, 22, 20, 0, -22 },
  { 776, 18, 22, 20, 1, -22 },
  { 826, 17, 22, 20, 2, -22 },
  { 873, 16, 22, 20, 4, -22 },
  { 917, 18, 22, 20, 1, -22 },
  { 967, 17, 22, 20, 2, -22 },
  { 1014, 8, 18, 20, 6, -18 },
  { 1032, 12, 24, 20, 2, -18 },
  { 1068, 16, 17, 20, 2, -19 },
  { 1102, 16, 13, 20, 2, -17 },
  { 1128, 16, 17, 20, 2, -19 },
  { 1162, 17, 22, 20, 2, -22 },
  { 1209, 20, 29, 20, 0, -24 },
  { 1282, 20, 22, 20, -2, -22 },
  { 1337, 18, 22, 20, 1, -22 },
  { 1387, 19, 22, 20, 1, -22 },
  { 1440, 19, 22, 20, 0, -22 },
  { 1493, 19, 22, 20, 1, -22 },
  { 1546, 19, 22, 20, 1, -22 },
  { 1599, 18, 22, 20, 1, -22 },
  { 1649, 19, 22, 20, 1, -22 },
  { 1702, 19, 22, 20, 1, -22 },
  { 1755, 18, 22, 20, 1, -22 },
  { 1805, 22, 22, 20, 0, -22 },
  { 1866, 15, 22, 20, 2, -22 },
  { 1908, 21, 22, 20, 0, -22 },
  { 1966, 20, 22, 20, 0, -22 },
  { 2021, 18, 22, 20, 1, -22 },
  { 2071, 20, 22, 20, 0, -22 },
  { 2126, 18, 28, 20, 1, -22 },
  { 2189, 19, 22, 20, 1, -22 },
  { 2242, 20, 22, 20, 0, -22 },
  { 2297, 18, 22, 20, 3, -22 },
  { 2347, 18, 22, 20, 2, -22 },
  { 2397, 19, 22, 20, 3, -22 },
  { 2450, 20, 22, 20, 2, -22 },
  { 2505, 24, 22, 20, -2, -22 },
  { 2571, 19, 22, 20, 3, -22 },
  { 2624, 20, 22, 20, 0, -22 },
  { 2679, 16, 31, 20, 3, -24 },
  { 2741, 13, 24, 20, 4, -24 },
  { 2780, 16, 31, 20, 1, -24 },
  { 2842, 17, 14, 20, 1, -23 },
  { 2872, 20, 2, 20, -2, 2 },
  { 2877, 8, 4, 20, 8, -23 },
  { 2881, 17, 18, 20, 1, -18 },
  { 2920, 18, 24, 20, 1, -24 },
  { 2974, 17, 18, 20, 1, -18 },
  { 3013, 19, 24, 20, 1, -24 },
  { 3070, 17, 18, 20, 1, -18 },
  { 3109, 18, 24, 20, 3, -24 },
  { 3163, 19, 25, 20, 1, -18 },
  { 3223, 18, 24, 20, 1, -24 },
  { 3277, 17, 24, 20, 0, -24 },
  { 3328, 18, 31, 20, -1, -24 },
  { 3398, 19, 24, 20, 1, -24 },
  { 3455, 17, 24, 20, 0, -24 },
  { 3506, 20, 18, 20, 0, -18 },
  { 3551, 18, 18, 20, 1, -18 },
  { 3592, 18, 18, 20, 1, -18 },
  { 3633, 20, 25, 20, -1, -18 },
  { 3696, 18, 25, 20, 1, -18 },
  { 3753, 17, 18, 20, 2, -18 },
  { 3792, 17, 18, 20, 1, -18 },
  { 3831, 14, 23, 20, 4, -23 },
  { 3872, 18, 18, 20, 1, -18 },
  { 3913, 19, 18, 20, 2, -18 },
  { 3956, 20, 18, 20, 1, -18 },
  { 4001, 21, 18, 20, -1, -18 },
  { 4049, 22, 25, 20, -1, -18 },
  { 4118, 17, 18, 20, 1, -18 },
  { 4157, 17, 31, 20, 3, -24 },
  { 4223, 4, 31, 20, 8, -24 },
  { 4239, 17, 31, 20, 0, -24 },
  { 4305, 17, 5, 20, 2, -14 },
};

const GFXfont LiberationMono_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic33pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _LIBERATIONMONO_BOLDITALIC33PT7B_H_
