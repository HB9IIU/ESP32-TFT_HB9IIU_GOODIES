#ifndef _LIBERATIONMONO_BOLDITALIC59PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF1, 0xDF, 0xF8, 0x0F, 0xF0, 0xF1, 0xFF, 0x03, 0xF8, 0x38, 0x3F, 0xC1,
  0xFE, 0x0E, 0x0F, 0xF0, 0x7F, 0x83, 0x83, 0xE0, 0x1F, 0xC0, 0xE0, 0x00,
  0x07, 0xF8, 0x78, 0x00, 0x01, 0xFE, 0x1C, 0x00, 0x00, 0x7F, 0xE7, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0x7F, 0xF8, 0x00, 0x01, 0xC3, 0xFF, 0x00, 0x00, 0x70, 0x7F, 0xC0,
  0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x07, 0x03, 0xFC, 0x3F, 0x03, 0xC0, 0xFE,
  0x3F, 0xC0, 0xE0, 0x3F, 0x8F, 0xF0, 0x38, 0x1F, 0xE3, 0xFE, 0x0E, 0x07,
  0xF0, 0x7F, 0x83, 0x87, 0xFC, 0x1F, 0xF9, 0xE7, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x01, 0xF0,
  0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xE3, 0xE0, 0x00, 0x0F, 0xFF, 0xCF, 0xC0, 0x00, 0x1F, 0xFF, 0x1F, 0x00,
  0x00, 0x1F, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x7F,
  0xF0, 0x00, 0x01, 0xF1, 0xFF, 0xF0, 0x00, 0x07, 0xE7, 0xFF, 0xE0, 0x00,
  0x0F, 0x8F, 0x87, 0xC0, 0x00, 0x3E, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x7C,
  0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x01, 0xF1, 0xF8, 0x07, 0xC0, 0x03,
  0xFF, 0xF0, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xE3, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x03, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF,
  0xFC, 0x07, 0xE0, 0xFF, 0x7F, 0x01, 0xF8, 0x7F, 0x8F, 0xE0, 0xFC, 0x3F,
  0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x87, 0xF8, 0x1F, 0xCF, 0xE1,
  0xFC, 0x03, 0xFB, 0xF0, 0x7F, 0x00, 0xFF, 0xF8, 0x1F, 0xC0, 0x1F, 0xFE,
  0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF,
  0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xC1, 0xF8, 0x33, 0xC7,
  0xC3, 0xDF, 0xDF, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x03,
  0xE0, 0x3C, 0x0F, 0x00, 0x20, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0xFF, 0xBF, 0xEF, 0xF3, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x8F, 0xC7, 0xF8, 0xFF, 0x1F, 0x8F, 0xF3,
  0xFC, 0x3F, 0x1F, 0xE7, 0xF8, 0xFE, 0x3F, 0xCF, 0xF1, 0xF8, 0xFF, 0x9F,
  0xE3, 0xF1, 0xFE, 0x3F, 0xC7, 0xE3, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x87,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFD, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0x80,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xCF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x8F, 0xFF, 0x01, 0xFE, 0x7F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xC1, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF1,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x07,
  0xFF, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x40, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFE,
  0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xE1,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x7F, 0x9E, 0xF0, 0x3C,
  0x0F, 0xF9, 0xEF, 0x03, 0xC1, 0xFF, 0xBC, 0xF0, 0x78, 0x3E, 0x1B, 0xCF,
  0x07, 0x87, 0xC1, 0xF8, 0xF0, 0xF0, 0xF8, 0x1F, 0x8F, 0x0F, 0x0F, 0x01,
  0xF8, 0xF1, 0xE1, 0xF0, 0x1F, 0x0F, 0x1E, 0x3E, 0x01, 0xF0, 0xF1, 0xE3,
  0xE0, 0x1E, 0x0E, 0x3C, 0x3C, 0x01, 0xE1, 0xE3, 0xC7, 0xC0, 0x3E, 0x1E,
  0x3C, 0x78, 0x03, 0xC1, 0xE3, 0xC7, 0x80, 0x3C, 0x1C, 0x78, 0xF8, 0x07,
  0x83, 0xC7, 0x8F, 0x00, 0x78, 0x3C, 0x78, 0xF0, 0x0F, 0x83, 0x87, 0x8F,
  0x00, 0xF0, 0x78, 0x79, 0xF0, 0x1F, 0x07, 0x87, 0x9F, 0x01, 0xF0, 0xF0,
  0xF1, 0xF0, 0x3E, 0x0F, 0x0F, 0x1F, 0x07, 0xE1, 0xE0, 0xF1, 0xF0, 0x7E,
  0x3E, 0x0F, 0x1F, 0x1E, 0xE7, 0xC0, 0xF0, 0xFF, 0xCF, 0xF8, 0x0F, 0x0F,
  0xF8, 0xFF, 0x00, 0xF8, 0x7F, 0x0F, 0xE0, 0x07, 0x83, 0xC0, 0x78, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xF8, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x30, 0x0F, 0xF8,
  0x00, 0x1F, 0xC7, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x3F, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFE,
  0x7F, 0xC1, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xFE, 0x7F, 0x81, 0xFF, 0xFE,
  0x7F, 0x81, 0xFF, 0xFE, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xFC,
  0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8,
  0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE,
  0x0F, 0xBF, 0x01, 0xFF, 0xF0, 0x7D, 0xF8, 0x0F, 0xDF, 0x87, 0xEF, 0xC0,
  0x7E, 0xFC, 0x3E, 0xFE, 0x03, 0xF7, 0xE3, 0xF7, 0xE0, 0x1F, 0x9F, 0x1F,
  0x3F, 0x01, 0xFC, 0xFD, 0xF9, 0xF8, 0x0F, 0xE7, 0xEF, 0xCF, 0xC0, 0x7E,
  0x3E, 0x7C, 0xFE, 0x03, 0xF1, 0xF7, 0xE7, 0xF0, 0x1F, 0x8F, 0xBE, 0x3F,
  0x01, 0xFC, 0x7D, 0xF1, 0xF8, 0x0F, 0xE3, 0xFF, 0x0F, 0xC0, 0x7E, 0x1F,
  0xF8, 0xFE, 0x03, 0xF0, 0xFF, 0x87, 0xF0, 0x1F, 0x87, 0xFC, 0x3F, 0x01,
  0xFC, 0x3F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xF0,
  0xFE, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F,
  0xFC, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFC, 0x07,
  0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x7E,
  0x07, 0xF8, 0x0F, 0xEF, 0xE0, 0xFE, 0x01, 0xFD, 0xFC, 0x1F, 0xC0, 0x7F,
  0xBF, 0x83, 0xF8, 0x0F, 0xE7, 0xF0, 0xFF, 0x01, 0xFC, 0x7E, 0x1F, 0xE0,
  0x3F, 0x8F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x8F,
  0xE0, 0x3F, 0xC7, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x7F, 0x80, 0xFE, 0x0F,
  0xCF, 0xF0, 0x1F, 0xC1, 0xFD, 0xFC, 0x07, 0xF8, 0x3F, 0xBF, 0x80, 0xFF,
  0x07, 0xF7, 0xF0, 0x1F, 0xE0, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xDF, 0xC0,
  0x7F, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFE, 0x03, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0,
  0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0xFF,
  0xC7, 0xF0, 0x1F, 0xC7, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0xF3, 0xF8, 0x07,
  0xF3, 0xFF, 0x9F, 0xC0, 0x3F, 0xBF, 0xFC, 0xFC, 0x01, 0xF9, 0xF7, 0xEF,
  0xE0, 0x0F, 0xDF, 0xBF, 0x7F, 0x00, 0x7E, 0xFD, 0xFB, 0xF0, 0x03, 0xF7,
  0xCF, 0xDF, 0x80, 0x3F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE,
  0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xE1,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0x7F, 0x87,
  0xFF, 0xFC, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xF8, 0x03,
  0xFC, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xC0, 0x7F,
  0xBF, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0xCF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0x9F,
  0xE0, 0x07, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xE3, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x04, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xE3,
  0xFC, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xDF, 0xE0, 0x0F,
  0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xFC, 0x03,
  0xFC, 0x7F, 0xFE, 0x03, 0xFC, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0x07,
  0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x3F, 0xC3,
  0xFE, 0x03, 0xF7, 0xFE, 0x7F, 0xE0, 0x3F, 0x7F, 0xE7, 0xFF, 0x07, 0xEF,
  0xFE, 0xFF, 0xF0, 0x7F, 0xCF, 0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xE1,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x81,
  0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xFC,
  0x03, 0xFC, 0x7F, 0xFE, 0x03, 0xF8, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0xFF,
  0x07, 0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x07, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE,
  0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC3, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0xF0, 0x03, 0xFC, 0xFF,
  0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xE0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC,
  0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xF0, 0x07,
  0xFB, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0xE0, 0x3F,
  0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0x3F, 0xC0, 0x0F, 0xFE, 0x3F, 0xC0, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x8F, 0xFF, 0xC1, 0xFE,
  0x7F, 0xFF, 0x07, 0xFB, 0xFF, 0xF8, 0x1F, 0xEF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x02, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x0C, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFD, 0xFE,
  0x07, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0x87, 0xF0, 0x0F, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC,
  0x07, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x81, 0xF8,
  0x7E, 0x07, 0xF0, 0x3F, 0x0F, 0xC1, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0xE1,
  0xF8, 0x3F, 0x0F, 0xFC, 0x3F, 0x07, 0xE3, 0xFF, 0x8F, 0xC0, 0xFC, 0x7D,
  0xF1, 0xF8, 0x1F, 0x9F, 0xBE, 0x3F, 0x03, 0xF3, 0xE7, 0xCF, 0xC0, 0x7E,
  0xFC, 0xF9, 0xF8, 0x0F, 0xDF, 0x1F, 0x3F, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0x3E, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x05, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBC, 0x07, 0xFF, 0xFF, 0x40,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
};

const GFXglyph LiberationMono_BoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 16, 39, 35, 10, -39 },
  { 79, 24, 18, 35, 10, -43 },
  { 133, 35, 39, 35, 1, -39 },
  { 304, 34, 49, 35, 1, -44 },
  { 513, 39, 41, 35, -1, -40 },
  { 713, 34, 40, 35, -1, -39 },
  { 883, 10, 18, 35, 17, -43 },
  { 906, 23, 55, 35, 9, -43 },
  { 1065, 24, 55, 35, 3, -43 },
  { 1230, 22, 22, 35, 10, -43 },
  { 1291, 30, 30, 35, 3, -35 },
  { 1404, 18, 19, 35, 2, -9 },
  { 1447, 18, 7, 35, 9, -19 },
  { 1463, 10, 9, 35, 11, -9 },
  { 1475, 39, 44, 35, -1, -43 },
  { 1690, 31, 41, 35, 3, -40 },
  { 1849, 30, 39, 35, 1, -39 },
  { 1996, 33, 40, 35, 1, -40 },
  { 2161, 32, 41, 35, 2, -40 },
  { 2325, 32, 39, 35, 1, -39 },
  { 2481, 33, 40, 35, 2, -39 },
  { 2646, 30, 41, 35, 4, -40 },
  { 2800, 29, 39, 35, 7, -39 },
  { 2942, 32, 41, 35, 2, -40 },
  { 3106, 31, 41, 35, 3, -40 },
  { 3265, 14, 31, 35, 11, -31 },
  { 3320, 21, 41, 35, 4, -31 },
  { 3428, 30, 31, 35, 3, -35 },
  { 3545, 30, 22, 35, 3, -31 },
  { 3628, 30, 31, 35, 3, -35 },
  { 3745, 31, 40, 35, 4, -40 },
  { 3900, 36, 51, 35, 0, -43 },
  { 4130, 35, 39, 35, -3, -39 },
  { 4301, 34, 39, 35, 1, -39 },
  { 4467, 33, 41, 35, 2, -40 },
  { 4637, 34, 39, 35, 1, -39 },
  { 4803, 35, 39, 35, 1, -39 },
  { 4974, 34, 39, 35, 2, -39 },
  { 5140, 32, 41, 35, 2, -40 },
  { 5304, 35, 39, 35, 1, -39 },
  { 5475, 34, 39, 35, 1, -39 },
  { 5641, 32, 40, 35, 2, -39 },
  { 5801, 38, 39, 35, 1, -39 },
  { 5987, 28, 39, 35, 3, -39 },
  { 6124, 37, 39, 35, 0, -39 },
  { 6305, 35, 39, 35, 1, -39 },
  { 6476, 33, 41, 35, 2, -40 },
  { 6646, 34, 39, 35, 1, -39 },
  { 6812, 33, 52, 35, 2, -40 },
  { 7027, 35, 39, 35, 1, -39 },
  { 7198, 35, 41, 35, 0, -40 },
  { 7378, 33, 39, 35, 5, -39 },
  { 7539, 33, 40, 35, 3, -39 },
  { 7704, 35, 39, 35, 5, -39 },
  { 7875, 37, 39, 35, 3, -39 },
  { 8056, 42, 39, 35, -3, -39 },
  { 8261, 35, 39, 35, 5, -39 },
  { 8432, 37, 39, 35, -1, -39 },
  { 8613, 28, 55, 35, 5, -43 },
  { 8806, 22, 44, 35, 8, -43 },
  { 8927, 28, 55, 35, 2, -43 },
  { 9120, 32, 26, 35, 1, -41 },
  { 9224, 36, 3, 35, -4, 4 },
  { 9238, 13, 8, 35, 15, -42 },
  { 9251, 31, 33, 35, 1, -32 },
  { 9379, 32, 44, 35, 1, -43 },
  { 9555, 30, 33, 35, 3, -32 },
  { 9679, 34, 44, 35, 2, -43 },
  { 9866, 31, 33, 35, 2, -32 },
  { 9994, 33, 44, 35, 5, -44 },
  { 10176, 34, 44, 35, 1, -32 },
  { 10363, 32, 43, 35, 1, -43 },
  { 10535, 31, 43, 35, 0, -43 },
  { 10702, 32, 55, 35, -2, -43 },
  { 10922, 34, 43, 35, 2, -43 },
  { 11105, 31, 43, 35, 0, -43 },
  { 11272, 36, 32, 35, -1, -32 },
  { 11416, 32, 32, 35, 1, -32 },
  { 11544, 31, 33, 35, 2, -32 },
  { 11672, 34, 44, 35, -1, -32 },
  { 11859, 32, 44, 35, 2, -32 },
  { 12035, 30, 32, 35, 4, -32 },
  { 12155, 31, 33, 35, 2, -32 },
  { 12283, 25, 40, 35, 7, -39 },
  { 12408, 31, 32, 35, 3, -31 },
  { 12532, 33, 31, 35, 4, -31 },
  { 12660, 35, 31, 35, 3, -31 },
  { 12796, 38, 31, 35, -2, -31 },
  { 12944, 38, 43, 35, -1, -31 },
  { 13149, 32, 31, 35, 1, -31 },
  { 13273, 30, 55, 35, 5, -43 },
  { 13480, 7, 56, 35, 14, -43 },
  { 13529, 30, 55, 35, 0, -43 },
  { 13736, 31, 9, 35, 3, -24 },
};

const GFXfont LiberationMono_BoldItalic59pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic59pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic59pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _LIBERATIONMONO_BOLDITALIC59PT7B_H_
