#ifndef _LIBERATIONMONO_BOLDITALIC34PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x0F,
  0x87, 0xC0, 0x7C, 0x7B, 0xC3, 0xDE, 0x3E, 0xF1, 0xE7, 0x8F, 0x78, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x0F, 0x38, 0x78, 0x00, 0x30, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x18, 0x00, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xE0,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xC1,
  0xC0, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x07, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x1C, 0x18, 0x00, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x60, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x30, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x6F, 0xC7, 0x8C, 0xF9, 0xF1,
  0x8F, 0x3E, 0x30, 0x07, 0xCC, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x06, 0x7E, 0x00, 0xC7, 0xDE, 0x18,
  0xFB, 0xC3, 0x1E, 0x7C, 0x43, 0xCF, 0xD9, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xE0, 0x0E, 0x1F, 0xE0, 0x38, 0x39, 0xC0, 0xE0, 0xE3, 0x83, 0x81, 0xC7,
  0x0E, 0x03, 0x0E, 0x38, 0x0E, 0x1C, 0xE0, 0x1C, 0x33, 0x80, 0x3C, 0xEE,
  0x00, 0x3F, 0x98, 0x00, 0x3E, 0x70, 0x00, 0x01, 0xDF, 0x00, 0x07, 0x7F,
  0x00, 0x1D, 0xC7, 0x00, 0x73, 0x8E, 0x01, 0xCE, 0x1C, 0x07, 0x1C, 0x38,
  0x1C, 0x38, 0x60, 0x70, 0x71, 0xC0, 0xC0, 0xE3, 0x83, 0x80, 0xFE, 0x0E,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xF1,
  0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x1C, 0xF8, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x07, 0x9F, 0xF0, 0xF3, 0xDE, 0x1C, 0xF1, 0xE7,
  0xBC, 0x3D, 0xE7, 0x83, 0xF8, 0xF0, 0x7F, 0x1E, 0x07, 0xC3, 0xE1, 0xFC,
  0x7F, 0xFF, 0xF7, 0xFF, 0x7E, 0x3F, 0x07, 0xC0, 0x79, 0xE7, 0x9E, 0xF3,
  0xCF, 0x3C, 0xE3, 0x8E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0xCE, 0x2F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xC3, 0xE0, 0x3F, 0x83, 0xDE, 0x3C, 0xF1, 0xC3, 0x82, 0x10, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D,
  0xF7, 0xBE, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0,
  0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBC, 0xF7, 0xFE, 0x7B, 0xFF,
  0x39, 0xFF, 0x9C, 0xFF, 0xC0, 0x7B, 0xC0, 0x7D, 0xE0, 0x3C, 0xF8, 0x3E,
  0x7C, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xC1, 0xFB, 0xC0, 0xFB, 0xE0,
  0x71, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC3, 0xF0, 0xF8,
  0x1F, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xF1, 0xF8, 0x7E, 0x3E, 0x07, 0xC0, 0x80, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xF3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0xFF,
  0x80, 0x3D, 0xF0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3C, 0x3E,
  0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x1E, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF3, 0xE0, 0x1F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x07, 0xC3, 0xC0, 0xFC, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x40, 0x7C, 0xF8, 0x1F, 0x9F, 0x87, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0x81, 0xE3, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0xFC, 0x1E, 0xFF, 0x87, 0xFF, 0xF3, 0xF8, 0x7C, 0xF8,
  0x1F, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0x1F,
  0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x81, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F,
  0xFF, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x07, 0xDF,
  0x03, 0xEF, 0xC7, 0xF3, 0xFF, 0xF1, 0xFF, 0x78, 0x3E, 0x7C, 0x00, 0x3C,
  0xF0, 0x3E, 0x7C, 0x3E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x01, 0xFE, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03,
  0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFE, 0x00, 0x38, 0x38, 0x03, 0x80, 0xE0, 0x30, 0x03,
  0x03, 0x80, 0x1C, 0x38, 0xF3, 0xE1, 0x8F, 0xF3, 0x1C, 0xE7, 0x98, 0xCE,
  0x3C, 0xCE, 0x61, 0xCE, 0x67, 0x0E, 0x73, 0x30, 0x73, 0x3B, 0x83, 0x19,
  0x98, 0x38, 0xCC, 0xC1, 0xCE, 0x6E, 0x0C, 0x67, 0x70, 0xE3, 0x3B, 0x87,
  0x31, 0xDC, 0x71, 0x8C, 0xE7, 0x98, 0x73, 0xEF, 0x83, 0x9E, 0x38, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x10, 0x1C, 0x01, 0x80, 0x78, 0x38,
  0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF,
  0x80, 0x1E, 0x7C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07,
  0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x01, 0xE7, 0xC0,
  0x0F, 0x3C, 0x00, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E,
  0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x01, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFC, 0x7E, 0x3E, 0x07, 0xCF,
  0x80, 0x79, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xC7, 0xE0, 0x3E, 0x7C,
  0x0F, 0x8F, 0xC3, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0xC3, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E,
  0x07, 0xCF, 0x80, 0xE1, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF1,
  0xFF, 0x3E, 0x3F, 0xE7, 0x87, 0xFD, 0xF0, 0xFF, 0xBE, 0x01, 0xE7, 0xE0,
  0x3C, 0x7C, 0x07, 0x8F, 0xC3, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x02, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x8F, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x81, 0xF8,
  0x3C, 0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xC3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C,
  0xFC, 0x01, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF0, 0x07,
  0xE7, 0xC0, 0x1F, 0x1F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xE3, 0xB8, 0x7F, 0x9F,
  0xC3, 0xBD, 0xDE, 0x1D, 0xEE, 0xF1, 0xEF, 0xF7, 0x8F, 0x7F, 0x38, 0x79,
  0xFB, 0xC3, 0x8F, 0x9E, 0x1C, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x38,
  0x78, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x38, 0x78, 0x03, 0xC0, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0x83, 0xF8, 0x3C,
  0x1F, 0xC1, 0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0xF8, 0x3B, 0xC7, 0xC3, 0xDE,
  0x3C, 0x1E, 0xF1, 0xE0, 0xF7, 0x8F, 0x07, 0xBC, 0xF8, 0x3C, 0xF7, 0xC3,
  0xE7, 0xBC, 0x1E, 0x3D, 0xE0, 0xF1, 0xEF, 0x07, 0x8F, 0x78, 0x3C, 0x3F,
  0xC3, 0xE1, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xF8, 0x3C,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xF8, 0x7E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0x87, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x3F, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7E,
  0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0x87, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x03, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7C, 0x7C, 0x07, 0xC3,
  0xE0, 0x7C, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0x83, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0xE0,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8,
  0x78, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C,
  0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xDF,
  0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xBE, 0x00, 0x3D,
  0xF0, 0x01, 0xEF, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC3, 0x87, 0x9E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x9E, 0x3C, 0xFD, 0xE1, 0xEF, 0xEF, 0x0F,
  0x77, 0x78, 0x7F, 0xBF, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78,
  0x3C, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x7C, 0x01,
  0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xCE, 0x00, 0xE3,
  0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0E, 0x07, 0x07, 0x81, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x78, 0x03, 0x9C, 0x00, 0xFF, 0x00, 0x3C, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xC0, 0xF1, 0xF0, 0xF0, 0xF0, 0xE0, 0x01, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x0F,
  0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x9F, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7,
  0xC1, 0xF3, 0xE3, 0xF9, 0xFF, 0xBF, 0x7F, 0x9F, 0x9F, 0x07, 0xC0, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0xFC, 0x1F, 0x7F, 0x87, 0xBF, 0xF3, 0xF8, 0xFC,
  0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x7C,
  0x07, 0xDF, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x3F, 0x8F,
  0xCF, 0xFF, 0xE3, 0xEF, 0xF0, 0xF1, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x02, 0x0F, 0x01, 0xF7,
  0xC1, 0xF3, 0xF1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x3E, 0x07, 0xFB, 0xC0, 0xFF, 0xBC,
  0x1F, 0x0F, 0xC3, 0xE0, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x07,
  0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x81,
  0xF0, 0xFC, 0x3F, 0x07, 0xC7, 0xF0, 0x7F, 0xFF, 0x03, 0xFD, 0xF0, 0x1F,
  0x1E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x3E,
  0x07, 0xCF, 0x80, 0xF7, 0xC0, 0x3D, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0xC7, 0xE1, 0xF1,
  0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x03,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0xFF, 0x7C,
  0x3F, 0xFF, 0x8F, 0xC7, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x8F, 0xC3, 0xFF, 0x78, 0x3F, 0xDF, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0x03, 0xE1, 0xF0, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x7C, 0x1F, 0x7F, 0x87, 0xBF, 0xF3, 0xFF, 0xFC, 0xFE, 0x1F, 0x3F, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x1E, 0x7C, 0x07, 0x9F, 0x03, 0xE7,
  0xC0, 0xF9, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xE7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0x83, 0xE0, 0x78, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0E, 0x78, 0xF0, 0x77, 0xEF, 0xC7, 0xFF, 0xFE, 0x3E, 0x7C, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0F, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0F,
  0x00, 0x1E, 0x1F, 0x07, 0x9F, 0xE1, 0xEF, 0xFC, 0xFF, 0xFF, 0x3F, 0x87,
  0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0x9F, 0x01, 0xE7,
  0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xCF, 0x80, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7C, 0x3F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x07, 0xC7, 0xC3, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x79, 0xFE, 0x07, 0xBF, 0xE0, 0xFE, 0x3F, 0x0F, 0xC1, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x3F, 0x8F,
  0xC3, 0xFF, 0xF8, 0x3E, 0xFF, 0x03, 0xC7, 0xC0, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE3, 0xE0, 0xFF, 0x78, 0x3F, 0xEF, 0x0F, 0x8F, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x1F,
  0x1F, 0xC3, 0xFF, 0xF8, 0x7F, 0xDE, 0x03, 0xE3, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x1F, 0xC7, 0xCF, 0xE1, 0xF7, 0xF8, 0x7F, 0xFE, 0x1F,
  0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x07, 0xCF, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xBE, 0x03, 0xCF, 0x81, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xF8, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7F,
  0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x3E, 0x07, 0xCF, 0x01, 0xE7, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0xF8, 0xF8, 0x3E, 0x3E, 0x3F,
  0x8F, 0xFF, 0xE3, 0xFE, 0xF8, 0xFF, 0x3C, 0x0F, 0x8F, 0x00, 0xF8, 0x03,
  0xE7, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0,
  0xF0, 0x7C, 0x1F, 0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03, 0xE3, 0xC0, 0x3E,
  0x78, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x03,
  0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x0F, 0x0E, 0x38, 0x78, 0xF1, 0xC7,
  0xC7, 0x8E, 0x3E, 0x38, 0x73, 0xF3, 0xC3, 0x9F, 0x9C, 0x1D, 0xDC, 0xE0,
  0xEE, 0x6F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87,
  0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF8,
  0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7E, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x80, 0xFE, 0x00,
};

const GFXglyph LiberationMono_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 22, 20, 6, -22 },
  { 26, 13, 11, 20, 6, -25 },
  { 44, 21, 22, 20, 0, -22 },
  { 102, 19, 27, 20, 1, -24 },
  { 167, 23, 22, 20, -1, -22 },
  { 231, 19, 22, 20, 0, -22 },
  { 284, 6, 11, 20, 10, -25 },
  { 293, 13, 32, 20, 5, -25 },
  { 345, 13, 32, 20, 2, -25 },
  { 397, 13, 13, 20, 6, -25 },
  { 419, 17, 18, 20, 2, -20 },
  { 458, 11, 11, 20, 1, -5 },
  { 474, 10, 4, 20, 5, -11 },
  { 479, 6, 5, 20, 6, -5 },
  { 483, 22, 25, 20, 0, -25 },
  { 552, 17, 22, 20, 2, -22 },
  { 599, 17, 22, 20, 1, -22 },
  { 646, 20, 22, 20, 0, -22 },
  { 701, 19, 22, 20, 1, -22 },
  { 754, 19, 22, 20, 0, -22 },
  { 807, 19, 22, 20, 1, -22 },
  { 860, 18, 22, 20, 2, -22 },
  { 910, 17, 22, 20, 4, -22 },
  { 957, 19, 22, 20, 1, -22 },
  { 1010, 17, 22, 20, 2, -22 },
  { 1057, 8, 18, 20, 6, -18 },
  { 1075, 13, 24, 20, 2, -18 },
  { 1114, 17, 19, 20, 2, -21 },
  { 1155, 17, 13, 20, 2, -18 },
  { 1183, 17, 19, 20, 2, -21 },
  { 1224, 17, 22, 20, 3, -22 },
  { 1271, 21, 30, 20, 0, -25 },
  { 1350, 21, 22, 20, -2, -22 },
  { 1408, 19, 22, 20, 1, -22 },
  { 1461, 19, 22, 20, 1, -22 },
  { 1514, 20, 22, 20, 0, -22 },
  { 1569, 20, 22, 20, 1, -22 },
  { 1624, 20, 22, 20, 1, -22 },
  { 1679, 19, 22, 20, 1, -22 },
  { 1732, 20, 22, 20, 1, -22 },
  { 1787, 19, 22, 20, 1, -22 },
  { 1840, 19, 22, 20, 1, -22 },
  { 1893, 22, 22, 20, 1, -22 },
  { 1954, 16, 22, 20, 2, -22 },
  { 1998, 21, 22, 20, 0, -22 },
  { 2056, 21, 22, 20, 0, -22 },
  { 2114, 19, 22, 20, 1, -22 },
  { 2167, 19, 22, 20, 1, -22 },
  { 2220, 19, 29, 20, 1, -22 },
  { 2289, 20, 22, 20, 1, -22 },
  { 2344, 20, 22, 20, 0, -22 },
  { 2399, 19, 22, 20, 3, -22 },
  { 2452, 19, 22, 20, 2, -22 },
  { 2505, 20, 22, 20, 3, -22 },
  { 2560, 21, 22, 20, 2, -22 },
  { 2618, 24, 22, 20, -2, -22 },
  { 2684, 20, 22, 20, 3, -22 },
  { 2739, 21, 22, 20, 0, -22 },
  { 2797, 16, 32, 20, 3, -25 },
  { 2861, 12, 25, 20, 5, -25 },
  { 2899, 16, 32, 20, 1, -25 },
  { 2963, 18, 15, 20, 1, -23 },
  { 2997, 21, 2, 20, -3, 2 },
  { 3003, 7, 5, 20, 9, -25 },
  { 3008, 17, 18, 20, 1, -18 },
  { 3047, 18, 25, 20, 1, -25 },
  { 3104, 17, 18, 20, 2, -18 },
  { 3143, 20, 25, 20, 1, -25 },
  { 3206, 18, 18, 20, 1, -18 },
  { 3247, 19, 25, 20, 3, -25 },
  { 3307, 19, 25, 20, 1, -18 },
  { 3367, 18, 25, 20, 1, -25 },
  { 3424, 18, 25, 20, 0, -25 },
  { 3481, 18, 32, 20, -1, -25 },
  { 3553, 20, 25, 20, 1, -25 },
  { 3616, 18, 25, 20, 0, -25 },
  { 3673, 21, 18, 20, -1, -18 },
  { 3721, 18, 18, 20, 1, -18 },
  { 3762, 18, 18, 20, 1, -18 },
  { 3803, 20, 25, 20, -1, -18 },
  { 3866, 19, 25, 20, 1, -18 },
  { 3926, 18, 18, 20, 2, -18 },
  { 3967, 18, 18, 20, 1, -18 },
  { 4008, 14, 23, 20, 4, -23 },
  { 4049, 18, 18, 20, 2, -18 },
  { 4090, 20, 18, 20, 2, -18 },
  { 4135, 21, 18, 20, 1, -18 },
  { 4183, 22, 18, 20, -1, -18 },
  { 4233, 23, 25, 20, -1, -18 },
  { 4305, 18, 18, 20, 1, -18 },
  { 4346, 17, 32, 20, 3, -25 },
  { 4414, 4, 33, 20, 8, -25 },
  { 4431, 17, 32, 20, 0, -25 },
  { 4499, 18, 5, 20, 2, -14 },
};

const GFXfont LiberationMono_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic34pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _LIBERATIONMONO_BOLDITALIC34PT7B_H_
