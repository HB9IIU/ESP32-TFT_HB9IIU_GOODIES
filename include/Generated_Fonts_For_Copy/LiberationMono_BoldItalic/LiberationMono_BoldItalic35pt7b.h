#ifndef _LIBERATIONMONO_BOLDITALIC35PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x80, 0x7C, 0x7D, 0xF1, 0xF7, 0x87, 0x9E,
  0x1E, 0x78, 0x79, 0xE3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x01, 0x81, 0x80, 0x1C, 0x1C, 0x00, 0xC0,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x03, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0x06, 0x06, 0x00, 0x70, 0x70, 0x03, 0x83, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x13, 0xF1, 0xE3, 0x1F, 0x3E,
  0x31, 0x03, 0xE3, 0x00, 0x3F, 0xB0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xC7, 0xC0, 0x0C, 0x3C,
  0xF0, 0xC3, 0xCF, 0x8C, 0x7C, 0xFC, 0x8F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xE0, 0x0E, 0x07, 0xF0, 0x1C, 0x0E, 0x70, 0x3C, 0x1C, 0x38,
  0x38, 0x1C, 0x38, 0x70, 0x1C, 0x70, 0xE0, 0x1C, 0x71, 0xC0, 0x38, 0x73,
  0x80, 0x38, 0x77, 0x00, 0x1C, 0xEE, 0x00, 0x1F, 0xDC, 0x00, 0x0F, 0xB9,
  0xF0, 0x00, 0x3B, 0xF8, 0x00, 0x77, 0x38, 0x00, 0xEE, 0x3C, 0x01, 0xCE,
  0x3C, 0x03, 0x8E, 0x38, 0x07, 0x1C, 0x38, 0x0E, 0x1C, 0x38, 0x1C, 0x1C,
  0x38, 0x38, 0x1E, 0x70, 0x38, 0x0F, 0xE0, 0x70, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0x3F, 0xE1, 0xE7, 0xDF, 0x1E, 0x78, 0xF3, 0xCF,
  0x0F, 0xB8, 0xF0, 0x7F, 0x8F, 0x03, 0xF0, 0xF0, 0x3F, 0x0F, 0x87, 0xF8,
  0xFF, 0xFF, 0xF7, 0xFF, 0x7E, 0x1F, 0x81, 0xE0, 0x7D, 0xF7, 0x9E, 0x79,
  0xEF, 0x3C, 0xF3, 0xCE, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0xCF, 0x37, 0xF7, 0xFF, 0xFD, 0xFF, 0xC3, 0xF0, 0x3F, 0x83,
  0xDE, 0x3E, 0x78, 0xE3, 0x82, 0x10, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0x7F, 0xE0, 0x7D, 0xF7, 0xDE, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x79, 0xF7, 0x9E,
  0x7F, 0xE7, 0x9E, 0xF9, 0xEF, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7F,
  0xC1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7C, 0xF0, 0x38, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF,
  0xF1, 0xF8, 0x7E, 0x3E, 0x07, 0xC3, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x7E,
  0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xBC, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0xC0, 0x3C, 0x7C, 0x07,
  0x87, 0x80, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x0F, 0x87,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xFB, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x87,
  0xE3, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x38, 0x0F,
  0x9F, 0x01, 0xF3, 0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x7C, 0x1F,
  0x7F, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xC7, 0xC3, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x87, 0xC3, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1E, 0x1F, 0x8F, 0xC1, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF,
  0x83, 0xF0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x0F, 0x87, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0x0F, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF,
  0x03, 0xF7, 0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFB, 0xE0, 0xF8,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x3C, 0x0F, 0x8F, 0x87, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0,
  0xF8, 0x78, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x07,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0x00, 0x3C, 0x3C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x83,
  0x80, 0x0C, 0x38, 0x73, 0x61, 0x8F, 0xDB, 0x1C, 0xE3, 0xD8, 0xCE, 0x1C,
  0xCE, 0x60, 0xE6, 0x67, 0x06, 0x33, 0x30, 0x71, 0xBB, 0x83, 0x9D, 0x9C,
  0x18, 0xCC, 0xC1, 0xC6, 0x66, 0x0E, 0x37, 0x70, 0x63, 0x3B, 0x87, 0x19,
  0xDC, 0x79, 0x8E, 0xE6, 0xDC, 0x73, 0xE7, 0xC3, 0x8E, 0x3C, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x10, 0x1C, 0x01, 0xC0, 0x78, 0x3C, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80,
  0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x7C, 0x07, 0xC3,
  0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x10,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x38, 0xFC, 0x07, 0xC7, 0xC0,
  0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xF0, 0xFE, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xDF,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFC, 0x7E, 0x3E,
  0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0xFF, 0xBE, 0x3F, 0xF7, 0xC7, 0xFD, 0xF8, 0xFF, 0xBF, 0x01, 0xF7, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC1, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC,
  0x3E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C,
  0x7E, 0x01, 0xF3, 0xF0, 0x07, 0x9F, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xF7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0xFC,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x77, 0x87, 0xF9, 0xDE, 0x1F, 0xEF, 0x70,
  0x73, 0xBB, 0xC3, 0xCE, 0xEF, 0x0F, 0x3F, 0x3C, 0x3C, 0xFC, 0xF0, 0xF3,
  0xE3, 0x83, 0x8F, 0x9E, 0x1E, 0x3E, 0x78, 0x78, 0xF1, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0xF0, 0xFC, 0x0F, 0x1F, 0xC1, 0xF1, 0xFC,
  0x1F, 0x1F, 0xE1, 0xF1, 0xFE, 0x1E, 0x1F, 0xE1, 0xE1, 0xFE, 0x1E, 0x3F,
  0xE3, 0xE3, 0xDF, 0x3E, 0x3C, 0xF3, 0xC3, 0xCF, 0x3C, 0x3C, 0xF3, 0xC7,
  0xCF, 0x7C, 0x7C, 0xF7, 0xC7, 0x87, 0xF8, 0x78, 0x7F, 0x87, 0x87, 0xF8,
  0xF8, 0x7F, 0x8F, 0x87, 0xF8, 0xF0, 0x3F, 0x0F, 0x03, 0xF0, 0xF0, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0xC7, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0x7E, 0x03, 0xF7,
  0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0x7E, 0x3F,
  0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0x03, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xE1, 0xF0, 0x3E,
  0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x03,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0,
  0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7C,
  0x7E, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x81, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F,
  0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x07, 0xE3, 0xF1, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x03,
  0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80,
  0x0F, 0x9E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x8F, 0x1E,
  0x3E, 0x3C, 0x78, 0xF9, 0xF1, 0xE3, 0xE7, 0xCF, 0x0F, 0x3F, 0x3C, 0x3C,
  0xFC, 0xF0, 0xF7, 0xF7, 0x83, 0xDD, 0xDE, 0x0F, 0xF7, 0x78, 0x3F, 0x9F,
  0xC0, 0xFE, 0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x8F,
  0x80, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF7,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE1,
  0xC0, 0x38, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x0E, 0x1E, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xE1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x0F, 0xCF, 0x87, 0xF3, 0xFF, 0x7F, 0x7F, 0x9F, 0xCF, 0x83, 0xE0,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xF8, 0x1F, 0x7F, 0x83, 0xFF, 0xF8,
  0x7E, 0x1F, 0x1F, 0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7,
  0xC0, 0xF9, 0xFC, 0x7E, 0x3F, 0xFF, 0x87, 0xDF, 0xE0, 0xF1, 0xF0, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xE1, 0xF3, 0xE0, 0xFB, 0xE0,
  0x3D, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x01, 0xEF, 0x81, 0xF7, 0xC1, 0xF3, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E, 0x7C,
  0x07, 0xFB, 0xE0, 0x7F, 0xFF, 0x07, 0xE3, 0xF8, 0x7E, 0x0F, 0x83, 0xE0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x3F,
  0x81, 0xFF, 0xFC, 0x07, 0xFB, 0xE0, 0x1F, 0x1F, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x1F, 0x1F, 0x03, 0xCF, 0x80, 0xF7, 0xC0,
  0x3D, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x03, 0xE7, 0xE1, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0xDE, 0x0F, 0xFD, 0xE1, 0xF8, 0xFE,
  0x1F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xC1,
  0xF8, 0x7E, 0x3F, 0x87, 0xFE, 0xF8, 0x3F, 0xCF, 0x01, 0xF9, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFC,
  0x1F, 0x7F, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC3, 0xF3, 0xF0, 0x3E,
  0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x78, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0,
  0x1E, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1,
  0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x78, 0x78, 0x3B, 0xF7, 0xE0,
  0xFF, 0xDF, 0xC7, 0xCF, 0xDF, 0x1F, 0x3E, 0x3C, 0x78, 0xF1, 0xE1, 0xE3,
  0xC7, 0x87, 0x8F, 0x1E, 0x3C, 0x3C, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x87,
  0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E,
  0x3C, 0x38, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x80, 0x1F, 0x1F, 0x83, 0xEF,
  0xF8, 0x7B, 0xFF, 0x0F, 0x7F, 0xF3, 0xF8, 0x7E, 0x7E, 0x07, 0xCF, 0x80,
  0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03,
  0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x1F, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xC3,
  0xE3, 0xE0, 0x7E, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07,
  0xFF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x1F,
  0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xC7,
  0xC0, 0x3E, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0xFE,
  0x3F, 0x07, 0xFF, 0xF0, 0x3E, 0xFF, 0x01, 0xF3, 0xF0, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF, 0x8F,
  0xC7, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF8,
  0x3F, 0x1F, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xDF, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x0F, 0xC7, 0xCF, 0xF1, 0xF7, 0xFC, 0x7F,
  0xFF, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3E,
  0x08, 0x07, 0xBE, 0x03, 0xEF, 0xC1, 0xF1, 0xFF, 0xFC, 0x3F, 0xFC, 0x03,
  0xFC, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xC0, 0x7D, 0xF0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xF9, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0xFD, 0xE3, 0xFF, 0xF8, 0xFF, 0x3E,
  0x0F, 0x8F, 0x80, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xE1, 0xF0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01,
  0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x0E,
  0x1E, 0x78, 0xF0, 0xF3, 0xCF, 0x8F, 0x1C, 0x7C, 0x78, 0xE7, 0x73, 0x87,
  0x3B, 0xBC, 0x3B, 0x9D, 0xE1, 0xDC, 0xEE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x83, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x00,
  0x1E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x5F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xA0, 0x0F, 0xC0,
};

const GFXglyph LiberationMono_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 10, 23, 21, 6, -23 },
  { 30, 14, 11, 21, 6, -25 },
  { 50, 21, 23, 21, 0, -23 },
  { 111, 20, 28, 21, 1, -25 },
  { 181, 24, 23, 21, -1, -23 },
  { 250, 20, 23, 21, 0, -23 },
  { 308, 6, 11, 21, 10, -25 },
  { 317, 14, 32, 21, 5, -25 },
  { 373, 14, 32, 21, 2, -25 },
  { 429, 13, 13, 21, 6, -25 },
  { 451, 17, 18, 21, 2, -21 },
  { 490, 11, 11, 21, 1, -5 },
  { 506, 11, 4, 21, 5, -11 },
  { 512, 6, 5, 21, 6, -5 },
  { 516, 23, 25, 21, 0, -25 },
  { 588, 18, 23, 21, 2, -23 },
  { 640, 17, 23, 21, 1, -23 },
  { 689, 20, 23, 21, 0, -23 },
  { 747, 19, 23, 21, 1, -23 },
  { 802, 20, 23, 21, 0, -23 },
  { 860, 19, 23, 21, 1, -23 },
  { 915, 18, 23, 21, 2, -23 },
  { 967, 17, 23, 21, 4, -23 },
  { 1016, 19, 23, 21, 1, -23 },
  { 1071, 18, 23, 21, 2, -23 },
  { 1123, 9, 18, 21, 6, -18 },
  { 1144, 12, 24, 21, 3, -18 },
  { 1180, 17, 19, 21, 2, -21 },
  { 1221, 17, 13, 21, 2, -18 },
  { 1249, 17, 19, 21, 2, -21 },
  { 1290, 18, 23, 21, 3, -23 },
  { 1342, 21, 30, 21, 0, -25 },
  { 1421, 21, 23, 21, -2, -23 },
  { 1482, 20, 23, 21, 1, -23 },
  { 1540, 20, 23, 21, 1, -23 },
  { 1598, 19, 23, 21, 1, -23 },
  { 1653, 21, 23, 21, 1, -23 },
  { 1714, 21, 23, 21, 1, -23 },
  { 1775, 19, 23, 21, 1, -23 },
  { 1830, 20, 23, 21, 1, -23 },
  { 1888, 20, 23, 21, 1, -23 },
  { 1946, 19, 23, 21, 1, -23 },
  { 2001, 22, 23, 21, 1, -23 },
  { 2065, 16, 23, 21, 2, -23 },
  { 2111, 22, 23, 21, 0, -23 },
  { 2175, 20, 23, 21, 1, -23 },
  { 2233, 20, 23, 21, 1, -23 },
  { 2291, 20, 23, 21, 1, -23 },
  { 2349, 20, 30, 21, 1, -23 },
  { 2424, 20, 23, 21, 1, -23 },
  { 2482, 21, 23, 21, 0, -23 },
  { 2543, 20, 23, 21, 3, -23 },
  { 2601, 19, 23, 21, 2, -23 },
  { 2656, 21, 23, 21, 3, -23 },
  { 2717, 22, 23, 21, 2, -23 },
  { 2781, 25, 23, 21, -2, -23 },
  { 2853, 21, 23, 21, 3, -23 },
  { 2914, 21, 23, 21, 0, -23 },
  { 2975, 17, 32, 21, 3, -25 },
  { 3043, 13, 25, 21, 5, -25 },
  { 3084, 17, 32, 21, 1, -25 },
  { 3152, 19, 15, 21, 1, -24 },
  { 3188, 22, 2, 21, -3, 2 },
  { 3194, 8, 5, 21, 9, -25 },
  { 3199, 18, 18, 21, 1, -18 },
  { 3240, 19, 25, 21, 1, -25 },
  { 3300, 17, 18, 21, 2, -18 },
  { 3339, 21, 25, 21, 1, -25 },
  { 3405, 18, 18, 21, 1, -18 },
  { 3446, 19, 25, 21, 3, -25 },
  { 3506, 20, 25, 21, 1, -18 },
  { 3569, 19, 25, 21, 1, -25 },
  { 3629, 18, 25, 21, 0, -25 },
  { 3686, 19, 32, 21, -1, -25 },
  { 3762, 20, 25, 21, 1, -25 },
  { 3825, 18, 25, 21, 0, -25 },
  { 3882, 22, 18, 21, -1, -18 },
  { 3932, 19, 18, 21, 1, -18 },
  { 3975, 19, 18, 21, 1, -18 },
  { 4018, 21, 25, 21, -1, -18 },
  { 4084, 19, 25, 21, 1, -18 },
  { 4144, 18, 18, 21, 2, -18 },
  { 4185, 18, 18, 21, 1, -18 },
  { 4226, 15, 23, 21, 4, -23 },
  { 4270, 18, 18, 21, 2, -18 },
  { 4311, 20, 18, 21, 2, -18 },
  { 4356, 21, 18, 21, 2, -18 },
  { 4404, 23, 18, 21, -1, -18 },
  { 4456, 23, 25, 21, -1, -18 },
  { 4528, 18, 18, 21, 1, -18 },
  { 4569, 18, 32, 21, 3, -25 },
  { 4641, 5, 33, 21, 8, -25 },
  { 4662, 18, 32, 21, 0, -25 },
  { 4734, 18, 6, 21, 2, -14 },
};

const GFXfont LiberationMono_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic35pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _LIBERATIONMONO_BOLDITALIC35PT7B_H_
