#ifndef _LIBERATIONMONO_BOLDITALIC43PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xE7, 0xC3,
  0xF7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x3E, 0x3C,
  0x1F, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x81, 0xE0, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x1F, 0xCE, 0xFE, 0x0F, 0xC6, 0x3F, 0x07, 0xC3, 0x0F, 0x87, 0xE1,
  0x87, 0xC3, 0xF1, 0xC0, 0x01, 0xF8, 0xE0, 0x00, 0xFF, 0x60, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0x7F, 0xC0, 0x01, 0x8F, 0xE0, 0x01, 0xC3, 0xF0,
  0xE0, 0xE1, 0xF9, 0xF0, 0x60, 0xF8, 0xFC, 0x30, 0x7C, 0x7E, 0x18, 0x7E,
  0x3F, 0xCC, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x1F, 0xE0, 0x07,
  0x81, 0xFF, 0x80, 0x78, 0x1E, 0x3C, 0x07, 0x80, 0xF0, 0xE0, 0x78, 0x0F,
  0x07, 0x07, 0x80, 0x78, 0x78, 0x78, 0x03, 0xC3, 0xC7, 0x80, 0x1C, 0x1E,
  0x38, 0x00, 0xE1, 0xE3, 0x80, 0x07, 0x8F, 0x38, 0x00, 0x3F, 0xF3, 0xC0,
  0x00, 0xFF, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xFC, 0x00,
  0x03, 0xCF, 0xF0, 0x00, 0x3C, 0xFF, 0xC0, 0x03, 0xCF, 0x1E, 0x00, 0x1C,
  0x70, 0xF0, 0x01, 0xC7, 0x87, 0x80, 0x1C, 0x3C, 0x3C, 0x01, 0xE1, 0xE1,
  0xE0, 0x1E, 0x0E, 0x0F, 0x01, 0xE0, 0x70, 0xF0, 0x1E, 0x03, 0xC7, 0x81,
  0xE0, 0x1F, 0xF8, 0x1E, 0x00, 0x7F, 0x80, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xF8, 0x7C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0x1F, 0xF8, 0x1F, 0x3F, 0xFC, 0x1E, 0x7E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0xF8, 0x3F, 0x7C, 0xF8, 0x1F, 0xF8, 0xF8,
  0x1F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFC, 0x7F, 0x0F, 0xE0, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x03, 0x1E,
  0x33, 0xEF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xF0, 0x07,
  0xFC, 0x07, 0xDF, 0x07, 0xCF, 0x87, 0xC3, 0xE0, 0xE1, 0xC0, 0x20, 0x40,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0x7E, 0xFF, 0xF7, 0xEF, 0xDF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F,
  0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xE3, 0xCF, 0xCF, 0xCF, 0x9F, 0x9F,
  0x9F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0x79, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFE, 0xFC, 0x03,
  0xF3, 0xF0, 0x1E, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0C, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x7E, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF0,
  0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0xBF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0x87, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x20, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x1F, 0x3F, 0xF0, 0x7D, 0xFF,
  0xE3, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0,
  0x3F, 0x8F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xE1, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x87,
  0xF1, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF8,
  0x7F, 0xCF, 0xFF, 0xFE, 0x1F, 0xFE, 0xF8, 0x3F, 0xF7, 0xE0, 0x3F, 0x1F,
  0x00, 0x00, 0xFC, 0x0C, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0xFF, 0x07, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x03, 0x8F, 0xC1, 0xC3,
  0xF7, 0x70, 0xE1, 0xFD, 0xDC, 0x38, 0xF1, 0xE7, 0x1C, 0x78, 0x79, 0xC7,
  0x3C, 0x1E, 0x73, 0x8E, 0x07, 0x1C, 0xE7, 0x81, 0xC7, 0x39, 0xC0, 0xF1,
  0xDC, 0x70, 0x38, 0x67, 0x38, 0x0E, 0x39, 0xCE, 0x07, 0x0E, 0x73, 0x81,
  0xC3, 0x19, 0xE0, 0xF1, 0xCE, 0x78, 0x38, 0x73, 0x9C, 0x1E, 0x38, 0xE7,
  0x8F, 0x8E, 0x39, 0xE7, 0xE7, 0x0E, 0x3F, 0xBF, 0x83, 0x8F, 0xCF, 0xC0,
  0xE1, 0xE1, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x01,
  0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x81, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0x7F, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x00, 0x3C, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0xFC, 0x00,
  0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xC1, 0xFF, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x0F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x9F,
  0xC0, 0x3F, 0x3F, 0x00, 0x70, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE1, 0xFF, 0xDF, 0xC3, 0xFF, 0xBF, 0x07, 0xFF, 0x7E, 0x1F,
  0xFE, 0xFC, 0x3F, 0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x0F,
  0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x30, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x8F, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x1F, 0x9F, 0xE0,
  0x01, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7B, 0xC3, 0xBE, 0x0F, 0x78, 0xF7, 0x83,
  0xEF, 0x1E, 0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xBC, 0xF7, 0xC1, 0xF7, 0xBC,
  0xF8, 0x3C, 0xF7, 0x9E, 0x07, 0x9E, 0xE3, 0xC1, 0xF1, 0xFC, 0xF8, 0x3E,
  0x3F, 0x9F, 0x07, 0xC7, 0xE3, 0xE0, 0xF0, 0xFC, 0x78, 0x1E, 0x1F, 0x0F,
  0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xC1, 0xFE,
  0x07, 0xE1, 0xFF, 0x03, 0xF0, 0xFF, 0x81, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F,
  0xE0, 0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0x7C, 0x3F, 0x0F, 0xBE, 0x1F, 0x07,
  0xDF, 0x0F, 0x83, 0xEF, 0x87, 0xC1, 0xF3, 0xE7, 0xE1, 0xF9, 0xF3, 0xF0,
  0xFC, 0xF9, 0xF0, 0x7E, 0x7C, 0xF8, 0x3E, 0x3E, 0x7C, 0x1F, 0x0F, 0x3E,
  0x1F, 0x87, 0xFF, 0x0F, 0xC3, 0xFF, 0x07, 0xE1, 0xFF, 0x83, 0xE0, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE1, 0xF8, 0x1F, 0xF0, 0xFC, 0x0F, 0xF0, 0x7E, 0x07,
  0xF8, 0x3E, 0x03, 0xFC, 0x1F, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xFC,
  0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F,
  0xC3, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xFC,
  0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3,
  0xFC, 0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7E, 0x03, 0xFC,
  0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x70,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x8F, 0xF8, 0x1F, 0xE1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x03,
  0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0,
  0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8,
  0x3E, 0x3F, 0x1F, 0x07, 0xCF, 0xE3, 0xE0, 0xF9, 0xFC, 0xF8, 0x1F, 0x7F,
  0x9F, 0x03, 0xEF, 0xF3, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0x7B, 0xFF, 0x01,
  0xEF, 0x7F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7F,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xDF, 0x80,
  0x0F, 0xE7, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xF3, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00,
  0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0x78, 0x03,
  0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8,
  0x07, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8,
  0x3F, 0x07, 0xE1, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x8F,
  0xE1, 0xFF, 0x3F, 0xFE, 0xFF, 0x7F, 0xF3, 0xFD, 0xFF, 0x8F, 0xF1, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0x9F, 0xF0, 0x3F, 0x7F, 0xF0, 0x7F, 0xFF,
  0xF0, 0xFF, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F,
  0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x1F, 0xC3, 0xEF, 0xFF, 0x0F, 0xDF,
  0xFC, 0x1F, 0x9F, 0xF0, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xC1, 0xF8, 0x7E, 0x07,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF8, 0x1F, 0x87, 0xF0, 0xFE,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x7E, 0x01, 0xFF, 0x3F, 0x03, 0xFF, 0xDF, 0x83, 0xFF,
  0xFF, 0x81, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF8, 0x3F, 0x87, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x7E, 0x01, 0xFF, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x1F, 0xC1, 0xF8, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0x7E,
  0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0x83,
  0xF8, 0x0F, 0xCF, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0xFF, 0x8F, 0x80, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0x1F, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F,
  0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xDF, 0x80, 0xFF, 0xCF, 0x80, 0x1F, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0x9F, 0xF8, 0x3F, 0x7F, 0xF0, 0x7D,
  0xFF, 0xF1, 0xFF, 0x0F, 0xE3, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x02, 0x07, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFE, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0xC1, 0xF0, 0x07, 0xE0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x07, 0x8F, 0x07, 0x83, 0xEF, 0xE7, 0xF0,
  0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xCF, 0xE7, 0xC3, 0xE3, 0xF1,
  0xF0, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F,
  0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3C, 0x1E, 0x1F,
  0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E,
  0x1F, 0x1E, 0x0F, 0x07, 0x8F, 0x87, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F,
  0x9F, 0xF8, 0x3E, 0x7F, 0xF0, 0x7D, 0xFF, 0xF1, 0xFF, 0x0F, 0xE3, 0xFC,
  0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC,
  0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x01, 0xF9,
  0xFF, 0x00, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC3, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x03, 0xEF, 0xFF, 0x03, 0xF7, 0xFF,
  0x01, 0xF9, 0xFF, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x7E, 0x07, 0xFC, 0xFC, 0x1F, 0xFD, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC,
  0x3F, 0xC7, 0xF0, 0x7F, 0x8F, 0xC0, 0x7F, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1,
  0xF8, 0x1F, 0xE3, 0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0x7E, 0x07,
  0xFC, 0xFC, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xFC, 0x7E, 0x3F,
  0xF1, 0xF9, 0xFF, 0xC7, 0xEF, 0xFE, 0x1F, 0xBF, 0xF8, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC,
  0x0F, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x18, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0xF9,
  0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07,
  0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xFF, 0xBF, 0x07, 0xFE, 0x7E,
  0x0F, 0xF8, 0xFC, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x83, 0xC1, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x3F, 0x0F,
  0x0F, 0x8F, 0xE7, 0xC3, 0xE7, 0xF9, 0xF0, 0xF9, 0xDE, 0x78, 0x3C, 0xF7,
  0xBE, 0x0F, 0x39, 0xEF, 0x03, 0xDE, 0x7B, 0xC0, 0xF7, 0x0E, 0xF0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x0D, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xD8, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00,
};

const GFXglyph LiberationMono_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 28, 26, 8, -28 },
  { 40, 17, 13, 26, 7, -31 },
  { 68, 26, 28, 26, 0, -28 },
  { 159, 25, 35, 26, 1, -31 },
  { 269, 29, 28, 26, -1, -28 },
  { 371, 24, 28, 26, 0, -28 },
  { 455, 8, 13, 26, 12, -31 },
  { 468, 17, 40, 26, 6, -31 },
  { 553, 17, 40, 26, 2, -31 },
  { 638, 17, 16, 26, 7, -31 },
  { 672, 22, 23, 26, 2, -26 },
  { 736, 13, 14, 26, 2, -6 },
  { 759, 13, 5, 26, 6, -14 },
  { 768, 7, 6, 26, 8, -6 },
  { 774, 28, 31, 26, 0, -31 },
  { 883, 23, 28, 26, 2, -28 },
  { 964, 22, 28, 26, 1, -28 },
  { 1041, 25, 28, 26, 0, -28 },
  { 1129, 24, 28, 26, 1, -28 },
  { 1213, 24, 28, 26, 0, -28 },
  { 1297, 24, 28, 26, 1, -28 },
  { 1381, 22, 28, 26, 3, -28 },
  { 1458, 21, 28, 26, 5, -28 },
  { 1532, 24, 28, 26, 1, -28 },
  { 1616, 22, 28, 26, 2, -28 },
  { 1693, 10, 23, 26, 8, -23 },
  { 1722, 15, 31, 26, 3, -23 },
  { 1781, 22, 23, 26, 2, -26 },
  { 1845, 22, 17, 26, 2, -22 },
  { 1892, 22, 23, 26, 2, -26 },
  { 1956, 22, 28, 26, 3, -28 },
  { 2033, 26, 37, 26, 0, -31 },
  { 2154, 26, 28, 26, -2, -28 },
  { 2245, 24, 28, 26, 1, -28 },
  { 2329, 24, 28, 26, 2, -28 },
  { 2413, 24, 28, 26, 1, -28 },
  { 2497, 26, 28, 26, 1, -28 },
  { 2588, 26, 28, 26, 1, -28 },
  { 2679, 23, 28, 26, 2, -28 },
  { 2760, 25, 28, 26, 1, -28 },
  { 2848, 25, 28, 26, 1, -28 },
  { 2936, 23, 28, 26, 2, -28 },
  { 3017, 28, 28, 26, 1, -28 },
  { 3115, 20, 28, 26, 2, -28 },
  { 3185, 27, 28, 26, 0, -28 },
  { 3280, 25, 28, 26, 1, -28 },
  { 3368, 23, 28, 26, 2, -28 },
  { 3449, 25, 28, 26, 1, -28 },
  { 3537, 23, 36, 26, 2, -28 },
  { 3641, 25, 28, 26, 1, -28 },
  { 3729, 26, 28, 26, 0, -28 },
  { 3820, 24, 28, 26, 4, -28 },
  { 3904, 24, 28, 26, 2, -28 },
  { 3988, 26, 28, 26, 3, -28 },
  { 4079, 27, 28, 26, 2, -28 },
  { 4174, 30, 28, 26, -2, -28 },
  { 4279, 26, 28, 26, 3, -28 },
  { 4370, 26, 28, 26, 0, -28 },
  { 4461, 20, 40, 26, 4, -31 },
  { 4561, 16, 31, 26, 6, -31 },
  { 4623, 21, 40, 26, 1, -31 },
  { 4728, 23, 19, 26, 1, -30 },
  { 4783, 26, 2, 26, -3, 3 },
  { 4790, 10, 6, 26, 11, -31 },
  { 4798, 22, 23, 26, 1, -23 },
  { 4862, 23, 31, 26, 1, -31 },
  { 4952, 22, 23, 26, 2, -23 },
  { 5016, 25, 31, 26, 2, -31 },
  { 5113, 22, 23, 26, 2, -23 },
  { 5177, 23, 31, 26, 4, -31 },
  { 5267, 25, 32, 26, 1, -23 },
  { 5367, 23, 31, 26, 1, -31 },
  { 5457, 23, 31, 26, 0, -31 },
  { 5547, 23, 40, 26, -1, -31 },
  { 5662, 25, 31, 26, 1, -31 },
  { 5759, 23, 31, 26, 0, -31 },
  { 5849, 26, 23, 26, -1, -23 },
  { 5924, 23, 23, 26, 1, -23 },
  { 5991, 22, 23, 26, 2, -23 },
  { 6055, 25, 32, 26, -1, -23 },
  { 6155, 23, 32, 26, 2, -23 },
  { 6247, 22, 23, 26, 3, -23 },
  { 6311, 23, 23, 26, 1, -23 },
  { 6378, 18, 29, 26, 5, -29 },
  { 6444, 23, 23, 26, 2, -23 },
  { 6511, 24, 23, 26, 3, -23 },
  { 6580, 26, 23, 26, 2, -23 },
  { 6655, 28, 23, 26, -1, -23 },
  { 6736, 28, 32, 26, -1, -23 },
  { 6848, 23, 23, 26, 1, -23 },
  { 6915, 22, 40, 26, 4, -31 },
  { 7025, 6, 41, 26, 10, -31 },
  { 7056, 22, 40, 26, 0, -31 },
  { 7166, 23, 7, 26, 2, -18 },
};

const GFXfont LiberationMono_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic43pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _LIBERATIONMONO_BOLDITALIC43PT7B_H_
