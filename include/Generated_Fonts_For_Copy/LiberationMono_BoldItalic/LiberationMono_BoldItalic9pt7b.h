#ifndef _LIBERATIONMONO_BOLDITALIC9PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x5E, 0x88, 0xB6, 0x80, 0x28, 0xA7, 0x94, 0xF9, 0x4A, 0x00, 0x11,
  0xD6, 0xC7, 0x96, 0xAE, 0x00, 0x66, 0xAD, 0x08, 0x39, 0x69, 0x80, 0x31,
  0x4C, 0xCA, 0xCB, 0xE0, 0xE0, 0x22, 0x44, 0xCC, 0xCC, 0x40, 0x64, 0x92,
  0xD2, 0x80, 0x27, 0x66, 0x21, 0x3E, 0x42, 0x00, 0x69, 0x00, 0xE0, 0x80,
  0x08, 0x21, 0x08, 0x21, 0x08, 0x00, 0x3A, 0x52, 0xD4, 0xA9, 0xC0, 0x13,
  0x84, 0x63, 0x13, 0xE0, 0x3A, 0x42, 0x22, 0x23, 0xE0, 0x3A, 0x42, 0x60,
  0xED, 0xC0, 0x19, 0x4E, 0xAF, 0x88, 0x40, 0x7A, 0x1C, 0x10, 0xED, 0xC0,
  0x7D, 0x8F, 0x9B, 0xE0, 0xF1, 0x26, 0x4C, 0x80, 0x3A, 0x52, 0x64, 0xED,
  0xC0, 0x3A, 0x52, 0xF1, 0xA9, 0xC0, 0xC0, 0x80, 0x60, 0x05, 0x20, 0x0B,
  0xA0, 0xE0, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0x79, 0x12, 0x40,
  0xC0, 0x39, 0x17, 0xF5, 0xDB, 0xC8, 0x1C, 0x31, 0x8C, 0xB7, 0xC6, 0x20,
  0x7A, 0x52, 0xE4, 0xE7, 0xC0, 0x3A, 0x51, 0x8C, 0x65, 0xC0, 0x7A, 0x52,
  0x94, 0xEB, 0xC0, 0x79, 0x04, 0x1E, 0x43, 0x0F, 0x80, 0x79, 0x04, 0x1E,
  0x41, 0x0C, 0x00, 0x3A, 0x51, 0xBC, 0xE5, 0xC0, 0x6A, 0x52, 0xF5, 0xEF,
  0x40, 0x78, 0x8C, 0x42, 0x13, 0xC0, 0x38, 0x46, 0x31, 0x69, 0x80, 0x4D,
  0x67, 0x1C, 0x53, 0x4D, 0x80, 0x23, 0x18, 0x84, 0x21, 0xE0, 0x6D, 0xA7,
  0x9E, 0xAA, 0x28, 0x80, 0x69, 0xA6, 0x9A, 0x6B, 0x69, 0x00, 0x3A, 0x53,
  0x9C, 0xED, 0xC0, 0x7A, 0x52, 0xE4, 0x63, 0x00, 0x3A, 0x53, 0x9C, 0xED,
  0xC4, 0x30, 0x7A, 0x52, 0xE5, 0x6B, 0x60, 0x3A, 0x50, 0xF0, 0xC5, 0xC0,
  0xFB, 0x18, 0x84, 0x21, 0x00, 0x49, 0x24, 0x92, 0x5B, 0x47, 0x00, 0x8C,
  0xA5, 0x4A, 0x71, 0x00, 0x45, 0x17, 0x9E, 0x59, 0x4D, 0x00, 0x4D, 0xA3,
  0x0C, 0x51, 0x49, 0x80, 0x9C, 0x98, 0xC4, 0x21, 0x00, 0x78, 0x61, 0x08,
  0x61, 0x0F, 0x80, 0x74, 0x44, 0x4C, 0x88, 0xE0, 0x84, 0x44, 0x22, 0x20,
  0x30, 0x84, 0x21, 0x18, 0x84, 0xE0, 0x31, 0x93, 0x10, 0xFC, 0xD0, 0x78,
  0xDD, 0xAF, 0x80, 0x62, 0x1E, 0x94, 0xEE, 0xC0, 0x3A, 0x71, 0xB7, 0x00,
  0x08, 0x27, 0x92, 0xCB, 0x67, 0x00, 0x3A, 0x7F, 0x87, 0x00, 0x3A, 0x3C,
  0x84, 0x63, 0x00, 0x3A, 0x53, 0xB7, 0x8B, 0xC0, 0x62, 0x1E, 0x94, 0xEF,
  0x40, 0x10, 0x1C, 0x62, 0x13, 0xE0, 0x18, 0x1C, 0x21, 0x18, 0x84, 0xE0,
  0x63, 0x12, 0xA7, 0x2B, 0x40, 0x30, 0x84, 0x62, 0x13, 0xE0, 0x6B, 0xEB,
  0x5A, 0x80, 0x7A, 0x53, 0xBD, 0x00, 0x3A, 0x73, 0xB7, 0x00, 0x7A, 0x53,
  0xBB, 0x42, 0x00, 0x7A, 0x73, 0xB7, 0x08, 0x40, 0xFC, 0x88, 0x80, 0x7A,
  0x1C, 0x17, 0x00, 0x4F, 0x4C, 0x8E, 0x4A, 0x57, 0xB7, 0x00, 0x94, 0xA9,
  0x4C, 0x00, 0x86, 0xAB, 0xB6, 0xD0, 0x48, 0xC2, 0x14, 0x90, 0x49, 0x25,
  0x14, 0x21, 0x8C, 0x00, 0x78, 0x88, 0x8F, 0x00, 0x36, 0x44, 0x84, 0xC8,
  0xE0, 0xFF, 0x80, 0x30, 0x84, 0x21, 0x90, 0x84, 0xE0, 0x64, 0xC0,
};

const GFXglyph LiberationMono_BoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 6, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 7, 5, 0, -7 },
  { 23, 5, 7, 5, 0, -7 },
  { 28, 1, 3, 5, 3, -7 },
  { 29, 4, 9, 5, 1, -7 },
  { 34, 3, 9, 5, 1, -7 },
  { 38, 4, 4, 5, 1, -7 },
  { 40, 5, 5, 5, 0, -6 },
  { 44, 3, 3, 5, 0, -1 },
  { 46, 3, 1, 5, 1, -3 },
  { 47, 1, 1, 5, 2, -1 },
  { 48, 6, 7, 5, 0, -7 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 7, 5, 0, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 4, 7, 5, 1, -7 },
  { 88, 4, 7, 5, 1, -7 },
  { 92, 5, 7, 5, 0, -7 },
  { 97, 5, 7, 5, 0, -7 },
  { 102, 2, 5, 5, 2, -5 },
  { 104, 3, 7, 5, 1, -5 },
  { 107, 5, 5, 5, 0, -6 },
  { 111, 5, 3, 5, 0, -5 },
  { 113, 5, 5, 5, 0, -6 },
  { 117, 4, 7, 5, 1, -7 },
  { 121, 6, 8, 5, 0, -7 },
  { 127, 5, 7, 5, 0, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 6, 7, 5, 0, -7 },
  { 153, 6, 7, 5, 0, -7 },
  { 159, 5, 7, 5, 0, -7 },
  { 164, 5, 7, 5, 0, -7 },
  { 169, 5, 7, 5, 0, -7 },
  { 174, 5, 7, 5, 0, -7 },
  { 179, 6, 7, 5, 0, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 6, 7, 5, 0, -7 },
  { 196, 6, 7, 5, 0, -7 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 5, 7, 5, 0, -7 },
  { 212, 5, 9, 5, 0, -7 },
  { 218, 5, 7, 5, 0, -7 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 5, 7, 5, 1, -7 },
  { 233, 6, 7, 5, 0, -7 },
  { 239, 5, 7, 5, 1, -7 },
  { 244, 6, 7, 5, 0, -7 },
  { 250, 6, 7, 5, 0, -7 },
  { 256, 5, 7, 5, 1, -7 },
  { 261, 6, 7, 5, 0, -7 },
  { 267, 4, 9, 5, 1, -7 },
  { 272, 4, 7, 5, 1, -7 },
  { 276, 5, 9, 5, 0, -7 },
  { 282, 5, 4, 5, 0, -7 },
  { 285, 6, 1, 5, -1, 1 },
  { 286, 2, 2, 5, 2, -7 },
  { 287, 5, 5, 5, 0, -5 },
  { 291, 5, 7, 5, 0, -7 },
  { 296, 5, 5, 5, 0, -5 },
  { 300, 6, 7, 5, 0, -7 },
  { 306, 5, 5, 5, 0, -5 },
  { 310, 5, 7, 5, 1, -7 },
  { 315, 5, 7, 5, 0, -5 },
  { 320, 5, 7, 5, 0, -7 },
  { 325, 5, 7, 5, 0, -7 },
  { 330, 5, 9, 5, 0, -7 },
  { 336, 5, 7, 5, 0, -7 },
  { 341, 5, 7, 5, 0, -7 },
  { 346, 5, 5, 5, 0, -5 },
  { 350, 5, 5, 5, 0, -5 },
  { 354, 5, 5, 5, 0, -5 },
  { 358, 5, 7, 5, 0, -5 },
  { 363, 5, 7, 5, 0, -5 },
  { 368, 4, 5, 5, 1, -5 },
  { 371, 5, 5, 5, 0, -5 },
  { 375, 4, 6, 5, 1, -6 },
  { 378, 5, 5, 5, 0, -5 },
  { 382, 5, 5, 5, 1, -5 },
  { 386, 6, 5, 5, 0, -5 },
  { 390, 6, 5, 5, 0, -5 },
  { 394, 6, 7, 5, 0, -5 },
  { 400, 5, 5, 5, 0, -5 },
  { 404, 4, 9, 5, 1, -7 },
  { 409, 1, 9, 5, 2, -7 },
  { 411, 5, 9, 5, 0, -7 },
  { 417, 5, 2, 5, 0, -4 },
};

const GFXfont LiberationMono_BoldItalic9pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic9pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic9pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _LIBERATIONMONO_BOLDITALIC9PT7B_H_
