#ifndef _LIBERATIONMONO_BOLDITALIC27PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0x80,
  0x00, 0x3C, 0x78, 0xF1, 0xE0, 0x71, 0xFC, 0x7F, 0x3F, 0x8E, 0xE3, 0xB8,
  0xEE, 0x3B, 0x0C, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0,
  0x30, 0xC1, 0xFF, 0xF8, 0xFF, 0xFC, 0x0C, 0x30, 0x06, 0x18, 0x06, 0x18,
  0x03, 0x0C, 0x0F, 0xFF, 0xCF, 0xFF, 0xC1, 0x87, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x61, 0x80, 0x30, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x80, 0x0F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xE7, 0x93, 0xCE, 0x27, 0x9C, 0xC0, 0x3D, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x67, 0x88, 0xCF, 0x71, 0x1E,
  0xF2, 0x79, 0xFF, 0xF1, 0xFF, 0xC1, 0xFC, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x07, 0x80, 0xC3, 0xF8, 0x30, 0x67, 0x0C, 0x1C, 0x63, 0x03, 0x9C, 0xE0,
  0x63, 0xB8, 0x0E, 0x6E, 0x01, 0xFD, 0x80, 0x1E, 0x60, 0x00, 0x1B, 0xE0,
  0x06, 0xFE, 0x01, 0x99, 0xC0, 0x77, 0x38, 0x1C, 0xC7, 0x07, 0x18, 0xC0,
  0xC3, 0x38, 0x30, 0x7E, 0x0C, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x38, 0xE0, 0x61, 0xC0, 0xC7, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x0E,
  0x7F, 0x1D, 0xEE, 0x77, 0x9E, 0xEE, 0x1F, 0x9C, 0x3F, 0x3C, 0x3C, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7E, 0x3C, 0x7F, 0xFE, 0xEE, 0xEC, 0x03, 0xC0, 0x70,
  0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x07, 0x01, 0xE0,
  0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x18, 0x3B, 0xF7,
  0xFE, 0x3E, 0x07, 0xC3, 0xDC, 0x73, 0x84, 0x40, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x1E, 0x1E, 0x3C, 0x38,
  0x38, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0x3C,
  0x1C, 0xF0, 0x77, 0x81, 0xDE, 0xE7, 0x7B, 0xBD, 0xCE, 0xF7, 0x03, 0xDC,
  0x0E, 0xF0, 0x79, 0xC1, 0xC7, 0x8F, 0x1F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00,
  0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x7F, 0xC3, 0xDE, 0x18, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0x1F, 0x1E, 0x0F, 0x02, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1,
  0xF1, 0xF3, 0xC1, 0xE0, 0x03, 0x80, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x9E, 0x0F, 0x3C, 0x3E, 0x7F, 0xF8,
  0x7F, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x1D, 0xC0, 0x77, 0x81, 0xCF, 0x07, 0x1E, 0x1C, 0x38, 0x70, 0x71, 0xC1,
  0xE3, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x78, 0x1F, 0xFC, 0x7F, 0xF8, 0xF8, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x9E, 0x0F, 0x3C, 0x3E, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00,
  0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x78, 0xF7, 0x83, 0x3C, 0x01, 0xCF, 0x1F,
  0xFE, 0xFF, 0xF7, 0xC7, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x7B, 0xC7,
  0x9F, 0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF1, 0xF3, 0xC1, 0xE7, 0x87, 0x8F,
  0x0F, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xF1, 0xE1, 0xE7, 0x81, 0xCF, 0x03,
  0x9E, 0x0F, 0x3C, 0x3E, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x1C, 0xE0, 0x77, 0x83, 0xDE, 0x0F,
  0x7C, 0x7C, 0xFF, 0xF3, 0xFB, 0xC7, 0xCE, 0x00, 0x79, 0xC1, 0xCF, 0x1F,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xF3, 0xCF, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x78, 0x1C, 0x06, 0x03, 0x80, 0x00, 0x04, 0x00, 0xF0, 0x1F,
  0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x0F, 0x80, 0x38, 0x00, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x7C, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE0, 0xFE, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF,
  0xDF, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xE1, 0xC0, 0xC0, 0x60,
  0xC0, 0x30, 0xC7, 0x68, 0x67, 0xF6, 0x66, 0x73, 0x37, 0x19, 0x33, 0x0C,
  0x9B, 0x0C, 0xCD, 0x86, 0x64, 0xC3, 0x36, 0x63, 0x13, 0x61, 0x99, 0xB1,
  0xCC, 0xD9, 0xCC, 0x67, 0xBC, 0x33, 0x9C, 0x1C, 0x00, 0x06, 0x01, 0x03,
  0x83, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xDC, 0x01, 0xDC, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x9C, 0x07, 0x1E,
  0x0F, 0x1E, 0x1E, 0x1E, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x78, 0x0E,
  0x78, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF,
  0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xFC, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E,
  0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x7F, 0xF0,
  0xF1, 0xF3, 0xC1, 0xEF, 0x03, 0x9E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0xDE, 0x0F, 0xBE, 0x3E, 0x3F, 0xF8,
  0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x3E,
  0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xF1, 0xE3, 0xC1, 0xEF, 0x02, 0x1E, 0x00, 0x3C, 0x00, 0xF1, 0xFD,
  0xE3, 0xFB, 0xC7, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x1E, 0x1E, 0x3F,
  0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x38, 0x78, 0x78, 0x70, 0x78, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x8F, 0x0F, 0x1E, 0x1E, 0x3E, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E,
  0x00, 0x0F, 0x07, 0xC3, 0x83, 0xE1, 0xE1, 0xF0, 0x78, 0xF8, 0x1E, 0x7C,
  0x07, 0xBE, 0x01, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0x81, 0xE1,
  0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x80, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0x63, 0xE3, 0xB3, 0xF1, 0xD9,
  0xF8, 0xEC, 0xDC, 0x76, 0xEE, 0x3B, 0x6E, 0x19, 0xF7, 0x1C, 0xF3, 0x8E,
  0x79, 0xC7, 0x38, 0xE3, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x00, 0x0F, 0x07, 0x07, 0xC3, 0x87, 0xE1, 0xC3, 0xF1, 0xE1,
  0xF8, 0xF0, 0xFC, 0x70, 0x7E, 0x38, 0x7B, 0x9C, 0x3D, 0xDE, 0x1C, 0xEF,
  0x0E, 0x77, 0x07, 0x3B, 0x87, 0x9F, 0xC3, 0xC7, 0xE1, 0xC3, 0xF0, 0xE1,
  0xF8, 0x70, 0xF8, 0x78, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1,
  0xF1, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3E, 0x3C, 0x3F, 0xF8,
  0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x1F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x3E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xF3,
  0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3E, 0x3E, 0x3F, 0xF8, 0x7F, 0xE0,
  0x7F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x3C, 0x1E, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0x3C, 0xF0,
  0x78, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3E,
  0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x1F, 0x1C, 0x0F, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1E,
  0x10, 0x1E, 0xF0, 0x1E, 0xF8, 0x3C, 0x7F, 0xFC, 0x3F, 0xF0, 0x1F, 0xC0,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x0E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0xF8, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78,
  0x78, 0x70, 0x78, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x70, 0x03,
  0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3, 0x8E, 0x71, 0xCF,
  0x38, 0xE7, 0xBC, 0x77, 0xDC, 0x3B, 0xEE, 0x1F, 0xF7, 0x0F, 0xBF, 0x06,
  0xDF, 0x83, 0xE7, 0xC1, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x70,
  0x00, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x3D,
  0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3C, 0x78, 0x07, 0x8F,
  0x01, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x78, 0x1E,
  0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0xF0, 0x1D, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x07, 0xF8, 0x3F, 0x83, 0xFC,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x70, 0x38,
  0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xF1, 0xC3, 0x87, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0x1E,
  0x00, 0x78, 0x01, 0xE1, 0xFF, 0x8F, 0xFC, 0x78, 0x73, 0xC3, 0xCF, 0x0F,
  0x3C, 0x7C, 0xFF, 0xFB, 0xF9, 0xE7, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xCF, 0x07, 0xBF, 0x0F, 0xFF, 0x1F,
  0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xCE, 0x0F,
  0x3E, 0x1E, 0x7C, 0x7C, 0xFF, 0xF1, 0xDF, 0xC3, 0x9E, 0x00, 0x03, 0xE0,
  0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x78, 0x3D, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xBE, 0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x07,
  0x9E, 0x1F, 0xDC, 0x3F, 0xDC, 0x3C, 0x7C, 0x78, 0x3C, 0x78, 0x3C, 0xF0,
  0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3C, 0xF0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F,
  0x78, 0x1D, 0xE0, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x3E, 0x1E, 0x7F, 0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x3C, 0x00, 0xF0, 0x0F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0xCF,
  0x07, 0xEF, 0x0F, 0xFF, 0x1F, 0x3E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x7C, 0x7C, 0x3F, 0xFC,
  0x3F, 0xBC, 0x1F, 0x38, 0x00, 0x78, 0x00, 0x78, 0xF8, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xCF, 0x87, 0xBF, 0x8F, 0xFF, 0x1F, 0x1E, 0x7C, 0x3C, 0xF0,
  0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0x8E, 0x07, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xC0, 0xE3, 0x81, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x83, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0xF0, 0x7B,
  0xC0, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xB8, 0x1E, 0x78, 0x38, 0xF0,
  0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x83, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3B, 0xCE, 0x3F, 0xDF, 0x3F,
  0xFF, 0x3D, 0xE7, 0x39, 0xC7, 0x79, 0xC7, 0x71, 0xCE, 0x71, 0xCE, 0x73,
  0x8E, 0x73, 0x8E, 0xE3, 0x8E, 0xE3, 0x9C, 0xE3, 0x9C, 0xE7, 0x9C, 0xE7,
  0x1C, 0x1E, 0x7C, 0x3D, 0xFC, 0x77, 0xF8, 0xF8, 0xF3, 0xE1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x1C, 0x0E, 0x00, 0x07, 0xF0, 0x3F, 0xE3, 0xFF, 0xCF,
  0x0F, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF,
  0x07, 0xBE, 0x3C, 0x7F, 0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0x3C, 0x0F,
  0x7E, 0x0F, 0xFF, 0x0F, 0x8F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1C, 0x0F, 0x1C, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x3F,
  0xF8, 0x39, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x07, 0x9E, 0x3F, 0xB8, 0xFF, 0x71, 0xE3, 0xE7, 0x83,
  0xCF, 0x07, 0xBC, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7,
  0xCF, 0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xFC, 0xF7, 0xE3, 0xFF,
  0x8F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0xE1, 0xFF, 0xCF, 0x0F, 0x38, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x01, 0xE0, 0x03, 0xBC, 0x1E, 0xFF, 0xF1, 0xFF, 0x83, 0xF8,
  0x00, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0x7F,
  0xCF, 0xF0, 0xFE, 0x00, 0x3C, 0x1C, 0x78, 0x38, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x38, 0x3C, 0x70, 0x79, 0xE0, 0xF3, 0xC3,
  0xE7, 0xCF, 0x8F, 0xF7, 0x0F, 0xCE, 0x0F, 0x3C, 0x00, 0xF0, 0x1F, 0xE0,
  0x7B, 0xC0, 0xF7, 0x83, 0xC7, 0x07, 0x8E, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0,
  0x79, 0xC0, 0xF7, 0x80, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE3, 0x8E,
  0xE3, 0x8E, 0xE7, 0x9C, 0xE7, 0x9C, 0xEF, 0xD8, 0xED, 0xF8, 0xFD, 0xF8,
  0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0x0F, 0x07, 0x83, 0xC3,
  0xC0, 0x70, 0xE0, 0x1E, 0x78, 0x03, 0xBC, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x80, 0x78, 0xE0, 0x3C,
  0x3C, 0x0E, 0x0F, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE0,
  0x78, 0x38, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x00, 0x00,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xC0, 0x0F,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x1F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x02, 0xFF, 0xF9,
  0xFF, 0xF4, 0x0F, 0xC0,
};

const GFXglyph LiberationMono_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 18, 16, 5, -18 },
  { 17, 10, 8, 16, 5, -20 },
  { 27, 17, 18, 16, 0, -18 },
  { 66, 15, 22, 16, 1, -20 },
  { 108, 19, 18, 16, -1, -18 },
  { 151, 15, 18, 16, 0, -18 },
  { 185, 4, 8, 16, 8, -20 },
  { 189, 11, 26, 16, 4, -20 },
  { 225, 10, 26, 16, 2, -20 },
  { 258, 11, 10, 16, 4, -20 },
  { 272, 14, 13, 16, 1, -15 },
  { 295, 8, 9, 16, 1, -4 },
  { 304, 8, 3, 16, 4, -9 },
  { 307, 4, 4, 16, 5, -4 },
  { 309, 17, 20, 16, 0, -20 },
  { 352, 14, 18, 16, 1, -18 },
  { 384, 13, 18, 16, 1, -18 },
  { 414, 16, 18, 16, 0, -18 },
  { 450, 15, 18, 16, 1, -18 },
  { 484, 15, 18, 16, 0, -18 },
  { 518, 15, 18, 16, 1, -18 },
  { 552, 13, 18, 16, 2, -18 },
  { 582, 13, 18, 16, 3, -18 },
  { 612, 15, 18, 16, 1, -18 },
  { 646, 14, 18, 16, 1, -18 },
  { 678, 6, 15, 16, 5, -15 },
  { 690, 10, 20, 16, 2, -15 },
  { 715, 14, 15, 16, 1, -16 },
  { 742, 14, 10, 16, 1, -14 },
  { 760, 14, 15, 16, 1, -16 },
  { 787, 14, 18, 16, 2, -18 },
  { 819, 17, 24, 16, 0, -20 },
  { 870, 16, 18, 16, -1, -18 },
  { 906, 16, 18, 16, 0, -18 },
  { 942, 15, 18, 16, 1, -18 },
  { 976, 16, 18, 16, 0, -18 },
  { 1012, 17, 18, 16, 0, -18 },
  { 1051, 16, 18, 16, 1, -18 },
  { 1087, 15, 18, 16, 1, -18 },
  { 1121, 16, 18, 16, 0, -18 },
  { 1157, 15, 18, 16, 1, -18 },
  { 1191, 15, 18, 16, 1, -18 },
  { 1225, 18, 18, 16, 0, -18 },
  { 1266, 13, 18, 16, 1, -18 },
  { 1296, 17, 18, 16, 0, -18 },
  { 1335, 17, 18, 16, 0, -18 },
  { 1374, 15, 18, 16, 1, -18 },
  { 1408, 16, 18, 16, 0, -18 },
  { 1444, 15, 23, 16, 1, -18 },
  { 1488, 16, 18, 16, 0, -18 },
  { 1524, 16, 18, 16, 0, -18 },
  { 1560, 15, 18, 16, 2, -18 },
  { 1594, 16, 18, 16, 1, -18 },
  { 1630, 16, 18, 16, 2, -18 },
  { 1666, 17, 18, 16, 1, -18 },
  { 1705, 19, 18, 16, -1, -18 },
  { 1748, 16, 18, 16, 2, -18 },
  { 1784, 17, 18, 16, 0, -18 },
  { 1823, 13, 26, 16, 2, -20 },
  { 1866, 10, 20, 16, 4, -20 },
  { 1891, 13, 26, 16, 1, -20 },
  { 1934, 14, 12, 16, 1, -19 },
  { 1955, 17, 1, 16, -2, 2 },
  { 1958, 6, 4, 16, 7, -20 },
  { 1961, 14, 15, 16, 1, -15 },
  { 1988, 15, 20, 16, 0, -20 },
  { 2026, 14, 15, 16, 1, -15 },
  { 2053, 16, 20, 16, 1, -20 },
  { 2093, 14, 15, 16, 1, -15 },
  { 2120, 15, 20, 16, 2, -20 },
  { 2158, 16, 21, 16, 0, -15 },
  { 2200, 15, 20, 16, 0, -20 },
  { 2238, 14, 20, 16, 0, -20 },
  { 2273, 15, 26, 16, -1, -20 },
  { 2322, 15, 20, 16, 1, -20 },
  { 2360, 14, 20, 16, 0, -20 },
  { 2395, 16, 15, 16, 0, -15 },
  { 2425, 15, 15, 16, 0, -15 },
  { 2454, 14, 15, 16, 1, -15 },
  { 2481, 16, 21, 16, -1, -15 },
  { 2523, 15, 21, 16, 1, -15 },
  { 2563, 14, 15, 16, 2, -15 },
  { 2590, 14, 15, 16, 1, -15 },
  { 2617, 11, 19, 16, 3, -19 },
  { 2644, 15, 15, 16, 1, -15 },
  { 2673, 15, 15, 16, 2, -15 },
  { 2702, 16, 15, 16, 1, -15 },
  { 2732, 18, 15, 16, -1, -15 },
  { 2766, 18, 21, 16, -1, -15 },
  { 2814, 15, 15, 16, 0, -15 },
  { 2843, 14, 26, 16, 2, -20 },
  { 2889, 4, 26, 16, 6, -20 },
  { 2902, 14, 26, 16, 0, -20 },
  { 2948, 15, 4, 16, 1, -11 },
};

const GFXfont LiberationMono_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic27pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _LIBERATIONMONO_BOLDITALIC27PT7B_H_
