#ifndef _LIBERATIONMONO_BOLDITALIC28PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x00, 0x00, 0x78, 0xF0, 0xF0, 0xF0, 0x79, 0xEE, 0x3D, 0xC7, 0x78,
  0xEF, 0x1D, 0xC7, 0xB8, 0xE7, 0x1C, 0xE3, 0x80, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x60, 0xC0, 0x30, 0xC0, 0x38, 0x60, 0xFF, 0xFC, 0xFF, 0xFE, 0x0C,
  0x38, 0x06, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x0F, 0xFF, 0xCF, 0xFF, 0xE1,
  0xC3, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x40, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3C, 0xDE, 0x3C,
  0xCF, 0x38, 0x80, 0x3C, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFC, 0x01, 0x1C, 0x63, 0x1C, 0xE3, 0x1C, 0xF2, 0x7C, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3F, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x07, 0x80, 0xE1, 0xF8, 0x38,
  0x73, 0x0E, 0x0C, 0x61, 0x83, 0x8C, 0x60, 0x73, 0x98, 0x0E, 0x66, 0x01,
  0xFD, 0x80, 0x1F, 0x60, 0x00, 0x1D, 0xE0, 0x07, 0x7E, 0x01, 0xDC, 0xC0,
  0x73, 0x18, 0x1C, 0xE3, 0x03, 0x1C, 0x60, 0xC3, 0x9C, 0x30, 0x3F, 0x0C,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x3C, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x87, 0x3F, 0x8E, 0x7B, 0x8E,
  0xF3, 0xDC, 0xE1, 0xFC, 0xE0, 0xF8, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0x0E, 0x7B, 0x9C, 0xEF, 0x73, 0x9C, 0xE0, 0x01, 0xE0, 0x78, 0x1E,
  0x03, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x0E, 0x03, 0x84, 0xE7,
  0xF7, 0xFF, 0xCF, 0x83, 0xE1, 0xDC, 0xE7, 0x90, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x0F, 0x07, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x00, 0x7F,
  0xFF, 0xBF, 0xC0, 0x7F, 0xBD, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x78, 0x3D,
  0xE0, 0xF7, 0x03, 0xFC, 0xCF, 0xF7, 0x3F, 0xDC, 0xEF, 0x07, 0xB8, 0x1E,
  0xE0, 0x73, 0x83, 0xCF, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x7F, 0x0F, 0xFC, 0x3E, 0xE0, 0xE7, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF9, 0xF0, 0xF3, 0xC1, 0xE0, 0x03, 0xC0, 0x0F, 0x01, 0xFC, 0x03, 0xC0,
  0x0F, 0xF0, 0x01, 0xF0, 0x01, 0xE3, 0x03, 0xDE, 0x07, 0xBE, 0x1E, 0x7F,
  0xFC, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xDE, 0x03, 0xDC, 0x07, 0x9C, 0x0F, 0x3C, 0x1E, 0x3C, 0x3C,
  0x3C, 0x78, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x7C, 0x1F, 0xFC, 0x3F, 0xFC, 0xF8, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xDE, 0x0F, 0xBE, 0x3E, 0x7F, 0xF8, 0x7F,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D,
  0xE0, 0x07, 0x3E, 0x3D, 0xFC, 0xFF, 0xFB, 0xE1, 0xEF, 0x07, 0xBC, 0x1E,
  0xE0, 0x7B, 0xC3, 0xCF, 0x1F, 0x3F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF8, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x0F, 0xFC, 0x07, 0xE0,
  0x7F, 0xF1, 0xE1, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBE, 0x1E, 0x7F,
  0xFC, 0x7F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF1,
  0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x1F, 0x7C, 0x7E, 0x7F, 0xF8,
  0xFF, 0xF0, 0x79, 0xE0, 0x03, 0x9E, 0x0F, 0x3E, 0x3C, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0x1E, 0x3C, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x1E, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x07, 0x81, 0xC0,
  0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x0F, 0xC0, 0x38, 0x00, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x7C, 0x07, 0xF0, 0xFF,
  0x1F, 0xF0, 0xFE, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xDE, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xE1,
  0xC0, 0xC0, 0x70, 0xC0, 0x18, 0xE7, 0xBC, 0x67, 0xF6, 0x67, 0x3B, 0x33,
  0x1D, 0x93, 0x0C, 0xD9, 0x86, 0x6D, 0x86, 0x36, 0xC3, 0x36, 0x61, 0x9B,
  0x71, 0x8D, 0xB8, 0xCC, 0xDC, 0xEC, 0x67, 0xFE, 0x33, 0x8E, 0x1C, 0x00,
  0x06, 0x01, 0x03, 0x83, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xDE, 0x03, 0xDE, 0x03, 0x9E, 0x07,
  0x9E, 0x07, 0x1E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFF, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x0F, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xFE, 0x3C, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78,
  0x1F, 0x78, 0x1E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0, 0x01, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x3C, 0x0F, 0x3C, 0x0E, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF8,
  0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x7C, 0x1E, 0x78,
  0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0x87,
  0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0x1E,
  0x00, 0x3C, 0x00, 0x79, 0xFF, 0xE3, 0xFF, 0xC7, 0xF7, 0x80, 0xEF, 0x03,
  0xDF, 0x07, 0x9E, 0x1F, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0x07,
  0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0x07, 0x87, 0x83, 0xC3,
  0xC3, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xCF,
  0x0F, 0x9E, 0x1E, 0x3E, 0x7C, 0x3F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x0F,
  0x07, 0xC1, 0xE1, 0xF0, 0x78, 0x7C, 0x0F, 0x1F, 0x01, 0xE7, 0xC0, 0x3D,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF0, 0xF0, 0x1E, 0x1F, 0x03, 0xC1,
  0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE0, 0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x7E, 0x1F,
  0x9B, 0x8E, 0xEF, 0xE3, 0xBB, 0xF0, 0xEF, 0xDC, 0x3B, 0xF7, 0x0E, 0xF9,
  0xC7, 0x3E, 0xF1, 0xCF, 0x38, 0x73, 0xCE, 0x1C, 0x03, 0x87, 0x00, 0xE3,
  0x80, 0x78, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC7,
  0xE1, 0xE3, 0xF0, 0xE1, 0xF8, 0x70, 0xFE, 0x78, 0x77, 0x3C, 0x7B, 0x9E,
  0x3D, 0xCE, 0x1E, 0xE7, 0x0E, 0x7B, 0x87, 0x1F, 0xC7, 0x8F, 0xE3, 0xC7,
  0xE1, 0xE3, 0xF0, 0xE1, 0xF8, 0x70, 0x7C, 0x78, 0x3E, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F,
  0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x3C, 0x7C, 0x1E, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x1E, 0x7C,
  0x1F, 0x78, 0x1F, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0x80, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x3E, 0x3C, 0x3E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0x9F,
  0x03, 0xC7, 0x83, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x3C,
  0x0F, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0,
  0x78, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0x80, 0x03, 0xE7, 0x00, 0xF7, 0x80, 0xF3, 0xE0, 0xF8, 0xFF, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF,
  0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0,
  0x1C, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xDE, 0x00,
  0xE7, 0x80, 0x39, 0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x71, 0xC7, 0x3C, 0xF1,
  0xCF, 0x38, 0x77, 0xCE, 0x1D, 0xF7, 0x87, 0xED, 0xC1, 0xFB, 0x70, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C,
  0x00, 0x0F, 0x01, 0xE1, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x87,
  0x81, 0xE0, 0xF0, 0x78, 0x1F, 0x1E, 0x01, 0xE0, 0xF8, 0x0F, 0x3C, 0x07,
  0x9E, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x1F,
  0xF0, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B,
  0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x0E, 0x1E, 0x1E, 0x38, 0x1C, 0xE0, 0x39,
  0xC0, 0x77, 0x00, 0xF0, 0xFF, 0xFF, 0x80, 0xF0, 0xF0, 0xF0, 0x60, 0x07,
  0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0xFF, 0x8F,
  0xFE, 0x78, 0x7B, 0xC1, 0xEF, 0x0F, 0x3C, 0x7C, 0xFF, 0x7F, 0xF9, 0xF7,
  0xC7, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x7C, 0x1E, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C, 0x7C,
  0x7F, 0xF8, 0x7F, 0xF0, 0x73, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xF1, 0xE3, 0xC1, 0xEF, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC1, 0xE7, 0xC7, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x07, 0x9E, 0x1F,
  0xDE, 0x3F, 0xFE, 0x3E, 0x7E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F,
  0x78, 0x3E, 0x78, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE7, 0x81,
  0xCF, 0x03, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x03, 0xC0, 0x07,
  0xC3, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF8, 0x78, 0x00, 0xE0, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xE7,
  0x83, 0xFB, 0x83, 0xFF, 0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xE0, 0x78, 0xF0,
  0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1F, 0x0F, 0x87, 0x8F, 0x83,
  0xFF, 0xC1, 0xFD, 0xE0, 0x7C, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x3C, 0x7C,
  0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x8F, 0x0F, 0x7F, 0x1F, 0xFF, 0x3E, 0x3E,
  0x78, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x78,
  0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x1F,
  0x1C, 0x3C, 0x3C, 0x78, 0x3C, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x79, 0xE0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xF8,
  0xF0, 0x78, 0xF0, 0x78, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xCF, 0x1D, 0xEF, 0x8F, 0xF7,
  0xE7, 0xBE, 0xF3, 0x9E, 0x73, 0xCE, 0x39, 0xC7, 0x1C, 0xE3, 0x8E, 0x71,
  0xCF, 0x39, 0xE7, 0x3C, 0xE3, 0x9C, 0x71, 0xCE, 0x38, 0xE7, 0x1C, 0xF3,
  0x8E, 0x70, 0x3C, 0x78, 0x7B, 0xF8, 0xFF, 0xF9, 0xF1, 0xF3, 0xC1, 0xEF,
  0x03, 0xDE, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x7B, 0xC0, 0xF7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1E, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF1, 0xF1, 0xF7, 0x81, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3D,
  0xE0, 0x7B, 0xC1, 0xF7, 0xC7, 0xC7, 0xFF, 0x0F, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0x1E, 0x07, 0xBF, 0x83, 0xFF, 0xC1, 0xF1, 0xF0, 0xF0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x87, 0xC7,
  0xC7, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xE7, 0xC0, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x07, 0x9E, 0x3F,
  0xBC, 0xFF, 0xF9, 0xF3, 0xF7, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xCF, 0xFF, 0x8F, 0xEF, 0x0F,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x7C, 0xF7, 0xF3, 0xFF, 0xCF, 0xE0, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0x07, 0x38,
  0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFC,
  0x1E, 0xFF, 0xF9, 0xFF, 0xC3, 0xF8, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x70, 0x3D, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xCF, 0xFF,
  0x8F, 0xEF, 0x0F, 0x1C, 0x00, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xE0, 0x79, 0xE0, 0x39,
  0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x70,
  0x03, 0xB8, 0x03, 0xDC, 0x01, 0xDE, 0x00, 0xEE, 0x1C, 0xE7, 0x1E, 0x73,
  0x9F, 0x39, 0xCF, 0xB8, 0xEE, 0xDC, 0x76, 0x6E, 0x3F, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0x87, 0x83, 0xC3, 0xC0, 0x0F, 0x03, 0xC3, 0xC1, 0xE0,
  0x78, 0xF0, 0x1E, 0x78, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x78, 0xF0, 0x3C, 0x3C,
  0x0F, 0x07, 0x87, 0x81, 0xE0, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x38, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x38, 0xE0,
  0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x00,
  0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x02, 0xFF,
  0xFD, 0xFF, 0xFC, 0x0F, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 18, 17, 5, -18 },
  { 19, 11, 9, 17, 5, -20 },
  { 32, 17, 18, 17, 0, -18 },
  { 71, 16, 22, 17, 1, -20 },
  { 115, 19, 18, 17, -1, -18 },
  { 158, 16, 18, 17, 0, -18 },
  { 194, 5, 9, 17, 8, -20 },
  { 200, 11, 26, 17, 4, -20 },
  { 236, 11, 26, 17, 2, -20 },
  { 272, 10, 10, 17, 5, -20 },
  { 285, 14, 15, 17, 1, -17 },
  { 312, 9, 9, 17, 1, -4 },
  { 323, 9, 3, 17, 4, -9 },
  { 327, 5, 4, 17, 5, -4 },
  { 330, 18, 20, 17, 0, -20 },
  { 375, 14, 18, 17, 2, -18 },
  { 407, 14, 18, 17, 1, -18 },
  { 439, 16, 18, 17, 0, -18 },
  { 475, 15, 18, 17, 1, -18 },
  { 509, 16, 18, 17, 0, -18 },
  { 545, 15, 18, 17, 1, -18 },
  { 579, 14, 18, 17, 2, -18 },
  { 611, 14, 18, 17, 3, -18 },
  { 643, 15, 18, 17, 1, -18 },
  { 677, 15, 18, 17, 1, -18 },
  { 711, 7, 15, 17, 5, -15 },
  { 725, 10, 20, 17, 2, -15 },
  { 750, 14, 15, 17, 1, -17 },
  { 777, 14, 11, 17, 1, -15 },
  { 797, 14, 15, 17, 1, -17 },
  { 824, 15, 18, 17, 2, -18 },
  { 858, 17, 24, 17, 0, -20 },
  { 909, 16, 18, 17, -1, -18 },
  { 945, 16, 18, 17, 0, -18 },
  { 981, 16, 18, 17, 1, -18 },
  { 1017, 16, 18, 17, 0, -18 },
  { 1053, 17, 18, 17, 0, -18 },
  { 1092, 16, 18, 17, 1, -18 },
  { 1128, 15, 18, 17, 1, -18 },
  { 1162, 17, 18, 17, 0, -18 },
  { 1201, 16, 18, 17, 1, -18 },
  { 1237, 15, 18, 17, 1, -18 },
  { 1271, 19, 18, 17, 0, -18 },
  { 1314, 14, 18, 17, 1, -18 },
  { 1346, 18, 18, 17, 0, -18 },
  { 1387, 17, 18, 17, 0, -18 },
  { 1426, 16, 18, 17, 1, -18 },
  { 1462, 17, 18, 17, 0, -18 },
  { 1501, 16, 23, 17, 1, -18 },
  { 1547, 17, 18, 17, 0, -18 },
  { 1586, 17, 18, 17, 0, -18 },
  { 1625, 16, 18, 17, 2, -18 },
  { 1661, 16, 18, 17, 1, -18 },
  { 1697, 17, 18, 17, 2, -18 },
  { 1736, 18, 18, 17, 1, -18 },
  { 1777, 19, 18, 17, -1, -18 },
  { 1820, 17, 18, 17, 2, -18 },
  { 1859, 17, 18, 17, 0, -18 },
  { 1898, 13, 26, 17, 3, -20 },
  { 1941, 10, 20, 17, 4, -20 },
  { 1966, 13, 26, 17, 1, -20 },
  { 2009, 15, 12, 17, 1, -19 },
  { 2032, 17, 1, 17, -2, 2 },
  { 2035, 7, 4, 17, 7, -20 },
  { 2039, 14, 15, 17, 1, -15 },
  { 2066, 16, 20, 17, 0, -20 },
  { 2106, 15, 15, 17, 1, -15 },
  { 2135, 16, 20, 17, 1, -20 },
  { 2175, 15, 15, 17, 1, -15 },
  { 2204, 15, 20, 17, 3, -20 },
  { 2242, 17, 21, 17, 0, -15 },
  { 2287, 15, 20, 17, 1, -20 },
  { 2325, 15, 20, 17, 0, -20 },
  { 2363, 15, 26, 17, -1, -20 },
  { 2412, 16, 20, 17, 1, -20 },
  { 2452, 15, 20, 17, 0, -20 },
  { 2490, 17, 15, 17, 0, -15 },
  { 2522, 15, 15, 17, 1, -15 },
  { 2551, 15, 15, 17, 1, -15 },
  { 2580, 17, 21, 17, -1, -15 },
  { 2625, 15, 21, 17, 1, -15 },
  { 2665, 14, 15, 17, 2, -15 },
  { 2692, 14, 15, 17, 1, -15 },
  { 2719, 12, 19, 17, 3, -19 },
  { 2748, 15, 15, 17, 1, -15 },
  { 2777, 16, 15, 17, 2, -15 },
  { 2807, 17, 15, 17, 1, -15 },
  { 2839, 18, 15, 17, -1, -15 },
  { 2873, 19, 21, 17, -1, -15 },
  { 2923, 15, 15, 17, 0, -15 },
  { 2952, 15, 26, 17, 2, -20 },
  { 3001, 3, 26, 17, 7, -20 },
  { 3011, 14, 26, 17, 0, -20 },
  { 3057, 15, 4, 17, 1, -11 },
};

const GFXfont LiberationMono_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic28pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _LIBERATIONMONO_BOLDITALIC28PT7B_H_
