#ifndef _LIBERATIONMONO_BOLDITALIC31PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x1E, 0x0F, 0x00,
  0x7C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0x71, 0xC3, 0x8E,
  0x3C, 0xF1, 0xE7, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x1C, 0x38, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x18, 0x30, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x18, 0x30,
  0x07, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x06, 0x0C, 0x07, 0xFF, 0xF9,
  0xFF, 0xFF, 0x06, 0x0C, 0x01, 0xC3, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x01,
  0xC3, 0x80, 0x30, 0x60, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0x00,
  0xFF, 0xE1, 0xFF, 0xF8, 0xFB, 0x7C, 0xF1, 0x9E, 0x78, 0xCE, 0x3C, 0x40,
  0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x06,
  0x3C, 0x23, 0x1E, 0xF1, 0x8F, 0x78, 0x87, 0xBE, 0x4F, 0x9F, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xC0, 0x38, 0x7F, 0x03, 0x87, 0x38, 0x38, 0x38, 0xC3, 0x81, 0x86, 0x38,
  0x1C, 0x73, 0x80, 0xE3, 0x98, 0x07, 0x39, 0x80, 0x1F, 0x98, 0x00, 0x79,
  0xC0, 0x00, 0x1D, 0xF0, 0x01, 0xDF, 0xC0, 0x1D, 0xCE, 0x01, 0xCC, 0x70,
  0x1C, 0xE3, 0x81, 0xC7, 0x1C, 0x1C, 0x38, 0xE0, 0xC1, 0xCE, 0x0C, 0x07,
  0xE0, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0E,
  0x1C, 0x07, 0x87, 0x01, 0xC3, 0x80, 0x79, 0xE0, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xE0, 0xE3, 0xFC, 0x39, 0xF7, 0x1C, 0x71, 0xE7, 0x3C, 0x3B, 0x8F,
  0x0F, 0xE3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFE,
  0x1E, 0x7B, 0xDE, 0xEF, 0x7B, 0xDC, 0xE7, 0x00, 0x01, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x00,
  0x07, 0x80, 0x70, 0x07, 0x06, 0x73, 0x7F, 0xFF, 0xFF, 0x1F, 0x81, 0xF8,
  0x3B, 0x87, 0x3C, 0x73, 0xC2, 0x10, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07,
  0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFD, 0xEF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1E, 0x1E, 0x3C, 0x1F, 0x3C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xFB,
  0xDE, 0xFB, 0x9E, 0xF3, 0x9E, 0xF3, 0x9E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x00,
  0x7C, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0xC3, 0xF7, 0x87, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1E, 0x1F, 0x0F, 0x07,
  0xC7, 0xC1, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0x01, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9, 0xE0, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFB, 0xC0, 0x79, 0xF0, 0x3C, 0xF8, 0x7E, 0x3F, 0xFE,
  0x1F, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3B, 0xC0, 0x1C, 0xF0, 0x0E, 0x3C, 0x07,
  0x9F, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x79, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0x8F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFB, 0xC0, 0x79, 0xF0, 0x7C,
  0xF8, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x1F, 0x3C, 0x00, 0x78, 0x00, 0x79,
  0xF0, 0x7F, 0xFC, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x3E, 0xF0, 0x3E, 0xF0,
  0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xE1, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x3C, 0x3E, 0x0F, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0x87, 0xC7, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0x79, 0xF0, 0x3C, 0xF8, 0x7E, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0,
  0x7C, 0xF0, 0x3E, 0x78, 0x1F, 0x3C, 0x0F, 0x1F, 0x1F, 0x8F, 0xFF, 0xC3,
  0xFD, 0xE0, 0xF9, 0xE0, 0x00, 0xF0, 0x20, 0xF9, 0xF0, 0x78, 0x78, 0x78,
  0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x1E, 0x7C, 0xF9, 0xE3, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3C, 0x78, 0xF0, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x1F,
  0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0xC0, 0x01, 0xF0, 0x03,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0x80, 0x0F, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01,
  0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x1F, 0x00, 0x0E, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0,
  0x3F, 0x00, 0x70, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF,
  0x3E, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0xF0, 0x07, 0x07, 0x01, 0x80, 0x60, 0x60, 0x0E, 0x1C, 0x00,
  0xC3, 0x1E, 0xD8, 0xC7, 0xDB, 0x19, 0xCE, 0x66, 0x71, 0xCC, 0xCC, 0x39,
  0xB3, 0x86, 0x36, 0x60, 0xCC, 0xDC, 0x39, 0x9B, 0x86, 0x37, 0x61, 0xCC,
  0xCC, 0x31, 0x99, 0x8E, 0x63, 0x33, 0xCC, 0x67, 0xDF, 0x0E, 0x71, 0xC1,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x60, 0x38, 0x38, 0x07, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE3,
  0x80, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x0F,
  0xBC, 0x00, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3C, 0x1F,
  0x0F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x3E, 0x1F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0xF0, 0xF8, 0x3E, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0,
  0x79, 0xF0, 0x3E, 0x7C, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3E, 0x1E, 0x07, 0x8F,
  0x81, 0xF3, 0xC0, 0x61, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x78,
  0x7C, 0x3C, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E,
  0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C, 0x7E, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF1,
  0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x7F,
  0xFE, 0x3F, 0xDF, 0x1F, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x7C, 0xF0,
  0x3C, 0x7C, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF0, 0x3C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0x0F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC3, 0xC1,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC1, 0xF0, 0x1E, 0x1F,
  0x00, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7B, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3B, 0x9F, 0x87, 0x77, 0x71, 0xEE,
  0xEE, 0x3D, 0xDB, 0xC7, 0x3F, 0x78, 0xE7, 0xEE, 0x1C, 0xF9, 0xC7, 0x9F,
  0x38, 0xF3, 0xCF, 0x1C, 0x79, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x1E, 0x00,
  0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x80, 0x0F, 0xC1, 0xE1, 0xF8, 0x3C, 0x3F,
  0x07, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF,
  0x1C, 0x1E, 0xE7, 0x83, 0x9C, 0xF0, 0xF3, 0xDE, 0x1E, 0x7B, 0xC3, 0xCF,
  0x70, 0x79, 0xEE, 0x0E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F,
  0xC1, 0xE1, 0xF8, 0x38, 0x1F, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xE1, 0xF1, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x78,
  0x07, 0xBC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0xFB,
  0xE0, 0x79, 0xF0, 0x7C, 0x7C, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x83, 0xE0, 0xF0,
  0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC1,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0xF9,
  0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C, 0x7C,
  0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x83, 0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF0, 0x1E, 0x1E, 0x0F, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xC7, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3E, 0x7C, 0x1F, 0x1F,
  0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE7, 0xC0, 0xF3,
  0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x0F,
  0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF8,
  0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x03, 0xEF, 0x00,
  0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x7C,
  0x03, 0xCF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00,
  0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x71,
  0xE7, 0x9E, 0x38, 0xF3, 0xCF, 0x1E, 0xF9, 0xE3, 0xDF, 0xB8, 0x77, 0x7F,
  0x0E, 0xEF, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x0F,
  0x03, 0xE0, 0x3E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xF3, 0xC0, 0x03, 0xDF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xBC, 0x00, 0x7C,
  0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xC0, 0x3C,
  0x1F, 0x00, 0xF8, 0x78, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x3E, 0x1E, 0x07,
  0x83, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xFB, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xBC,
  0x07, 0x9C, 0x07, 0x1C, 0x0F, 0x1E, 0x0E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E,
  0x38, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0xF0,
  0xF0, 0xF0, 0x70, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3E,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0xFE, 0x3F, 0xFE, 0x7C, 0x3C, 0xF8,
  0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0xFC, 0xFF, 0xBF, 0xFF, 0x3E, 0x7E,
  0x1E, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x7C, 0x1E, 0xFE, 0x3F, 0xFF, 0x3F, 0x1F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x78,
  0x1E, 0xFC, 0x3E, 0xFC, 0x7C, 0xF7, 0xF8, 0xF7, 0xF8, 0xF3, 0xE0, 0x01,
  0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1E, 0x78,
  0x3E, 0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x78, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x8F, 0xC3, 0xC1, 0xF1, 0xF0, 0x7C,
  0x78, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x3E,
  0x0F, 0x8F, 0x87, 0xE3, 0xE3, 0xF0, 0x7F, 0xFC, 0x1F, 0xEF, 0x01, 0xE3,
  0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x7C,
  0x0F, 0x7C, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x1E, 0x7C, 0x3C, 0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x03,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFD, 0xE3, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0,
  0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F,
  0x03, 0xC7, 0x83, 0xE3, 0xE3, 0xF1, 0xFF, 0xF8, 0x7F, 0x7C, 0x1F, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x1E, 0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x3E, 0x3E, 0xFF, 0x3F, 0xFF, 0x3F, 0x1F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x03, 0xE7, 0x80,
  0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFB, 0xC0, 0x7C,
  0xF0, 0x1E, 0x3E, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F,
  0x8F, 0x03, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1D, 0xE3, 0x8F, 0xF9, 0xF3, 0xBF, 0xFC, 0xFB, 0xE7, 0x3C, 0xF1,
  0xCE, 0x3C, 0x73, 0x8E, 0x3D, 0xE3, 0x8F, 0x78, 0xE3, 0xDC, 0x78, 0xE7,
  0x1E, 0x39, 0xC7, 0x9E, 0xF1, 0xC7, 0xBC, 0x71, 0xEF, 0x3C, 0x73, 0x8F,
  0x1C, 0xE3, 0xC7, 0x00, 0x1E, 0x3E, 0x3E, 0xFF, 0x3D, 0xFF, 0x3F, 0x1F,
  0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x1F, 0x78, 0x1F,
  0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x3C, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xC0,
  0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE,
  0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x00, 0x07, 0x8F, 0x03, 0xEF, 0xE0, 0xFF, 0xFC, 0x3F, 0x1F,
  0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xC7,
  0x81, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0xC7, 0xC3, 0xDF,
  0xF0, 0xF7, 0xF8, 0x3C, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC7, 0x87, 0xF3, 0xC7,
  0xFF, 0xC7, 0xC7, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0, 0x7C, 0xF0, 0x3E,
  0xF8, 0x1E, 0x7C, 0x0F, 0x3E, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC7,
  0xE1, 0xFF, 0xF0, 0xFF, 0x78, 0x3E, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x3F, 0x1E, 0x7F,
  0x1E, 0xFF, 0x1F, 0xFE, 0x3F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF,
  0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x70, 0x1E, 0xF8, 0x3C, 0xFF, 0xFC,
  0x7F, 0xF8, 0x1F, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x7F,
  0xFD, 0xFF, 0xE7, 0xFF, 0x87, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x1E, 0x07, 0x9F, 0x07, 0xCF, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xE7, 0xE1, 0xFE,
  0xF0, 0xFE, 0x78, 0x3E, 0x3C, 0x00, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80,
  0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x01, 0xEE,
  0x00, 0x3D, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x1E, 0x38, 0xE3, 0xC7, 0x1C,
  0xF9, 0xE3, 0x9F, 0x38, 0x77, 0xE7, 0x0E, 0xED, 0xE3, 0xD9, 0xB8, 0x7F,
  0x37, 0x0E, 0xC6, 0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0,
  0x78, 0x00, 0x0F, 0x01, 0xF0, 0xF8, 0x3E, 0x07, 0x87, 0xC0, 0x7C, 0x78,
  0x03, 0xCF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x1E, 0x01, 0xF1,
  0xE0, 0x3E, 0x1F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x80, 0x1F, 0x00, 0xF0,
  0xF8, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0xC3,
  0xE0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01,
  0xE7, 0x80, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0x00,
  0xBF, 0xF0, 0xDF, 0xFF, 0xEC, 0x3F, 0xE0, 0x03, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 20, 19, 5, -20 },
  { 24, 13, 10, 19, 5, -23 },
  { 41, 19, 20, 19, 0, -20 },
  { 89, 17, 25, 19, 1, -22 },
  { 143, 21, 20, 19, -1, -20 },
  { 196, 18, 20, 19, 0, -20 },
  { 241, 5, 10, 19, 9, -23 },
  { 248, 12, 29, 19, 5, -23 },
  { 292, 12, 29, 19, 2, -23 },
  { 336, 12, 12, 19, 5, -23 },
  { 354, 15, 15, 19, 2, -18 },
  { 383, 10, 10, 19, 1, -5 },
  { 396, 9, 4, 19, 5, -10 },
  { 401, 5, 5, 19, 6, -5 },
  { 405, 20, 23, 19, 0, -23 },
  { 463, 16, 20, 19, 2, -20 },
  { 503, 15, 20, 19, 1, -20 },
  { 541, 18, 20, 19, 0, -20 },
  { 586, 17, 20, 19, 1, -20 },
  { 629, 18, 20, 19, 0, -20 },
  { 674, 17, 20, 19, 1, -20 },
  { 717, 16, 20, 19, 2, -20 },
  { 757, 16, 20, 19, 3, -20 },
  { 797, 17, 20, 19, 1, -20 },
  { 840, 17, 20, 19, 1, -20 },
  { 883, 7, 17, 19, 6, -17 },
  { 898, 11, 22, 19, 2, -17 },
  { 929, 15, 17, 19, 2, -19 },
  { 961, 15, 11, 19, 2, -16 },
  { 982, 15, 17, 19, 2, -19 },
  { 1014, 16, 20, 19, 2, -20 },
  { 1054, 19, 27, 19, 0, -23 },
  { 1119, 19, 20, 19, -2, -20 },
  { 1167, 18, 20, 19, 0, -20 },
  { 1212, 18, 20, 19, 1, -20 },
  { 1257, 18, 20, 19, 0, -20 },
  { 1302, 19, 20, 19, 0, -20 },
  { 1350, 18, 20, 19, 1, -20 },
  { 1395, 17, 20, 19, 1, -20 },
  { 1438, 19, 20, 19, 0, -20 },
  { 1486, 18, 20, 19, 1, -20 },
  { 1531, 17, 20, 19, 1, -20 },
  { 1574, 21, 20, 19, 0, -20 },
  { 1627, 14, 20, 19, 2, -20 },
  { 1662, 19, 20, 19, 0, -20 },
  { 1710, 19, 20, 19, 0, -20 },
  { 1758, 17, 20, 19, 1, -20 },
  { 1801, 19, 20, 19, 0, -20 },
  { 1849, 17, 26, 19, 1, -20 },
  { 1905, 19, 20, 19, 0, -20 },
  { 1953, 18, 20, 19, 0, -20 },
  { 1998, 17, 20, 19, 3, -20 },
  { 2041, 17, 20, 19, 2, -20 },
  { 2084, 19, 20, 19, 2, -20 },
  { 2132, 19, 20, 19, 2, -20 },
  { 2180, 22, 20, 19, -2, -20 },
  { 2235, 19, 20, 19, 2, -20 },
  { 2283, 19, 20, 19, 0, -20 },
  { 2331, 15, 29, 19, 3, -23 },
  { 2386, 12, 23, 19, 4, -23 },
  { 2421, 15, 29, 19, 1, -23 },
  { 2476, 16, 14, 19, 1, -21 },
  { 2504, 19, 1, 19, -2, 2 },
  { 2507, 7, 4, 19, 8, -22 },
  { 2511, 16, 17, 19, 1, -17 },
  { 2545, 16, 23, 19, 1, -23 },
  { 2591, 16, 17, 19, 1, -17 },
  { 2625, 18, 23, 19, 1, -23 },
  { 2677, 16, 17, 19, 1, -17 },
  { 2711, 17, 23, 19, 3, -23 },
  { 2760, 17, 23, 19, 1, -17 },
  { 2809, 16, 23, 19, 1, -23 },
  { 2855, 16, 23, 19, 0, -23 },
  { 2901, 17, 29, 19, -1, -23 },
  { 2963, 18, 23, 19, 1, -23 },
  { 3015, 16, 23, 19, 0, -23 },
  { 3061, 18, 17, 19, 0, -17 },
  { 3100, 16, 17, 19, 1, -17 },
  { 3134, 17, 17, 19, 1, -17 },
  { 3171, 18, 23, 19, -1, -17 },
  { 3223, 17, 23, 19, 1, -17 },
  { 3272, 16, 17, 19, 2, -17 },
  { 3306, 16, 17, 19, 1, -17 },
  { 3340, 14, 21, 19, 3, -21 },
  { 3377, 17, 17, 19, 1, -17 },
  { 3414, 18, 17, 19, 2, -17 },
  { 3453, 19, 17, 19, 1, -17 },
  { 3494, 20, 17, 19, -1, -17 },
  { 3537, 21, 23, 19, -1, -17 },
  { 3598, 17, 17, 19, 0, -17 },
  { 3635, 16, 29, 19, 3, -23 },
  { 3693, 4, 30, 19, 7, -23 },
  { 3708, 16, 29, 19, 0, -23 },
  { 3766, 17, 5, 19, 1, -13 },
};

const GFXfont LiberationMono_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic31pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _LIBERATIONMONO_BOLDITALIC31PT7B_H_
