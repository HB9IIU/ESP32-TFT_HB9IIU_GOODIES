#ifndef _LIBERATIONMONO_BOLDITALIC36PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x3C, 0x3D, 0xF1, 0xF7, 0xC7,
  0xDF, 0x1F, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x00, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x03, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0x80, 0x0E, 0x0E, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x18, 0x18, 0x00, 0xE0, 0xE0,
  0x03, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x18,
  0x00, 0xE0, 0xE0, 0x03, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0x9B, 0xF1, 0xF1, 0x9F, 0x1E, 0x30, 0xC3, 0xE3, 0x00, 0x1F, 0x30,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x67, 0xE0, 0x06, 0x3E, 0x10, 0xC3, 0xEF, 0x0C, 0x3E, 0xF8,
  0xC7, 0xCF, 0xCC, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0x07, 0xF0, 0x0E, 0x0E, 0x78, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x38,
  0x70, 0x1C, 0x38, 0xF0, 0x1C, 0x38, 0xE0, 0x3C, 0x71, 0xC0, 0x3C, 0x73,
  0x80, 0x1C, 0xE7, 0x00, 0x1F, 0xEE, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x39,
  0xF0, 0x00, 0x7B, 0xFC, 0x00, 0x77, 0x1C, 0x00, 0xE7, 0x1C, 0x01, 0xCE,
  0x1C, 0x03, 0x8E, 0x1C, 0x07, 0x0E, 0x1C, 0x0E, 0x0E, 0x3C, 0x1C, 0x0E,
  0x38, 0x3C, 0x0E, 0x78, 0x38, 0x0F, 0xF0, 0x70, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1E, 0x3E, 0x03, 0xC1, 0xE0, 0x3C,
  0x1C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xDF, 0x00, 0x3F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x0F, 0x1F, 0xE0, 0xF3, 0xFF, 0x0E, 0x7C, 0xF1, 0xEF,
  0x8F, 0xBC, 0xF0, 0x7F, 0xCF, 0x07, 0xF8, 0xF0, 0x3F, 0x0F, 0x01, 0xF0,
  0xF8, 0x7F, 0x8F, 0xFF, 0xFF, 0x7F, 0xF3, 0xF1, 0xFC, 0x1F, 0x3D, 0xF7,
  0xDF, 0x79, 0xE7, 0x9E, 0xF3, 0xCF, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x18, 0xE2, 0x7B, 0xFB,
  0xFF, 0xF7, 0xFF, 0x83, 0xE0, 0x1F, 0xC0, 0xF7, 0x8F, 0x9E, 0x1C, 0x78,
  0x20, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x00,
  0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xF0, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xCF,
  0x80, 0xF9, 0xF3, 0xDF, 0x3E, 0x73, 0xEF, 0x9E, 0x7D, 0xF3, 0xCF, 0xBE,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7E,
  0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xFE, 0x07, 0xEF,
  0x81, 0xF3, 0xE0, 0x70, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x83, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x03, 0xFE, 0x00,
  0x7B, 0xE0, 0x0F, 0x3E, 0x01, 0xE3, 0xC0, 0x3C, 0x7C, 0x07, 0x87, 0xC0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x78, 0x3C, 0x0F, 0x87, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x7E, 0x01, 0xEF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xCF, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x7C, 0x0F, 0xBF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xE1, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x7C, 0x3E, 0x1F, 0x87, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xF1,
  0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x7C,
  0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0x83, 0xF0, 0xFC, 0x3E, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC0,
  0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x8F, 0xCF, 0x81,
  0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFD,
  0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFD, 0xF1, 0xFE, 0xF8, 0x3F, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x3C,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF,
  0xFF, 0x7F, 0x0F, 0xDF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x80, 0x0F, 0x07, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x18,
  0x1C, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x87, 0x9B, 0x0C, 0x3E, 0xEC, 0x63,
  0xCF, 0x31, 0x8C, 0x3C, 0xCE, 0x70, 0xE7, 0x33, 0x83, 0x9C, 0xCE, 0x0E,
  0x67, 0x30, 0x71, 0x99, 0xC1, 0xC6, 0x67, 0x06, 0x39, 0x98, 0x38, 0xCE,
  0xE0, 0xE3, 0x3B, 0x87, 0x18, 0xEE, 0x1C, 0x63, 0x98, 0xB3, 0x0E, 0x7E,
  0xF8, 0x38, 0xE3, 0xC0, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x10,
  0x1E, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0,
  0x0F, 0x03, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07,
  0xE7, 0xE0, 0x18, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFE, 0x3F, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x0F, 0xE1, 0xF0, 0x3F,
  0x1F, 0x03, 0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0,
  0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x1F, 0x8F, 0xC3, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xC3, 0xE1, 0xF8, 0x3F, 0x1F, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC3, 0xFE, 0x7C, 0x3F, 0xE7,
  0xC7, 0xFE, 0x7C, 0x7F, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xE0, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E,
  0x1F, 0x03, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3,
  0xE0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFE,
  0x1F, 0x03, 0xF8, 0x3E, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF0, 0xFE, 0x03,
  0xE3, 0xF8, 0x07, 0xCF, 0xE0, 0x0F, 0xBF, 0x80, 0x1E, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF8,
  0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x77, 0x0F, 0xE0, 0xEE, 0x1F, 0xC3,
  0xDC, 0x77, 0x87, 0xB8, 0xEE, 0x0F, 0x73, 0xFC, 0x1E, 0xE7, 0x78, 0x3D,
  0xCE, 0xF0, 0xF3, 0xB9, 0xE1, 0xE7, 0x73, 0x83, 0xCF, 0xEF, 0x07, 0x9F,
  0x9E, 0x0F, 0x3F, 0x3C, 0x1C, 0x7C, 0x78, 0x78, 0xF8, 0xE0, 0xF1, 0xE3,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3,
  0xF8, 0x3E, 0x3F, 0xC1, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0xF8, 0x7F, 0x87,
  0xC3, 0xFC, 0x3E, 0x3F, 0xF1, 0xE1, 0xF7, 0x8F, 0x0F, 0xBC, 0xF8, 0x79,
  0xE7, 0xC3, 0xCF, 0x3E, 0x1E, 0x7D, 0xE1, 0xF1, 0xEF, 0x0F, 0x8F, 0x78,
  0x7C, 0x7B, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x83,
  0xF8, 0x7C, 0x1F, 0xC3, 0xC0, 0xFE, 0x1E, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F,
  0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3E, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0x87, 0xE1, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF0, 0x3F, 0x0F, 0x80,
  0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x8F,
  0x81, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC3,
  0xF1, 0xF8, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xF0, 0x3F, 0x8F, 0x80, 0xFC, 0x7C, 0x03,
  0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFC, 0x1F, 0x87, 0xC0,
  0x7C, 0x7C, 0x03, 0xC3, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0xF9, 0xFC,
  0x0F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF3, 0xF0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xCF, 0xC0, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0xC7, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF8, 0x07, 0xCF, 0xC0,
  0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0xF9, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x3C,
  0x7C, 0xF8, 0xF1, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1E, 0x3E, 0xFC, 0xF0,
  0xFB, 0xFB, 0xC3, 0xDF, 0xEF, 0x0F, 0x77, 0xF8, 0x3D, 0xDF, 0xE0, 0xFF,
  0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0x81,
  0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8,
  0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xE7, 0xE0,
  0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0xF0, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0x3E,
  0x07, 0xCF, 0x83, 0xF3, 0xF1, 0xFC, 0xFF, 0xEF, 0xDF, 0xF3, 0xF3, 0xF0,
  0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0xFC, 0x1F, 0x7F, 0xC3, 0xFF,
  0xFC, 0x7F, 0x1F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0xFC, 0xFC, 0x1F, 0x3F, 0x87, 0xC7, 0xDF, 0xF8, 0xFB, 0xFC,
  0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3F,
  0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x63, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x81,
  0xF3, 0xF0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x3E, 0x07, 0xFD, 0xF0, 0x7F, 0xFF,
  0x07, 0xE3, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xFD,
  0xF0, 0x3F, 0xCF, 0x80, 0xF8, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0x7B,
  0xF0, 0x0F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x08, 0x1F, 0x03, 0xE3, 0xF0, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0xF0, 0x3F, 0xDF, 0x0F, 0xFF, 0xF0, 0xF8, 0x7F, 0x1F, 0x07, 0xE3, 0xF0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7,
  0xE3, 0xF8, 0x3F, 0xFF, 0x83, 0xFE, 0xF8, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x1F, 0x3F,
  0xC3, 0xEF, 0xFC, 0x7F, 0xFF, 0x9F, 0xE3, 0xF3, 0xF0, 0x3E, 0x7E, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0x9F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x00, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x3C, 0x78, 0x3D, 0xF3, 0xF0, 0xEF, 0xDF, 0xC3, 0xEF, 0xCF,
  0x1F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E,
  0x3C, 0x7C, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x78,
  0x78, 0xF1, 0xE1, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0xF0, 0xF1,
  0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x00, 0x1F, 0x0F, 0x83, 0xE7, 0xF8, 0x7D,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFC, 0x7E, 0x7E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F,
  0xC3, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xEF, 0xC0, 0x7D, 0xF8,
  0x1F, 0x9F, 0x03, 0xE3, 0xF0, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x3E, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xE3,
  0xF0, 0x7E, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0x87, 0xF0, 0xF8, 0x3E, 0xFF, 0xC1, 0xF7,
  0xFC, 0x0F, 0x8F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF1, 0xF0, 0x7F, 0x9F, 0x0F, 0xFF, 0xE1, 0xF8, 0xFE, 0x1F, 0x07, 0xE3,
  0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F,
  0x87, 0xE3, 0xF8, 0x7F, 0xEF, 0x83, 0xFD, 0xF0, 0x1F, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x1F, 0xCF, 0x9F, 0xF3, 0xEF, 0xF8, 0xFB,
  0xFE, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C,
  0x04, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x30, 0x0F, 0xBE, 0x01, 0xE7, 0xE0,
  0x7C, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8,
  0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xE0,
  0x7C, 0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x81,
  0xF1, 0xF0, 0x7E, 0x3F, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0xDF, 0x0F, 0xF3,
  0xC0, 0xF8, 0x78, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1,
  0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x01,
  0xE7, 0xC0, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x78, 0xF3, 0xC7, 0xC7,
  0x9E, 0x3E, 0x38, 0xF3, 0xF3, 0xC7, 0x9F, 0x9E, 0x39, 0xDC, 0xE1, 0xCE,
  0xEF, 0x0E, 0xE7, 0x78, 0x77, 0x3B, 0x83, 0xF1, 0xFC, 0x1F, 0x87, 0xE0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0xC0, 0x7E, 0x0F,
  0x80, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xC3,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC1, 0xF0,
  0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0,
  0x03, 0xE7, 0x80, 0x03, 0xEF, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x2F, 0xFE, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEC, 0x1F, 0xFD, 0x00, 0x7E, 0x00,
};

const GFXglyph LiberationMono_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 24, 22, 6, -24 },
  { 31, 14, 11, 22, 6, -26 },
  { 51, 22, 24, 22, 0, -24 },
  { 117, 20, 29, 22, 1, -26 },
  { 190, 24, 24, 22, -1, -24 },
  { 262, 20, 24, 22, 0, -24 },
  { 322, 6, 11, 22, 10, -26 },
  { 331, 14, 33, 22, 5, -26 },
  { 389, 14, 33, 22, 2, -26 },
  { 447, 14, 13, 22, 6, -26 },
  { 470, 18, 18, 22, 2, -21 },
  { 511, 11, 12, 22, 1, -5 },
  { 528, 11, 4, 22, 5, -11 },
  { 534, 7, 5, 22, 6, -5 },
  { 539, 23, 26, 22, 0, -26 },
  { 614, 19, 24, 22, 2, -24 },
  { 671, 18, 24, 22, 1, -24 },
  { 725, 21, 24, 22, 0, -24 },
  { 788, 20, 24, 22, 1, -24 },
  { 848, 20, 24, 22, 0, -24 },
  { 908, 20, 24, 22, 1, -24 },
  { 968, 19, 24, 22, 2, -24 },
  { 1025, 18, 24, 22, 4, -24 },
  { 1079, 20, 24, 22, 1, -24 },
  { 1139, 18, 24, 22, 2, -24 },
  { 1193, 9, 19, 22, 6, -19 },
  { 1215, 12, 26, 22, 3, -19 },
  { 1254, 18, 19, 22, 2, -21 },
  { 1297, 18, 14, 22, 2, -19 },
  { 1329, 18, 19, 22, 2, -21 },
  { 1372, 18, 24, 22, 3, -24 },
  { 1426, 22, 31, 22, 0, -26 },
  { 1512, 22, 24, 22, -2, -24 },
  { 1578, 20, 24, 22, 1, -24 },
  { 1638, 21, 24, 22, 1, -24 },
  { 1701, 20, 24, 22, 1, -24 },
  { 1761, 21, 24, 22, 1, -24 },
  { 1824, 21, 24, 22, 1, -24 },
  { 1887, 20, 24, 22, 1, -24 },
  { 1947, 21, 24, 22, 1, -24 },
  { 2010, 21, 24, 22, 1, -24 },
  { 2073, 20, 24, 22, 1, -24 },
  { 2133, 23, 24, 22, 1, -24 },
  { 2202, 17, 24, 22, 2, -24 },
  { 2253, 23, 24, 22, 0, -24 },
  { 2322, 21, 24, 22, 1, -24 },
  { 2385, 20, 24, 22, 1, -24 },
  { 2445, 21, 24, 22, 1, -24 },
  { 2508, 20, 31, 22, 1, -24 },
  { 2586, 21, 24, 22, 1, -24 },
  { 2649, 21, 24, 22, 0, -24 },
  { 2712, 20, 24, 22, 3, -24 },
  { 2772, 20, 24, 22, 2, -24 },
  { 2832, 21, 24, 22, 3, -24 },
  { 2895, 22, 24, 22, 2, -24 },
  { 2961, 26, 24, 22, -2, -24 },
  { 3039, 21, 24, 22, 3, -24 },
  { 3102, 22, 24, 22, 0, -24 },
  { 3168, 17, 33, 22, 3, -26 },
  { 3239, 13, 26, 22, 5, -26 },
  { 3282, 17, 33, 22, 1, -26 },
  { 3353, 19, 16, 22, 1, -25 },
  { 3391, 22, 2, 22, -3, 2 },
  { 3397, 8, 5, 22, 9, -26 },
  { 3402, 18, 19, 22, 1, -19 },
  { 3445, 19, 26, 22, 1, -26 },
  { 3507, 18, 19, 22, 2, -19 },
  { 3550, 21, 26, 22, 1, -26 },
  { 3619, 19, 19, 22, 1, -19 },
  { 3665, 20, 26, 22, 3, -26 },
  { 3730, 20, 26, 22, 1, -19 },
  { 3795, 19, 26, 22, 1, -26 },
  { 3857, 19, 26, 22, 0, -26 },
  { 3919, 19, 33, 22, -1, -26 },
  { 3998, 21, 26, 22, 1, -26 },
  { 4067, 19, 26, 22, 0, -26 },
  { 4129, 22, 19, 22, -1, -19 },
  { 4182, 19, 19, 22, 1, -19 },
  { 4228, 19, 19, 22, 1, -19 },
  { 4274, 21, 26, 22, -1, -19 },
  { 4343, 20, 26, 22, 1, -19 },
  { 4408, 18, 19, 22, 3, -19 },
  { 4451, 19, 19, 22, 1, -19 },
  { 4497, 15, 24, 22, 4, -24 },
  { 4542, 19, 19, 22, 2, -19 },
  { 4588, 21, 19, 22, 2, -19 },
  { 4638, 21, 19, 22, 2, -19 },
  { 4688, 23, 19, 22, -1, -19 },
  { 4743, 24, 26, 22, -1, -19 },
  { 4821, 19, 19, 22, 1, -19 },
  { 4867, 19, 33, 22, 3, -26 },
  { 4946, 5, 34, 22, 8, -26 },
  { 4968, 19, 33, 22, 0, -26 },
  { 5047, 19, 6, 22, 2, -15 },
};

const GFXfont LiberationMono_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic36pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _LIBERATIONMONO_BOLDITALIC36PT7B_H_
