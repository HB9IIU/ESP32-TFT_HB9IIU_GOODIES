#ifndef _LIBERATIONMONO_BOLDITALIC23PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8E, 0x31, 0xC0, 0x00, 0x73, 0xCE,
  0x00, 0x73, 0xB9, 0xD8, 0xDC, 0xEE, 0x77, 0x3B, 0x18, 0x01, 0x08, 0x0C,
  0x60, 0x21, 0x81, 0x8C, 0x3F, 0xFC, 0xFF, 0xF0, 0xC6, 0x02, 0x18, 0x18,
  0xC1, 0xFF, 0xCF, 0xFF, 0x0C, 0x60, 0x21, 0x81, 0x8C, 0x04, 0x30, 0x00,
  0x00, 0xC0, 0x02, 0x00, 0x7F, 0x03, 0xFE, 0x1C, 0xB8, 0xE6, 0x73, 0x90,
  0x0F, 0x40, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x9E, 0x62, 0x39, 0xC9,
  0xC7, 0x27, 0x1F, 0xF8, 0x1F, 0x80, 0x10, 0x00, 0x40, 0x00, 0x0F, 0x06,
  0x1F, 0x06, 0x39, 0x8C, 0x31, 0x98, 0x33, 0x30, 0x33, 0x60, 0x3F, 0xC0,
  0x1D, 0xBC, 0x03, 0x7C, 0x06, 0xEC, 0x06, 0xCC, 0x0C, 0xCC, 0x18, 0xCC,
  0x30, 0xF8, 0x60, 0x70, 0x03, 0xE0, 0x3F, 0x83, 0x9C, 0x18, 0xE0, 0xCE,
  0x07, 0xE0, 0x3C, 0x07, 0xC7, 0x77, 0x37, 0x3B, 0xB8, 0xF9, 0xC7, 0x8E,
  0x3E, 0x7F, 0xFD, 0xF9, 0xE0, 0x73, 0x9C, 0xE6, 0x31, 0x80, 0x03, 0x83,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x07, 0x03, 0x83, 0x80,
  0x0C, 0x06, 0x17, 0x5F, 0xEF, 0xF1, 0xE1, 0xF9, 0xDC, 0x44, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x1C, 0x38, 0xE1, 0x87, 0x0C, 0x30, 0x00,
  0x7F, 0xFC, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x07, 0xC1, 0xFE, 0x1C, 0x73, 0x87, 0x78, 0x77, 0x07, 0x77, 0x77, 0x67,
  0xF6, 0xFE, 0x0E, 0xE0, 0xEE, 0x1C, 0x71, 0xC7, 0xF8, 0x3E, 0x00, 0x00,
  0xE0, 0x1E, 0x07, 0xC1, 0xFC, 0x39, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x87, 0xFF, 0x7F, 0xF0, 0x03, 0xE0,
  0x7F, 0xC7, 0x8E, 0x38, 0x73, 0xC3, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x07,
  0xE1, 0xFF, 0x3C, 0x73, 0x87, 0x00, 0x70, 0x0E, 0x07, 0xC0, 0xFC, 0x01,
  0xE0, 0x0E, 0x60, 0xEE, 0x0E, 0xF1, 0xCF, 0xFC, 0x3F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x7C, 0x07, 0xE0, 0x77, 0x07, 0x38, 0x73, 0x87, 0x1C, 0x70,
  0xE3, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F,
  0xF1, 0xFF, 0x38, 0x03, 0x80, 0x38, 0x07, 0xFC, 0x7F, 0xE7, 0x0E, 0x00,
  0xF0, 0x0E, 0x00, 0xEE, 0x0E, 0xF1, 0xC7, 0xF8, 0x3E, 0x00, 0x07, 0xE0,
  0xFF, 0x1C, 0x73, 0x87, 0x30, 0x07, 0x7C, 0x7F, 0xE7, 0x8E, 0x70, 0xEF,
  0x0E, 0xE0, 0xE7, 0x0E, 0x71, 0xC7, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xE1, 0xFF, 0x3C, 0x73, 0x87,
  0x38, 0x73, 0x8E, 0x1F, 0xC3, 0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xF1, 0xCF, 0xFC, 0x3F, 0x00, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70,
  0x77, 0x07, 0x70, 0xF7, 0x8F, 0x3F, 0xE1, 0xEE, 0x00, 0xEE, 0x1C, 0xF3,
  0xC7, 0xF8, 0x3E, 0x00, 0x3C, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x3C, 0xE0, 0x0F, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x3C, 0x38, 0x70, 0x60, 0xE0, 0xC0, 0x00, 0x30, 0x0F, 0x07, 0xF1,
  0xFC, 0xFE, 0x0F, 0x80, 0xC0, 0x0F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x70, 0x1F, 0x07, 0xE3, 0xF8, 0xFC, 0x0F, 0x00, 0x80, 0x00, 0x0F,
  0xC3, 0xFE, 0x78, 0xEF, 0x0F, 0xE0, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0x01, 0xF0,
  0x18, 0x60, 0xC0, 0x86, 0x03, 0x11, 0xDC, 0xC9, 0xD2, 0x46, 0x5B, 0x1B,
  0x6C, 0x6D, 0x61, 0x35, 0x8C, 0xB6, 0x32, 0xD8, 0x9B, 0x66, 0x4D, 0xAA,
  0x37, 0x30, 0xC0, 0x01, 0x81, 0x06, 0x18, 0x07, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0x70, 0x1D, 0xC0, 0xE3, 0x03, 0x8E, 0x1C,
  0x38, 0x7F, 0xE3, 0xFF, 0x8E, 0x0E, 0x70, 0x39, 0xC0, 0xEE, 0x03, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x38, 0xF1, 0xE3, 0xFE,
  0x0F, 0xFC, 0x38, 0x79, 0xE0, 0xE7, 0x83, 0x9C, 0x1E, 0x70, 0x71, 0xFF,
  0x8F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0xF7, 0x03, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x1D, 0xE1, 0xCF, 0x1C,
  0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x87, 0x1E, 0x38, 0x73, 0xC3,
  0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0xC3, 0xDE, 0x1C, 0xE1, 0xE7,
  0x1E, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xCE,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0xFC, 0x7F, 0xE3, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xC1, 0xFE,
  0x3C, 0x73, 0x87, 0x70, 0x67, 0x00, 0xF0, 0x0F, 0x3F, 0xE3, 0xFE, 0x07,
  0xE0, 0xEF, 0x0E, 0xF1, 0xE7, 0xFC, 0x3F, 0x00, 0x1E, 0x1C, 0x70, 0xF1,
  0xC3, 0xC7, 0x0E, 0x3C, 0x38, 0xF0, 0xE3, 0xFF, 0x8F, 0xFE, 0x38, 0x71,
  0xE1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xF1, 0xC3, 0x8F, 0x0E, 0x00, 0x3F,
  0xF9, 0xFF, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xE3, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0xE1, 0xCE, 0x3C, 0xF3, 0x87, 0xF0, 0x3E, 0x00, 0x1C,
  0x1E, 0x38, 0x78, 0x71, 0xE0, 0xE7, 0x83, 0xDE, 0x07, 0x78, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0xFB, 0x81, 0xE7, 0x83, 0x8F, 0x07, 0x0F, 0x0E,
  0x1E, 0x3C, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xFF, 0xFF,
  0xF8, 0x1E, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x9F, 0x36, 0x7C, 0xDB, 0x63,
  0x6D, 0x9D, 0xEE, 0x77, 0xB9, 0x9C, 0xE6, 0x73, 0x18, 0x0C, 0xE0, 0x33,
  0x81, 0xCE, 0x07, 0x00, 0x1E, 0x1C, 0x78, 0x71, 0xF1, 0xC7, 0xCE, 0x3F,
  0x38, 0xFC, 0xE3, 0xB3, 0x8E, 0xCE, 0x33, 0xB1, 0xCF, 0xC7, 0x3F, 0x1C,
  0x7C, 0x71, 0xF1, 0xC7, 0x8E, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0x1C,
  0x70, 0xE7, 0x07, 0xB8, 0x3F, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0xB8,
  0x39, 0xC1, 0xCF, 0x1C, 0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xE1,
  0xC3, 0xC7, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x87, 0x8F, 0xFC, 0x3F, 0xC1,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0xE7, 0x07, 0xB8, 0x3F, 0xC1, 0xDC, 0x0E,
  0xE0, 0x77, 0x07, 0xB8, 0x39, 0xC1, 0xCF, 0x1C, 0x3F, 0xC0, 0xFC, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0xF0, 0x7F, 0xE1,
  0xC3, 0xC7, 0x07, 0x3C, 0x1C, 0xF0, 0xE3, 0x87, 0x8F, 0xFC, 0x3F, 0xC1,
  0xE7, 0x07, 0x9E, 0x1C, 0x38, 0x70, 0xF1, 0xC3, 0xCF, 0x07, 0x00, 0x03,
  0xF0, 0x3F, 0xE1, 0xC3, 0x8F, 0x0F, 0x38, 0x00, 0xF0, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x01, 0xE6, 0x03, 0xBC, 0x1C, 0xF0, 0xF1, 0xFF, 0x81,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xE7, 0x87, 0x38,
  0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xE7, 0x87, 0x3C, 0x39, 0xE3, 0x8F, 0x1C,
  0x3F, 0xC0, 0xF8, 0x00, 0xE0, 0x3B, 0x81, 0xEF, 0x07, 0x3C, 0x3C, 0xF0,
  0xE1, 0xC7, 0x87, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x07, 0x70, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0x00, 0xC6, 0x33, 0x8C, 0xE7, 0x19, 0xCC, 0x77, 0xB8, 0xEF, 0x71,
  0xF6, 0xC3, 0xEF, 0x87, 0xDE, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xE0, 0x00,
  0x1E, 0x0F, 0x0E, 0x1E, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1C, 0x70,
  0x38, 0x70, 0x78, 0x38, 0xF0, 0x38, 0xE0, 0x3B, 0xC1, 0xC7, 0x0F, 0x1C,
  0x78, 0x39, 0xC0, 0xEE, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x0F, 0xE1, 0xFC, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0xE1, 0xFC, 0x00, 0xE0, 0x30, 0x1C, 0x0E, 0x03,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C,
  0x0E, 0x03, 0x00, 0x0F, 0xE1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0C, 0xC0, 0xC7, 0x0E, 0x38, 0x61, 0xC7, 0x06, 0x70,
  0x3B, 0x01, 0xC0, 0xFF, 0xFC, 0xE3, 0x8E, 0x0F, 0xC3, 0xFC, 0xE3, 0xBC,
  0x70, 0x0E, 0x3F, 0xDF, 0xFF, 0x8E, 0xE1, 0xDC, 0x7B, 0x8F, 0x7E, 0xF7,
  0x9E, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xDE, 0x0F, 0xF8, 0xF9,
  0xE7, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xE7, 0x87, 0x3C, 0x79,
  0xE3, 0x8F, 0xF8, 0x77, 0x80, 0x07, 0xC1, 0xFE, 0x38, 0xF7, 0x87, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xF1, 0xC7, 0xF8, 0x3E,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0xF7, 0x1F, 0xF8, 0xE3,
  0xCE, 0x1E, 0x70, 0xF7, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xF3,
  0xCF, 0x1F, 0xF8, 0x79, 0xC0, 0x07, 0xC1, 0xFE, 0x38, 0xE7, 0x07, 0x70,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x08, 0xF1, 0xC7, 0xF8, 0x3F,
  0x00, 0x03, 0xF8, 0x7F, 0x83, 0x80, 0x3C, 0x0F, 0xFE, 0x7F, 0xF0, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x9C, 0x3F, 0xE1, 0xC7, 0x8F, 0x1E,
  0x38, 0x38, 0xE1, 0xE7, 0x87, 0x1E, 0x1C, 0x78, 0x71, 0xE3, 0xC7, 0x8F,
  0x0F, 0xFC, 0x1E, 0xE0, 0x03, 0x8F, 0x0E, 0x1C, 0x70, 0x7F, 0x80, 0xFC,
  0x00, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xCF, 0x0F, 0xFC, 0xE9,
  0xE7, 0x87, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0xF0, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0xCE, 0x1C, 0x70, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0xC1, 0xFC, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x07, 0xF0, 0x7E, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x87, 0x9C, 0x78, 0xE7, 0x87, 0x78, 0x77, 0x83, 0xF8, 0x1F,
  0xC0, 0xFF, 0x07, 0x38, 0x79, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xE0, 0x0F,
  0xE0, 0xFE, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x0F, 0xFF, 0xFF,
  0xF0, 0x37, 0x38, 0xFF, 0xF3, 0xB9, 0xDC, 0xE7, 0x73, 0x99, 0xCC, 0x66,
  0x33, 0x99, 0xCE, 0xE7, 0x3B, 0x9C, 0xCE, 0x63, 0x39, 0x9C, 0xC6, 0x70,
  0x1C, 0xF1, 0xFF, 0xCE, 0x9E, 0x78, 0x73, 0x83, 0x9C, 0x3C, 0xE1, 0xCF,
  0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x00, 0x0F, 0xC1,
  0xFE, 0x38, 0xF7, 0x07, 0x70, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE,
  0x0E, 0xF1, 0xC7, 0xF8, 0x3E, 0x00, 0x1D, 0xE0, 0xFF, 0x8F, 0x9E, 0x78,
  0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xEF, 0x0E, 0x78, 0x73, 0xC7, 0x9E, 0x38,
  0xFF, 0x87, 0x78, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x0F, 0x73, 0xFF, 0x38, 0xF7, 0x0F, 0x70, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x79, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x71, 0xEF, 0xFD, 0xDF, 0xBF, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0F, 0xC1, 0xFE,
  0x38, 0x77, 0x04, 0x78, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xE6, 0x0E,
  0xE1, 0xCF, 0xFC, 0x3F, 0x00, 0x1C, 0x0C, 0x0E, 0x1F, 0xFF, 0xFB, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x83, 0xFC, 0xFE, 0x38,
  0x77, 0x87, 0x70, 0x77, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xEE, 0x0E, 0xE1,
  0xEE, 0x1E, 0xF3, 0xCF, 0xDC, 0x79, 0xC0, 0xE0, 0x77, 0x03, 0xB8, 0x39,
  0xC1, 0xCE, 0x1C, 0x78, 0xE1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0xB0, 0x1F,
  0x80, 0xF8, 0x03, 0xC0, 0x00, 0xE0, 0x1F, 0x80, 0x6E, 0x01, 0xB9, 0xCE,
  0xE7, 0x33, 0xBC, 0xCE, 0xF7, 0x36, 0xD8, 0xDB, 0x63, 0xCF, 0x8F, 0x3C,
  0x38, 0xF0, 0xE1, 0xC0, 0x1E, 0x1E, 0x1C, 0x38, 0x38, 0xE0, 0x3B, 0x80,
  0x7E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x0E, 0xE0, 0x3D, 0xC0, 0x71,
  0xC1, 0xC3, 0x87, 0x07, 0x80, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1,
  0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x1B, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xCF, 0xFE,
  0x00, 0x03, 0xF0, 0x7E, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x80, 0x7F, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xF0,
  0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0xFE, 0x0F, 0xC0, 0x3C, 0x0F, 0xF1, 0xC7, 0xF0, 0x1E,
};

const GFXglyph LiberationMono_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 15, 14, 4, -15 },
  { 13, 9, 7, 14, 4, -17 },
  { 21, 14, 15, 14, 0, -15 },
  { 48, 14, 19, 14, 0, -17 },
  { 82, 16, 15, 14, -1, -15 },
  { 112, 13, 15, 14, 0, -15 },
  { 137, 5, 7, 14, 6, -17 },
  { 142, 9, 22, 14, 3, -17 },
  { 167, 9, 22, 14, 1, -17 },
  { 192, 9, 9, 14, 4, -17 },
  { 203, 12, 12, 14, 1, -14 },
  { 221, 7, 7, 14, 1, -3 },
  { 228, 7, 2, 14, 3, -7 },
  { 230, 4, 3, 14, 4, -3 },
  { 232, 15, 17, 14, 0, -17 },
  { 264, 12, 15, 14, 1, -15 },
  { 287, 12, 15, 14, 0, -15 },
  { 310, 13, 15, 14, 0, -15 },
  { 335, 12, 15, 14, 1, -15 },
  { 358, 13, 15, 14, 0, -15 },
  { 383, 12, 15, 14, 1, -15 },
  { 406, 12, 15, 14, 1, -15 },
  { 429, 11, 15, 14, 3, -15 },
  { 450, 12, 15, 14, 1, -15 },
  { 473, 12, 15, 14, 1, -15 },
  { 496, 6, 13, 14, 4, -13 },
  { 506, 8, 17, 14, 2, -13 },
  { 523, 12, 13, 14, 1, -14 },
  { 543, 12, 8, 14, 1, -12 },
  { 555, 12, 13, 14, 1, -14 },
  { 575, 12, 15, 14, 2, -15 },
  { 598, 14, 20, 14, 0, -17 },
  { 633, 14, 15, 14, -1, -15 },
  { 660, 14, 15, 14, 0, -15 },
  { 687, 13, 15, 14, 1, -15 },
  { 712, 13, 15, 14, 0, -15 },
  { 737, 14, 15, 14, 0, -15 },
  { 764, 13, 15, 14, 1, -15 },
  { 789, 12, 15, 14, 1, -15 },
  { 812, 14, 15, 14, 0, -15 },
  { 839, 13, 15, 14, 1, -15 },
  { 864, 12, 15, 14, 1, -15 },
  { 887, 15, 15, 14, 0, -15 },
  { 916, 11, 15, 14, 1, -15 },
  { 937, 14, 15, 14, 0, -15 },
  { 964, 14, 15, 14, 0, -15 },
  { 991, 13, 15, 14, 1, -15 },
  { 1016, 14, 15, 14, 0, -15 },
  { 1043, 13, 20, 14, 1, -15 },
  { 1076, 14, 15, 14, 0, -15 },
  { 1103, 14, 15, 14, 0, -15 },
  { 1130, 13, 15, 14, 2, -15 },
  { 1155, 13, 15, 14, 1, -15 },
  { 1180, 14, 15, 14, 2, -15 },
  { 1207, 15, 15, 14, 1, -15 },
  { 1236, 16, 15, 14, -1, -15 },
  { 1266, 14, 15, 14, 2, -15 },
  { 1293, 14, 15, 14, 0, -15 },
  { 1320, 11, 22, 14, 2, -17 },
  { 1351, 9, 17, 14, 3, -17 },
  { 1371, 11, 22, 14, 1, -17 },
  { 1402, 13, 10, 14, 0, -16 },
  { 1419, 14, 1, 14, -2, 1 },
  { 1421, 5, 3, 14, 6, -16 },
  { 1423, 11, 13, 14, 1, -13 },
  { 1441, 13, 17, 14, 0, -17 },
  { 1469, 12, 13, 14, 1, -13 },
  { 1489, 13, 17, 14, 1, -17 },
  { 1517, 12, 13, 14, 1, -13 },
  { 1537, 13, 17, 14, 2, -17 },
  { 1565, 14, 18, 14, 0, -13 },
  { 1597, 13, 17, 14, 0, -17 },
  { 1625, 12, 17, 14, 0, -17 },
  { 1651, 13, 22, 14, -1, -17 },
  { 1687, 13, 17, 14, 1, -17 },
  { 1715, 12, 17, 14, 0, -17 },
  { 1741, 14, 13, 14, 0, -13 },
  { 1764, 13, 13, 14, 0, -13 },
  { 1786, 12, 13, 14, 1, -13 },
  { 1806, 13, 18, 14, 0, -13 },
  { 1836, 12, 18, 14, 1, -13 },
  { 1863, 11, 13, 14, 2, -13 },
  { 1881, 12, 13, 14, 1, -13 },
  { 1901, 9, 16, 14, 3, -16 },
  { 1919, 12, 13, 14, 1, -13 },
  { 1939, 13, 13, 14, 2, -13 },
  { 1961, 14, 13, 14, 1, -13 },
  { 1984, 15, 13, 14, -1, -13 },
  { 2009, 15, 18, 14, 0, -13 },
  { 2043, 13, 13, 14, 0, -13 },
  { 2065, 12, 22, 14, 2, -17 },
  { 2098, 3, 22, 14, 5, -17 },
  { 2107, 12, 22, 14, 0, -17 },
  { 2140, 12, 4, 14, 1, -9 },
};

const GFXfont LiberationMono_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic23pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _LIBERATIONMONO_BOLDITALIC23PT7B_H_
