#ifndef _LIBERATIONMONO_BOLDITALIC14PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x26, 0x06, 0x60, 0x6D, 0x34, 0xB2, 0x09, 0x08, 0x9F,
  0xC2, 0x42, 0x41, 0x23, 0xFC, 0x90, 0x48, 0x00, 0x04, 0x1E, 0x3B, 0x6B,
  0x78, 0x3E, 0x0F, 0xCB, 0xD6, 0x7C, 0x10, 0x71, 0xAC, 0x94, 0x8E, 0x80,
  0x80, 0xB8, 0xB4, 0x92, 0x8E, 0x00, 0x1E, 0x12, 0x36, 0x3C, 0x73, 0xDA,
  0xCE, 0xCC, 0x7F, 0xFE, 0x18, 0xC3, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0x60, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0x8C, 0xCC, 0x00, 0x11,
  0x77, 0x9C, 0x50, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x00, 0x66, 0xC8,
  0xF0, 0x6C, 0x01, 0x81, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x60,
  0x60, 0x00, 0x3C, 0xCD, 0x1E, 0x3D, 0x78, 0xF3, 0x66, 0x70, 0x06, 0x38,
  0xB0, 0x60, 0xC1, 0x86, 0x0C, 0xFE, 0x1E, 0x33, 0x23, 0x02, 0x0E, 0x18,
  0x30, 0x60, 0xFE, 0x1E, 0x33, 0x63, 0x02, 0x1C, 0x06, 0xC2, 0x66, 0x7C,
  0x07, 0x0E, 0x1E, 0x16, 0x26, 0x46, 0xFF, 0x0C, 0x0C, 0x3F, 0x30, 0x30,
  0x7E, 0x67, 0x03, 0xC6, 0x66, 0x7C, 0x3C, 0xCD, 0x07, 0xEC, 0xD8, 0xF3,
  0x66, 0x78, 0xFC, 0x18, 0x61, 0x82, 0x0C, 0x30, 0x60, 0xC0, 0x1E, 0x33,
  0x33, 0x33, 0x1C, 0x66, 0x66, 0x66, 0x7C, 0x3C, 0xCF, 0x1E, 0x3C, 0xEF,
  0x83, 0x64, 0xF0, 0x33, 0x00, 0x06, 0x60, 0x18, 0xC0, 0x00, 0x19, 0x88,
  0xC0, 0x06, 0x7F, 0xC4, 0x0F, 0x07, 0xC1, 0x80, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x81, 0xE0, 0x78, 0x31, 0xFE, 0x20, 0x00, 0x3C, 0xCF, 0x18, 0x71,
  0x86, 0x00, 0x30, 0x60, 0x0F, 0x08, 0x88, 0x29, 0xD5, 0x2D, 0x2A, 0x95,
  0x54, 0xB6, 0x40, 0x31, 0x0F, 0x00, 0x07, 0x07, 0x82, 0xC3, 0x61, 0x31,
  0xF8, 0x84, 0xC2, 0x41, 0x80, 0x3F, 0x33, 0x33, 0x63, 0x7C, 0x63, 0x63,
  0x67, 0xFC, 0x3C, 0xCF, 0x1E, 0x0C, 0x18, 0x31, 0xE6, 0x78, 0x3E, 0x33,
  0x23, 0x63, 0x63, 0x63, 0x66, 0x66, 0xF8, 0x3F, 0x18, 0x0C, 0x0C, 0x07,
  0xE3, 0x01, 0x80, 0xC0, 0xFE, 0x00, 0x3F, 0x18, 0x0C, 0x06, 0x07, 0xF3,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x3C, 0xCF, 0x1E, 0x0D, 0xF8, 0xF1, 0x66,
  0x78, 0x33, 0x19, 0x8C, 0xCC, 0x67, 0xF3, 0x31, 0x98, 0xCC, 0xC6, 0x00,
  0x3F, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x7E, 0x0F, 0x03, 0x07,
  0x06, 0x06, 0x06, 0x66, 0x6C, 0x78, 0x33, 0x9B, 0x8B, 0x8F, 0x87, 0xC3,
  0xE1, 0xB8, 0xCC, 0xC6, 0x00, 0x61, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xFC,
  0x33, 0xB9, 0x9D, 0xCE, 0xA5, 0x72, 0xDB, 0x69, 0x84, 0xC2, 0x00, 0x31,
  0x1D, 0x8E, 0xCF, 0x66, 0xB3, 0x51, 0x38, 0x9C, 0xCE, 0x00, 0x1E, 0x33,
  0x63, 0x63, 0x63, 0x63, 0x66, 0x66, 0x3C, 0x3F, 0x33, 0x23, 0x63, 0x7E,
  0x60, 0x60, 0x40, 0xC0, 0x1E, 0x33, 0x63, 0x63, 0x63, 0x63, 0x66, 0x66,
  0x7C, 0x18, 0x18, 0x0E, 0x3F, 0x19, 0x88, 0xCC, 0x67, 0xC3, 0x61, 0x98,
  0x8C, 0xC6, 0x00, 0x1E, 0x33, 0x63, 0x78, 0x3E, 0x07, 0xC3, 0xC6, 0x7C,
  0xFF, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x66, 0x66, 0xC6,
  0xC6, 0xC6, 0xCC, 0xCC, 0xCC, 0xF8, 0xC3, 0xC3, 0xC6, 0x66, 0x6C, 0x68,
  0x78, 0x70, 0x70, 0xC1, 0xC3, 0xC3, 0xDA, 0xFE, 0xBC, 0xFC, 0xDC, 0xC8,
  0x18, 0xC6, 0x60, 0xF0, 0x38, 0x0E, 0x07, 0x83, 0x60, 0xCC, 0x63, 0x00,
  0xC3, 0x66, 0x6C, 0x6C, 0x38, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x01, 0x81,
  0x81, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xFE, 0x00, 0x1E, 0x20, 0xC1, 0x83,
  0x06, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x0F, 0x80, 0xC6, 0x10, 0xC6, 0x10,
  0xC2, 0x18, 0xC0, 0x1E, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x30,
  0x60, 0xC7, 0x80, 0x0C, 0x1E, 0x16, 0x22, 0x62, 0x43, 0xFF, 0x00, 0xCC,
  0x1E, 0x36, 0x06, 0x3E, 0x66, 0xCE, 0x76, 0x30, 0x30, 0x30, 0x3E, 0x73,
  0x63, 0x63, 0x66, 0x66, 0xDC, 0x3C, 0xCF, 0x06, 0x0C, 0x19, 0x9E, 0x00,
  0x03, 0x06, 0x06, 0x7E, 0xEE, 0xC6, 0xCC, 0xCC, 0xDC, 0xEC, 0x3C, 0xCF,
  0x1F, 0xFC, 0x19, 0x9E, 0x00, 0x0F, 0x18, 0x30, 0xFE, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x1F, 0x33, 0x63, 0x63, 0x66, 0x66, 0x7E, 0x06, 0xCC,
  0x78, 0x30, 0x30, 0x30, 0x3E, 0x73, 0x63, 0x63, 0x66, 0x66, 0xC6, 0x06,
  0x00, 0x01, 0xE0, 0xC1, 0x82, 0x0C, 0x19, 0xFC, 0x06, 0x00, 0x01, 0xF0,
  0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xCF, 0x00, 0x30, 0x18, 0x0C, 0x06,
  0x62, 0x63, 0x61, 0xF0, 0xD8, 0x66, 0x23, 0x00, 0x1E, 0x18, 0x30, 0x60,
  0xC1, 0x82, 0x0C, 0x19, 0xFC, 0x7B, 0x6D, 0x49, 0x5B, 0xDB, 0xDA, 0x92,
  0x2E, 0x73, 0x63, 0x63, 0x66, 0x46, 0xC6, 0x3C, 0x8F, 0x1E, 0x3C, 0xD9,
  0xBE, 0x00, 0x2E, 0x73, 0x63, 0x63, 0x66, 0x66, 0xDC, 0xC0, 0xC0, 0xC0,
  0x7F, 0xDF, 0x1E, 0x6C, 0xDB, 0xBB, 0x06, 0x18, 0x30, 0x6E, 0xE1, 0x83,
  0x04, 0x18, 0x30, 0x00, 0x1E, 0x23, 0x70, 0x3E, 0x06, 0x46, 0x7C, 0x21,
  0x8F, 0x98, 0xC3, 0x0C, 0x30, 0xF0, 0x47, 0x8F, 0x1E, 0x6C, 0xDB, 0xBB,
  0x00, 0xC3, 0xC6, 0xCC, 0x4C, 0x78, 0x70, 0x70, 0x83, 0x82, 0x92, 0xB6,
  0xFC, 0xDC, 0xCC, 0x73, 0x1B, 0x07, 0x03, 0x03, 0xC3, 0x73, 0x18, 0x61,
  0xB1, 0x89, 0x86, 0xC3, 0xC1, 0xC0, 0x60, 0x60, 0x30, 0x70, 0x00, 0x3F,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0x0E, 0x30, 0x41, 0x83, 0x06, 0x30,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x18,
  0x30, 0x60, 0xC1, 0x81, 0x86, 0x18, 0x30, 0x60, 0x8F, 0x00, 0xF0, 0x3C,
};

const GFXglyph LiberationMono_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 6, 4, 8, 2, -10 },
  { 9, 9, 9, 8, 0, -9 },
  { 20, 8, 11, 8, 0, -10 },
  { 31, 9, 9, 8, 0, -9 },
  { 42, 8, 9, 8, 0, -9 },
  { 51, 2, 4, 8, 4, -10 },
  { 52, 6, 13, 8, 2, -10 },
  { 62, 5, 13, 8, 1, -10 },
  { 71, 6, 5, 8, 2, -10 },
  { 75, 7, 7, 8, 1, -8 },
  { 82, 4, 4, 8, 1, -2 },
  { 84, 4, 1, 8, 2, -4 },
  { 85, 3, 2, 8, 2, -2 },
  { 86, 9, 10, 8, 0, -10 },
  { 98, 7, 9, 8, 1, -9 },
  { 106, 7, 9, 8, 0, -9 },
  { 114, 8, 9, 8, 0, -9 },
  { 123, 8, 9, 8, 0, -9 },
  { 132, 8, 9, 8, 0, -9 },
  { 141, 8, 9, 8, 0, -9 },
  { 150, 7, 9, 8, 1, -9 },
  { 158, 7, 9, 8, 2, -9 },
  { 166, 8, 9, 8, 0, -9 },
  { 175, 7, 9, 8, 1, -9 },
  { 183, 4, 7, 8, 2, -7 },
  { 187, 5, 9, 8, 1, -7 },
  { 193, 7, 7, 8, 1, -8 },
  { 200, 7, 5, 8, 1, -7 },
  { 205, 7, 7, 8, 1, -8 },
  { 212, 7, 9, 8, 1, -9 },
  { 220, 9, 12, 8, 0, -10 },
  { 234, 9, 9, 8, -1, -9 },
  { 245, 8, 9, 8, 0, -9 },
  { 254, 7, 9, 8, 1, -9 },
  { 262, 8, 9, 8, 0, -9 },
  { 271, 9, 9, 8, 0, -9 },
  { 282, 9, 9, 8, 0, -9 },
  { 293, 7, 9, 8, 1, -9 },
  { 301, 9, 9, 8, 0, -9 },
  { 312, 8, 9, 8, 0, -9 },
  { 321, 8, 9, 8, 0, -9 },
  { 330, 9, 9, 8, 0, -9 },
  { 341, 6, 9, 8, 1, -9 },
  { 348, 9, 9, 8, 0, -9 },
  { 359, 9, 9, 8, 0, -9 },
  { 370, 8, 9, 8, 0, -9 },
  { 379, 8, 9, 8, 0, -9 },
  { 388, 8, 12, 8, 0, -9 },
  { 400, 9, 9, 8, 0, -9 },
  { 411, 8, 9, 8, 0, -9 },
  { 420, 8, 9, 8, 1, -9 },
  { 429, 8, 9, 8, 1, -9 },
  { 438, 8, 9, 8, 1, -9 },
  { 447, 8, 9, 8, 1, -9 },
  { 456, 10, 9, 8, -1, -9 },
  { 468, 8, 9, 8, 1, -9 },
  { 477, 9, 9, 8, 0, -9 },
  { 488, 7, 13, 8, 1, -10 },
  { 500, 5, 10, 8, 2, -10 },
  { 507, 7, 13, 8, 0, -10 },
  { 519, 8, 6, 8, 0, -10 },
  { 525, 9, 1, 8, -1, 1 },
  { 527, 3, 2, 8, 4, -10 },
  { 528, 8, 7, 8, 0, -7 },
  { 535, 8, 10, 8, 0, -10 },
  { 545, 7, 7, 8, 1, -7 },
  { 552, 8, 10, 8, 1, -10 },
  { 562, 7, 7, 8, 1, -7 },
  { 569, 8, 10, 8, 1, -10 },
  { 579, 8, 10, 8, 0, -7 },
  { 589, 8, 10, 8, 0, -10 },
  { 599, 7, 10, 8, 0, -10 },
  { 608, 7, 13, 8, 0, -10 },
  { 620, 9, 10, 8, 0, -10 },
  { 632, 7, 10, 8, 0, -10 },
  { 641, 8, 7, 8, 0, -7 },
  { 648, 8, 7, 8, 0, -7 },
  { 655, 7, 7, 8, 1, -7 },
  { 662, 8, 10, 8, 0, -7 },
  { 672, 7, 10, 8, 1, -7 },
  { 681, 7, 7, 8, 1, -7 },
  { 688, 8, 7, 8, 0, -7 },
  { 695, 6, 9, 8, 2, -9 },
  { 702, 7, 7, 8, 1, -7 },
  { 709, 8, 7, 8, 1, -7 },
  { 716, 8, 7, 8, 1, -7 },
  { 723, 9, 7, 8, 0, -7 },
  { 731, 9, 10, 8, 0, -7 },
  { 743, 8, 7, 8, 0, -7 },
  { 750, 7, 13, 8, 1, -10 },
  { 762, 2, 13, 8, 3, -10 },
  { 766, 7, 13, 8, 0, -10 },
  { 778, 7, 2, 8, 1, -6 },
};

const GFXfont LiberationMono_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic14pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _LIBERATIONMONO_BOLDITALIC14PT7B_H_
