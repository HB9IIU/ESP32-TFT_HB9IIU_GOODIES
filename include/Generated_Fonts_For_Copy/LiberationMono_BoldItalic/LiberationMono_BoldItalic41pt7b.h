#ifndef _LIBERATIONMONO_BOLDITALIC41PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0x83, 0xF0, 0x00, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0,
  0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC0, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0xE0, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xE3, 0x7F, 0x0F, 0x8E, 0x7E, 0x3F, 0x18, 0x7C, 0x7C,
  0x30, 0xC0, 0xF8, 0x60, 0x01, 0xF8, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0x8F, 0xE0, 0x03, 0x0F, 0xC1, 0x06, 0x1F, 0xBE, 0x0C, 0x3E,
  0x7C, 0x38, 0x7C, 0xFC, 0x61, 0xF9, 0xFC, 0xC7, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x3F, 0xC0, 0x1C,
  0x07, 0xFC, 0x03, 0x80, 0xF1, 0xE0, 0x78, 0x0E, 0x1E, 0x0F, 0x01, 0xE1,
  0xE1, 0xE0, 0x1E, 0x1C, 0x3C, 0x01, 0xC1, 0xC7, 0x80, 0x1C, 0x3C, 0xF0,
  0x01, 0xC3, 0xCE, 0x00, 0x1E, 0x79, 0xC0, 0x01, 0xFF, 0xB8, 0x00, 0x0F,
  0xF7, 0x80, 0x00, 0x7C, 0xF3, 0xE0, 0x00, 0x1E, 0xFF, 0x00, 0x03, 0xDF,
  0xF8, 0x00, 0x7B, 0xC7, 0x80, 0x07, 0x3C, 0x78, 0x00, 0xE3, 0x87, 0x80,
  0x1C, 0x78, 0x78, 0x03, 0x87, 0x87, 0x80, 0x78, 0x78, 0x70, 0x0F, 0x07,
  0x8F, 0x01, 0xE0, 0x78, 0xF0, 0x3C, 0x07, 0xFE, 0x07, 0x80, 0x3F, 0xC0,
  0x70, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xDF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xE1, 0xFF, 0x07, 0xC7, 0xFE, 0x0F, 0x1F,
  0x3E, 0x3E, 0x7C, 0x7C, 0x79, 0xF0, 0x7D, 0xF3, 0xE0, 0xFB, 0xC7, 0xC0,
  0xFF, 0x0F, 0x81, 0xFE, 0x1F, 0x01, 0xF8, 0x3F, 0x07, 0xF8, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xF1, 0xFC, 0x7F, 0x80, 0xF0, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x17, 0x3C, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3, 0xE7, 0x8F, 0x8F, 0x8E,
  0x1E, 0x08, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xDF, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFE, 0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0xF3, 0xF7, 0xE7, 0x9F, 0xBF,
  0x3C, 0xFD, 0xF1, 0xE7, 0xFF, 0x9F, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8,
  0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBE, 0x03, 0xF3, 0xF0, 0x1C, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xE1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7E, 0x1F,
  0xC1, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xBF, 0x00, 0x1F,
  0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x0F,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x01, 0xF8,
  0x3C, 0x03, 0xF0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x3F,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC3, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x1F, 0x81, 0xFB, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF3, 0xFC, 0x3F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xC0,
  0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0xFC, 0x7E, 0x07, 0xE3,
  0xF8, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F,
  0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFC, 0x3F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF3, 0xF0,
  0x3F, 0x9F, 0xC3, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xF9, 0xF0,
  0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x7C, 0x7E, 0x07,
  0xE3, 0xF8, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xC1,
  0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x07, 0x9F,
  0x87, 0x0F, 0xDD, 0xC3, 0x8F, 0xFE, 0xE3, 0x8F, 0x1E, 0x71, 0xCF, 0x0F,
  0x39, 0xC7, 0x07, 0x9C, 0xE7, 0x83, 0x8E, 0x73, 0x81, 0xC6, 0x73, 0xC1,
  0xC3, 0x39, 0xC0, 0xE3, 0x9C, 0xE0, 0x71, 0xCE, 0xF0, 0x70, 0xC6, 0x70,
  0x38, 0xE7, 0x38, 0x3C, 0x73, 0x9C, 0x1C, 0x71, 0xCE, 0x1E, 0x38, 0xE7,
  0x1B, 0x38, 0x73, 0xFD, 0xF8, 0x38, 0xFC, 0xF8, 0x1C, 0x38, 0x78, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x01, 0x00, 0xF0, 0x03, 0x80,
  0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0xFE,
  0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC,
  0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x00, 0x70, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0xE1, 0xFC, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8, 0x7F, 0x83, 0xF0, 0x3F, 0x8F, 0xC0,
  0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87,
  0xE0, 0x7F, 0x0F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x87, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0xFB, 0xF0, 0xFF, 0xEF, 0xC3, 0xFF, 0xBF, 0x0F, 0xFE, 0xFC, 0x01,
  0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFE, 0x03, 0xF3,
  0xFC, 0x3F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E,
  0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0xE3, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0,
  0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE,
  0x00, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xBF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0x7F, 0x83, 0xDC, 0x1F, 0xE0, 0xF7, 0x8F,
  0xF8, 0x3D, 0xE3, 0xBC, 0x1F, 0x79, 0xEF, 0x07, 0xDE, 0x7F, 0xC1, 0xF7,
  0xBD, 0xF0, 0x79, 0xEF, 0x7C, 0x1E, 0x7F, 0x9E, 0x0F, 0x9F, 0xE7, 0x83,
  0xE7, 0xF1, 0xE0, 0xF9, 0xFC, 0xF8, 0x3C, 0x7E, 0x3E, 0x0F, 0x1F, 0x8F,
  0x03, 0xC7, 0xE3, 0xC1, 0xF1, 0xF0, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3E,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x1F,
  0x0F, 0xF0, 0x3F, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0x78, 0x7C,
  0x1F, 0x7C, 0x7C, 0x1F, 0x7C, 0x7C, 0x3F, 0x7C, 0xFC, 0x3E, 0x7C, 0xF8,
  0x3E, 0x3C, 0xF8, 0x3E, 0x3C, 0xF8, 0x3E, 0x3E, 0xF8, 0x7E, 0x3E, 0xF8,
  0x7C, 0x3E, 0xF0, 0x7C, 0x3E, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0,
  0xFC, 0x1F, 0xF0, 0xF8, 0x1F, 0xE0, 0xF8, 0x1F, 0xE0, 0xF8, 0x0F, 0xE0,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0x0F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x3F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x81, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3C, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFE,
  0x00, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x7F,
  0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3F,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x3C, 0x3E, 0x1F, 0x1F, 0x0F, 0x07, 0xC7, 0xC7, 0xC1, 0xF3, 0xF1, 0xF0,
  0x7C, 0xFC, 0x78, 0x1E, 0x7F, 0xBE, 0x07, 0x9F, 0xEF, 0x81, 0xEF, 0x7B,
  0xC0, 0x7B, 0xDF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFE, 0x03, 0xFE,
  0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x3F,
  0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F,
  0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x1E, 0x00,
  0xF8, 0x78, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0,
  0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E,
  0x78, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xE0, 0xF8,
  0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC3, 0xF0, 0x3E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x9F,
  0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF7, 0xFC, 0x3F, 0x8F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x3E, 0x7F, 0xC0, 0xFB, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80,
  0x3F, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFC,
  0x7F, 0x07, 0xF1, 0xFE, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0x7F, 0xE0, 0xFC,
  0xFF, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x9F, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xF9, 0xF8, 0x3F, 0xFB, 0xE0, 0xFF,
  0xF7, 0xC3, 0xF8, 0x7F, 0x87, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01,
  0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x07, 0xF0,
  0xFC, 0x0F, 0xE1, 0xFC, 0x7F, 0x83, 0xFF, 0xDF, 0x03, 0xFF, 0x7E, 0x07,
  0xFC, 0xFC, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x80, 0xFD, 0xF8, 0x03,
  0xEF, 0xC0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xE7, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x03, 0xFE, 0x7C, 0x0F, 0xFD, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE3, 0xF0,
  0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF,
  0x81, 0xFF, 0x3E, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x3E, 0x3F,
  0xE1, 0xFB, 0xFF, 0x87, 0xEF, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0,
  0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x0F, 0x9E, 0x0F, 0x07, 0x9F, 0x9F, 0xC3, 0xDF, 0xDF, 0xE1, 0xFF, 0xEF,
  0xF0, 0xFC, 0xFC, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1F, 0x1F, 0x0F, 0x0F, 0x8F, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC7, 0xC3,
  0xE3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0x78, 0x78,
  0x7C, 0x3C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x8F,
  0x0F, 0x87, 0xC7, 0x87, 0xC3, 0xC7, 0xC3, 0xE1, 0xE0, 0x0F, 0x83, 0xE0,
  0x3E, 0x3F, 0xE1, 0xFB, 0xFF, 0x87, 0xEF, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F,
  0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F, 0x9F,
  0x80, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xE0,
  0x0F, 0xDF, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x03,
  0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x07,
  0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xE3, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x7F, 0xF0, 0x3F, 0x7F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x1F, 0xF3, 0xF0, 0xFF,
  0xEF, 0x87, 0xFF, 0xBE, 0x3F, 0x87, 0xF8, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F,
  0x9F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3F, 0x03,
  0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0xFF, 0x0F, 0xFF, 0x7C, 0x1F, 0xFF, 0xF0,
  0x7F, 0xCF, 0xC0, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0xFC, 0xFF,
  0xC7, 0xEF, 0xFC, 0x3F, 0x7F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0xFC, 0x01, 0xF1, 0xF8, 0x1F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x87, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE3,
  0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xFF, 0x7C, 0x3F, 0xFB,
  0xF0, 0x7F, 0xCF, 0xC0, 0xFC, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7E,
  0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x80,
  0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0xF8, 0x78, 0x3C, 0xF8, 0x78, 0x3C, 0xF0, 0xFC, 0x7C, 0xF0,
  0xFC, 0x78, 0xF1, 0xFC, 0x78, 0xF1, 0xFC, 0xF8, 0xF3, 0xFC, 0xF0, 0xF3,
  0x9C, 0xF0, 0xF7, 0x9D, 0xF0, 0xF7, 0x1D, 0xE0, 0xFF, 0x1D, 0xE0, 0xFE,
  0x1D, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE3, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x37, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
};

const GFXglyph LiberationMono_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 27, 25, 7, -27 },
  { 39, 16, 13, 25, 7, -30 },
  { 65, 25, 27, 25, 0, -27 },
  { 150, 23, 33, 25, 1, -30 },
  { 245, 28, 27, 25, -1, -27 },
  { 340, 23, 27, 25, 0, -27 },
  { 418, 8, 13, 25, 11, -30 },
  { 431, 16, 39, 25, 6, -30 },
  { 509, 16, 39, 25, 2, -30 },
  { 587, 15, 15, 25, 7, -30 },
  { 616, 21, 21, 25, 2, -24 },
  { 672, 12, 13, 25, 2, -6 },
  { 692, 13, 5, 25, 6, -13 },
  { 701, 7, 6, 25, 7, -6 },
  { 707, 26, 30, 25, 0, -30 },
  { 805, 21, 27, 25, 2, -27 },
  { 876, 21, 27, 25, 1, -27 },
  { 947, 24, 27, 25, 0, -27 },
  { 1028, 23, 27, 25, 1, -27 },
  { 1106, 23, 27, 25, 0, -27 },
  { 1184, 23, 27, 25, 1, -27 },
  { 1262, 21, 27, 25, 3, -27 },
  { 1333, 20, 27, 25, 5, -27 },
  { 1401, 23, 27, 25, 1, -27 },
  { 1479, 21, 27, 25, 2, -27 },
  { 1550, 10, 22, 25, 7, -22 },
  { 1578, 15, 29, 25, 3, -22 },
  { 1633, 21, 23, 25, 2, -25 },
  { 1694, 21, 16, 25, 2, -21 },
  { 1736, 21, 23, 25, 2, -25 },
  { 1797, 21, 27, 25, 3, -27 },
  { 1868, 25, 36, 25, 0, -30 },
  { 1981, 25, 27, 25, -2, -27 },
  { 2066, 23, 27, 25, 1, -27 },
  { 2144, 23, 27, 25, 2, -27 },
  { 2222, 23, 27, 25, 1, -27 },
  { 2300, 24, 27, 25, 1, -27 },
  { 2381, 24, 27, 25, 1, -27 },
  { 2462, 22, 27, 25, 2, -27 },
  { 2537, 24, 27, 25, 1, -27 },
  { 2618, 24, 27, 25, 1, -27 },
  { 2699, 23, 27, 25, 1, -27 },
  { 2777, 26, 27, 25, 1, -27 },
  { 2865, 19, 27, 25, 2, -27 },
  { 2930, 26, 27, 25, 0, -27 },
  { 3018, 24, 27, 25, 1, -27 },
  { 3099, 23, 27, 25, 1, -27 },
  { 3177, 24, 27, 25, 1, -27 },
  { 3258, 23, 35, 25, 1, -27 },
  { 3359, 24, 27, 25, 1, -27 },
  { 3440, 24, 27, 25, 0, -27 },
  { 3521, 24, 27, 25, 3, -27 },
  { 3602, 23, 27, 25, 2, -27 },
  { 3680, 25, 27, 25, 3, -27 },
  { 3765, 26, 27, 25, 2, -27 },
  { 3853, 29, 27, 25, -2, -27 },
  { 3951, 25, 27, 25, 3, -27 },
  { 4036, 25, 27, 25, 0, -27 },
  { 4121, 19, 39, 25, 4, -30 },
  { 4214, 16, 30, 25, 5, -30 },
  { 4274, 20, 39, 25, 1, -30 },
  { 4372, 22, 18, 25, 1, -28 },
  { 4422, 25, 2, 25, -3, 2 },
  { 4429, 10, 5, 25, 10, -29 },
  { 4436, 21, 22, 25, 1, -22 },
  { 4494, 22, 30, 25, 1, -30 },
  { 4577, 21, 22, 25, 2, -22 },
  { 4635, 23, 30, 25, 2, -30 },
  { 4722, 21, 22, 25, 2, -22 },
  { 4780, 22, 30, 25, 4, -30 },
  { 4863, 23, 31, 25, 1, -22 },
  { 4953, 22, 30, 25, 1, -30 },
  { 5036, 22, 30, 25, 0, -30 },
  { 5119, 22, 39, 25, -1, -30 },
  { 5227, 24, 30, 25, 1, -30 },
  { 5317, 22, 30, 25, 0, -30 },
  { 5400, 25, 22, 25, -1, -22 },
  { 5469, 22, 22, 25, 1, -22 },
  { 5530, 21, 22, 25, 2, -22 },
  { 5588, 24, 31, 25, -1, -22 },
  { 5681, 22, 31, 25, 2, -22 },
  { 5767, 21, 22, 25, 3, -22 },
  { 5825, 22, 22, 25, 1, -22 },
  { 5886, 17, 28, 25, 5, -28 },
  { 5946, 22, 22, 25, 2, -22 },
  { 6007, 23, 22, 25, 3, -22 },
  { 6071, 24, 22, 25, 2, -22 },
  { 6137, 26, 22, 25, -1, -22 },
  { 6209, 27, 31, 25, -1, -22 },
  { 6314, 22, 22, 25, 1, -22 },
  { 6375, 22, 39, 25, 3, -30 },
  { 6483, 5, 39, 25, 10, -30 },
  { 6508, 21, 39, 25, 0, -30 },
  { 6611, 22, 7, 25, 2, -17 },
};

const GFXfont LiberationMono_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic41pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _LIBERATIONMONO_BOLDITALIC41PT7B_H_
