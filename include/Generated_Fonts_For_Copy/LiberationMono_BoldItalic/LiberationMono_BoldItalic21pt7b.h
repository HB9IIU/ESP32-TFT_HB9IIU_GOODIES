#ifndef _LIBERATIONMONO_BOLDITALIC21PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0x39, 0xCE, 0x60, 0x01, 0xCE, 0x70, 0xE7, 0xE7,
  0xE6, 0xC6, 0xC6, 0xCE, 0xCC, 0x03, 0x10, 0x11, 0x81, 0x8C, 0x08, 0x43,
  0xFF, 0x9F, 0xFC, 0x21, 0x03, 0x18, 0x10, 0x87, 0xFF, 0x3F, 0xF8, 0x42,
  0x06, 0x30, 0x23, 0x00, 0x00, 0x80, 0x7E, 0x1F, 0xF1, 0x97, 0x39, 0x33,
  0x90, 0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x2F, 0x02, 0x7E, 0x66, 0x74, 0xE7,
  0xFC, 0x3F, 0x00, 0x40, 0x0C, 0x00, 0x1C, 0x18, 0x98, 0xC6, 0x62, 0x19,
  0x98, 0x66, 0xC1, 0xB6, 0x03, 0xB0, 0x01, 0xBC, 0x0D, 0xB0, 0x64, 0xC1,
  0x33, 0x0C, 0xCC, 0x63, 0x23, 0x07, 0x00, 0x03, 0xC0, 0xFE, 0x0C, 0x60,
  0xCE, 0x0D, 0xC0, 0xF8, 0x1E, 0x37, 0xE6, 0x66, 0x6E, 0x7C, 0xC3, 0xCE,
  0x3C, 0xFF, 0xF7, 0xC7, 0x66, 0xEE, 0xEC, 0xC0, 0x07, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0x70, 0x70, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x03, 0x03, 0x03, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0x0C, 0x06,
  0x1B, 0xCF, 0xE1, 0xC1, 0xE1, 0x98, 0x48, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x0F, 0xFF, 0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x1C, 0xE3, 0x9C,
  0x63, 0x8C, 0x00, 0xFD, 0xF8, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x83,
  0xF8, 0xE3, 0x98, 0x77, 0x0E, 0xED, 0xDB, 0xBF, 0x77, 0xE1, 0xDC, 0x3B,
  0x87, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x01, 0xC0, 0xF8, 0xF7, 0x1D, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFE,
  0xFF, 0xC0, 0x07, 0xC0, 0xFF, 0x1C, 0x73, 0x87, 0x00, 0x70, 0x0E, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x7F, 0xEF, 0xFC, 0x0F,
  0xC3, 0xFC, 0xE3, 0xB8, 0x70, 0x0E, 0x03, 0x83, 0xE0, 0x7C, 0x01, 0xC0,
  0x3B, 0x87, 0x71, 0xEF, 0xF8, 0xFC, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xE0,
  0x7E, 0x06, 0xE0, 0xCE, 0x18, 0xC3, 0x1C, 0x61, 0xC7, 0xFF, 0xFF, 0xF0,
  0x18, 0x01, 0x80, 0x38, 0x3F, 0xE7, 0xFC, 0xE0, 0x18, 0x07, 0x00, 0xEF,
  0x1F, 0xF3, 0x8E, 0x01, 0xC0, 0x3B, 0x87, 0x71, 0xCF, 0xF0, 0xFC, 0x00,
  0x07, 0xC3, 0xFC, 0xE3, 0x9C, 0x67, 0x00, 0xEF, 0x1F, 0xF7, 0x8E, 0xE1,
  0xDC, 0x3B, 0x87, 0x39, 0xC7, 0xF8, 0x7C, 0x00, 0x7F, 0xEF, 0xF8, 0x07,
  0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x00, 0x0F, 0xC3, 0xFC, 0xE3, 0xB8, 0x77, 0x0E, 0x73,
  0x8F, 0xE1, 0xFC, 0x71, 0xDC, 0x3B, 0x87, 0x71, 0xEF, 0xF8, 0xFC, 0x00,
  0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x7B, 0xFE, 0x3D,
  0xC0, 0x39, 0x86, 0x71, 0xCF, 0xF0, 0xF8, 0x00, 0x39, 0xDC, 0x00, 0x00,
  0x00, 0xE7, 0x38, 0x0E, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x71,
  0xC3, 0x86, 0x18, 0x30, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0x3F, 0x0F, 0x81,
  0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3E, 0x00, 0xC0, 0xF8, 0xFE, 0x7E, 0x1E, 0x02, 0x00, 0x00,
  0x1F, 0x9F, 0xF7, 0x1F, 0x87, 0x01, 0xC0, 0xF0, 0x78, 0x38, 0x1C, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x1C, 0x00, 0x03, 0xE0, 0x31, 0x82, 0x04, 0x20,
  0x33, 0x3B, 0x92, 0x7D, 0xB3, 0x69, 0x1B, 0x58, 0x96, 0x8C, 0xB4, 0x6D,
  0xA2, 0x4D, 0x36, 0x6E, 0xE3, 0x00, 0x08, 0x10, 0x61, 0x81, 0xF0, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0xD8, 0x0E, 0xC0, 0x66, 0x07, 0x30, 0x31, 0xC3,
  0x8E, 0x1F, 0xF1, 0xFF, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x38, 0x1F,
  0xE1, 0xFF, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x3F, 0xC3, 0xFE, 0x70,
  0x77, 0x07, 0x70, 0x77, 0x0E, 0x7F, 0xEF, 0xF8, 0x0F, 0xC1, 0xFE, 0x38,
  0xE7, 0x0F, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0C, 0xE1,
  0xCF, 0x3C, 0x7F, 0x83, 0xE0, 0x1F, 0xC1, 0xFE, 0x18, 0xF3, 0x87, 0x38,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x1C, 0x7F,
  0x8F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC7, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xFF, 0x87, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFE, 0x7F,
  0xF0, 0x3F, 0xF3, 0xFF, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x7F, 0xC7,
  0xFC, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x83,
  0xF8, 0xE3, 0xB8, 0x77, 0x01, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xFC, 0x1B,
  0x87, 0x78, 0xE7, 0xF8, 0x7C, 0x00, 0x1C, 0x38, 0xE1, 0xC7, 0x1C, 0x70,
  0xE3, 0x87, 0x1C, 0x38, 0xFF, 0xC7, 0xFC, 0x70, 0xE3, 0x87, 0x1C, 0x38,
  0xE1, 0xC7, 0x1C, 0x70, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0xFF,
  0x8F, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x8C, 0x73, 0x8E, 0x73, 0x8F, 0xF0, 0xF8, 0x00, 0x1C, 0x3C,
  0x71, 0xE1, 0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x7B, 0x81, 0xCF, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xE3, 0x83, 0x80, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xFF, 0xFF, 0xF0, 0x1C, 0x39, 0xE3, 0xCF, 0x16, 0x79, 0xF3,
  0xEF, 0x1B, 0xD9, 0xDE, 0xCC, 0xEE, 0x67, 0x73, 0x33, 0x18, 0x19, 0xC0,
  0xCC, 0x06, 0x60, 0x70, 0x1E, 0x38, 0xF1, 0xC7, 0x8C, 0x7C, 0x63, 0xE7,
  0x1B, 0x38, 0xDD, 0xC6, 0xEC, 0x73, 0x63, 0x9B, 0x1C, 0xF8, 0xC7, 0xC6,
  0x3C, 0x70, 0xE0, 0x0F, 0x83, 0xFC, 0xE3, 0xB8, 0x77, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x1F,
  0xE0, 0xFF, 0x86, 0x1C, 0x70, 0xF3, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0xFC,
  0x7F, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x83,
  0xFC, 0xE3, 0xB8, 0x77, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B,
  0x87, 0x71, 0xC7, 0xF0, 0x7C, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x1F,
  0xE0, 0xFF, 0x87, 0x1E, 0x70, 0x73, 0x87, 0x1C, 0x38, 0xFF, 0x87, 0xF0,
  0x73, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0xC7, 0x0E, 0x70, 0x70, 0x07, 0xE0,
  0xFF, 0x8F, 0x1C, 0x70, 0xE3, 0x80, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0xF0, 0x03, 0xB8, 0x19, 0xE1, 0xC7, 0xFC, 0x1F, 0x80, 0xFF, 0xEF, 0xFE,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x73, 0x87, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x38,
  0x7F, 0x03, 0xE0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38,
  0x63, 0x87, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x03, 0x80,
  0x60, 0x3B, 0x01, 0xD8, 0x0D, 0xC0, 0xEE, 0x67, 0x77, 0x33, 0xB9, 0x9F,
  0x7C, 0xFB, 0xC7, 0xDE, 0x3C, 0xF1, 0xE7, 0x0E, 0x38, 0x71, 0xC0, 0x1C,
  0x1C, 0x1C, 0x78, 0x38, 0xE0, 0x3B, 0x80, 0x7E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x07, 0x1E,
  0x0E, 0x00, 0xE0, 0x7E, 0x0E, 0x71, 0xC7, 0x38, 0x73, 0x83, 0xF0, 0x3E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1F,
  0xF8, 0xFF, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xC7,
  0xF1, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x3F, 0x0F, 0xC0, 0xC0, 0xE0,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06,
  0x06, 0x1F, 0xC7, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x3F, 0x0F,
  0xC0, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0xCC, 0x1C, 0xE1, 0x86, 0x30, 0x67,
  0x06, 0x60, 0x70, 0x7F, 0xF8, 0xE1, 0x86, 0x1F, 0x8F, 0xF7, 0x1C, 0x07,
  0x3F, 0xDF, 0xFE, 0x3B, 0x8E, 0xE7, 0xBF, 0xFF, 0x1C, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x19, 0xE3, 0xFE, 0x3C, 0xF3, 0x87, 0x38, 0x73, 0x07,
  0x70, 0xE7, 0x0E, 0x79, 0xC7, 0xFC, 0xE7, 0x00, 0x0F, 0x87, 0xF9, 0xE7,
  0xB8, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0x0E, 0xE3, 0x8F, 0xE0, 0xF8, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x1E, 0xE3, 0xFE, 0x71, 0xE7, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0xF8, 0x7B, 0x80, 0x0F,
  0x87, 0xF9, 0xC3, 0x38, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0xE1, 0xCF,
  0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x70, 0x0E, 0x0F, 0xFD, 0xFF, 0x8E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0x0F, 0x30, 0xFF, 0x8F, 0x3C, 0x70, 0xE3, 0x87, 0x38, 0x31, 0xC3, 0x8E,
  0x1C, 0x79, 0xE3, 0xF7, 0x0F, 0x70, 0x03, 0x8E, 0x3C, 0x3F, 0xC0, 0xF8,
  0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x39, 0xE3, 0xBF, 0x3C, 0x73,
  0x87, 0x38, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xE1, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x71, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x07, 0xE0,
  0xFC, 0x00, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0xE3, 0x1C, 0x73,
  0x87, 0x70, 0x7E, 0x07, 0xF0, 0x77, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xE1,
  0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x71, 0xFF, 0xFF, 0xF8, 0x37, 0x73,
  0xFF, 0x73, 0xB7, 0x33, 0x67, 0x36, 0x63, 0x66, 0x7E, 0x66, 0xE6, 0x6C,
  0xE6, 0xCE, 0x60, 0x39, 0xE3, 0xBF, 0x3C, 0x73, 0x87, 0x38, 0x77, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xE1, 0xC0, 0x0F, 0x87, 0xF9, 0xC7,
  0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0x0E, 0xE3, 0x9F, 0xF0, 0xF8, 0x00,
  0x39, 0xE3, 0xBE, 0x3C, 0xF3, 0x87, 0x38, 0x77, 0x07, 0x70, 0xE7, 0x0E,
  0x79, 0xE7, 0xFC, 0xE7, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1E,
  0xE7, 0xFD, 0xC7, 0xB8, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0x9F,
  0xF1, 0xEE, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x39, 0xE7, 0x7C, 0xF8,
  0x1E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x00,
  0x0F, 0x87, 0xF9, 0xC3, 0xB8, 0x07, 0xE0, 0x7F, 0x01, 0xF0, 0x0E, 0xE1,
  0xDF, 0xF1, 0xF8, 0x00, 0x0C, 0x0E, 0x06, 0x0F, 0xFF, 0xF9, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xF1, 0xF8, 0x70, 0xEE, 0x1D, 0xC3,
  0xB8, 0x66, 0x1D, 0xC3, 0xB8, 0x77, 0x1E, 0xE3, 0x9F, 0xF1, 0xEE, 0x00,
  0xF0, 0x77, 0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0x33, 0x03, 0x70,
  0x3E, 0x03, 0xE0, 0x3C, 0x00, 0xE0, 0x36, 0x01, 0xB0, 0x1D, 0x8C, 0xCC,
  0xE6, 0x6F, 0x73, 0x7B, 0x1E, 0x58, 0xF3, 0x87, 0x1C, 0x38, 0xE0, 0x1C,
  0x38, 0x39, 0xE0, 0xE7, 0x01, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x03,
  0xF0, 0x1C, 0xE0, 0xE3, 0x87, 0x07, 0x00, 0x38, 0x39, 0xC3, 0x8E, 0x1C,
  0x71, 0xC3, 0x8E, 0x0C, 0xE0, 0x76, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0xFC, 0xFF,
  0xC0, 0x07, 0xE1, 0xF8, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x83, 0xF8, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x1F,
  0x83, 0xE0, 0x00, 0x7C, 0x3F, 0xFE, 0x1F, 0x00,
};

const GFXglyph LiberationMono_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 14, 13, 4, -14 },
  { 10, 8, 7, 13, 4, -15 },
  { 17, 13, 14, 13, 0, -14 },
  { 40, 12, 17, 13, 0, -15 },
  { 66, 14, 14, 13, 0, -14 },
  { 91, 12, 14, 13, 0, -14 },
  { 112, 4, 7, 13, 6, -15 },
  { 116, 8, 19, 13, 3, -15 },
  { 135, 8, 19, 13, 1, -15 },
  { 154, 9, 8, 13, 3, -15 },
  { 163, 11, 10, 13, 1, -12 },
  { 177, 6, 7, 13, 1, -3 },
  { 183, 7, 2, 13, 3, -7 },
  { 185, 3, 3, 13, 4, -3 },
  { 187, 14, 15, 13, 0, -15 },
  { 214, 11, 14, 13, 1, -14 },
  { 234, 11, 14, 13, 0, -14 },
  { 254, 12, 14, 13, 0, -14 },
  { 275, 11, 14, 13, 1, -14 },
  { 295, 12, 14, 13, 0, -14 },
  { 316, 11, 14, 13, 1, -14 },
  { 336, 11, 14, 13, 1, -14 },
  { 356, 11, 14, 13, 2, -14 },
  { 376, 11, 14, 13, 1, -14 },
  { 396, 11, 14, 13, 1, -14 },
  { 416, 5, 11, 13, 4, -11 },
  { 423, 7, 15, 13, 2, -11 },
  { 437, 11, 11, 13, 1, -12 },
  { 453, 11, 8, 13, 1, -11 },
  { 464, 11, 11, 13, 1, -12 },
  { 480, 10, 14, 13, 2, -14 },
  { 498, 13, 18, 13, 0, -15 },
  { 528, 13, 14, 13, -1, -14 },
  { 551, 12, 14, 13, 0, -14 },
  { 572, 12, 14, 13, 1, -14 },
  { 593, 12, 14, 13, 0, -14 },
  { 614, 13, 14, 13, 0, -14 },
  { 637, 12, 14, 13, 1, -14 },
  { 658, 11, 14, 13, 1, -14 },
  { 678, 13, 14, 13, 0, -14 },
  { 701, 12, 14, 13, 1, -14 },
  { 722, 11, 14, 13, 1, -14 },
  { 742, 14, 14, 13, 0, -14 },
  { 767, 10, 14, 13, 1, -14 },
  { 785, 13, 14, 13, 0, -14 },
  { 808, 13, 14, 13, 0, -14 },
  { 831, 11, 14, 13, 1, -14 },
  { 851, 13, 14, 13, 0, -14 },
  { 874, 11, 18, 13, 1, -14 },
  { 899, 13, 14, 13, 0, -14 },
  { 922, 13, 14, 13, 0, -14 },
  { 945, 12, 14, 13, 2, -14 },
  { 966, 12, 14, 13, 1, -14 },
  { 987, 12, 14, 13, 2, -14 },
  { 1008, 13, 14, 13, 1, -14 },
  { 1031, 15, 14, 13, -1, -14 },
  { 1058, 12, 14, 13, 2, -14 },
  { 1079, 13, 14, 13, 0, -14 },
  { 1102, 10, 19, 13, 2, -15 },
  { 1126, 8, 15, 13, 3, -15 },
  { 1141, 10, 19, 13, 1, -15 },
  { 1165, 12, 9, 13, 0, -14 },
  { 1179, 13, 1, 13, -2, 1 },
  { 1181, 5, 3, 13, 5, -15 },
  { 1183, 10, 11, 13, 1, -11 },
  { 1197, 12, 15, 13, 0, -15 },
  { 1220, 11, 11, 13, 1, -11 },
  { 1236, 12, 15, 13, 1, -15 },
  { 1259, 11, 11, 13, 1, -11 },
  { 1275, 11, 15, 13, 2, -15 },
  { 1296, 13, 15, 13, 0, -11 },
  { 1321, 12, 15, 13, 0, -15 },
  { 1344, 11, 15, 13, 0, -15 },
  { 1365, 12, 19, 13, -1, -15 },
  { 1394, 12, 15, 13, 1, -15 },
  { 1417, 11, 15, 13, 0, -15 },
  { 1438, 12, 11, 13, 0, -11 },
  { 1455, 12, 11, 13, 0, -11 },
  { 1472, 11, 11, 13, 1, -11 },
  { 1488, 12, 15, 13, 0, -11 },
  { 1511, 11, 15, 13, 1, -11 },
  { 1532, 11, 11, 13, 1, -11 },
  { 1548, 11, 11, 13, 1, -11 },
  { 1564, 9, 14, 13, 2, -14 },
  { 1580, 11, 11, 13, 1, -11 },
  { 1596, 12, 11, 13, 1, -11 },
  { 1613, 13, 11, 13, 1, -11 },
  { 1631, 14, 11, 13, -1, -11 },
  { 1651, 13, 15, 13, 0, -11 },
  { 1676, 12, 11, 13, 0, -11 },
  { 1693, 11, 19, 13, 2, -15 },
  { 1720, 3, 20, 13, 5, -15 },
  { 1728, 11, 19, 13, 0, -15 },
  { 1755, 11, 3, 13, 1, -9 },
};

const GFXfont LiberationMono_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic21pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _LIBERATIONMONO_BOLDITALIC21PT7B_H_
