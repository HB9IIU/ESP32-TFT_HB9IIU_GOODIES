#ifndef _LIBERATIONMONO_BOLDITALIC11PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x21, 0xB0, 0xD9, 0xB0, 0x14, 0x29, 0xF9, 0x4F, 0xCA, 0x24,
  0x00, 0x08, 0x79, 0xD3, 0x83, 0xC2, 0xB7, 0x3C, 0x20, 0x62, 0xAA, 0xA3,
  0xE3, 0x4A, 0xA7, 0x00, 0x18, 0x93, 0x99, 0x9E, 0x6F, 0xC0, 0xF8, 0x36,
  0x4C, 0x88, 0x88, 0x8C, 0x23, 0x33, 0x33, 0x26, 0x4C, 0x2F, 0x6A, 0x21,
  0x3E, 0x42, 0x00, 0x26, 0x44, 0xE0, 0xF0, 0x02, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x60, 0x7E, 0x73, 0x59, 0xCB, 0x80, 0x19, 0xE1, 0x86, 0x10, 0x4F,
  0xC0, 0x3D, 0x90, 0x46, 0x31, 0x8F, 0xC0, 0x3D, 0x90, 0x46, 0x0F, 0x37,
  0x80, 0x0C, 0x72, 0xD2, 0xFC, 0x61, 0x80, 0x3D, 0x87, 0x83, 0x0F, 0x37,
  0x80, 0x3A, 0x71, 0xF9, 0xCF, 0xC0, 0xFC, 0x21, 0x08, 0x61, 0x0C, 0x00,
  0x3D, 0x96, 0x4E, 0x4F, 0x37, 0x80, 0x3D, 0x96, 0x5F, 0x0D, 0x27, 0x00,
  0x68, 0x0D, 0x80, 0x32, 0x00, 0x64, 0xC8, 0x0F, 0xA1, 0xE0, 0x80, 0xF8,
  0x01, 0xF0, 0x83, 0xC2, 0xF8, 0x00, 0x7E, 0x46, 0xC0, 0x21, 0x00, 0x1C,
  0x45, 0x7B, 0x5C, 0xBA, 0xBA, 0x40, 0x80, 0xE0, 0x0C, 0x38, 0x51, 0xB3,
  0xEC, 0xD1, 0x80, 0x7D, 0x96, 0x5E, 0x47, 0x3F, 0x80, 0x3C, 0xC9, 0x02,
  0x0C, 0x09, 0x9E, 0x00, 0x7D, 0x96, 0x51, 0x4F, 0x2F, 0x00, 0x7E, 0xC1,
  0x83, 0xE4, 0x18, 0x3F, 0x00, 0x3E, 0xC1, 0x83, 0xE4, 0x08, 0x30, 0x00,
  0x3D, 0x94, 0x17, 0xC5, 0x37, 0x80, 0x66, 0xC9, 0x93, 0xE4, 0xD9, 0xB2,
  0x00, 0x3C, 0x30, 0x40, 0x83, 0x06, 0x3E, 0x00, 0x1C, 0x30, 0xC3, 0x0B,
  0x67, 0x00, 0x66, 0xD9, 0xE3, 0x87, 0x99, 0x33, 0x00, 0x42, 0x31, 0x8C,
  0x43, 0xE0, 0x66, 0xDD, 0xB3, 0xAF, 0x50, 0xA3, 0x00, 0x66, 0xE9, 0x52,
  0xA5, 0xDB, 0xB6, 0x00, 0x3C, 0xC9, 0x12, 0x2C, 0xD9, 0x9E, 0x00, 0x7C,
  0xCD, 0x93, 0xC4, 0x18, 0x30, 0x00, 0x3C, 0xC9, 0x12, 0x2C, 0xD9, 0x9E,
  0x18, 0x18, 0x7C, 0xCD, 0x93, 0xC5, 0x99, 0x33, 0x00, 0x3C, 0xCD, 0x81,
  0xE0, 0xD9, 0x9E, 0x00, 0xFC, 0xC2, 0x08, 0x61, 0x86, 0x00, 0xCF, 0x2C,
  0xA6, 0x9A, 0x4F, 0x00, 0xC7, 0x3C, 0xB4, 0x71, 0x86, 0x00, 0x86, 0x1A,
  0xFA, 0xEB, 0xC9, 0x00, 0x33, 0x16, 0x1C, 0x18, 0x1C, 0x24, 0x66, 0xCF,
  0x25, 0x1C, 0x61, 0x86, 0x00, 0x3E, 0x18, 0x61, 0x82, 0x08, 0x3F, 0x00,
  0x39, 0x18, 0xC6, 0x21, 0x18, 0xC7, 0x00, 0x42, 0x18, 0x42, 0x18, 0x42,
  0x38, 0x20, 0x86, 0x18, 0x41, 0x04, 0x33, 0xC0, 0x18, 0xE2, 0xD1, 0x44,
  0xFE, 0xD0, 0x39, 0xB0, 0xDE, 0xDB, 0xB0, 0x21, 0x87, 0xD9, 0x45, 0x34,
  0xFE, 0x3D, 0x94, 0x10, 0x4D, 0xE0, 0x06, 0x0C, 0xD3, 0x64, 0xD9, 0xB3,
  0x3C, 0x3D, 0x97, 0xF0, 0x4D, 0xE0, 0x3C, 0x8F, 0x98, 0x61, 0x04, 0x10,
  0x3C, 0xD9, 0x12, 0x64, 0xCF, 0x02, 0x78, 0x21, 0x87, 0xD9, 0x45, 0x3C,
  0xF2, 0x08, 0x03, 0x86, 0x10, 0x43, 0x3F, 0x0C, 0x03, 0x86, 0x18, 0x61,
  0x04, 0x33, 0x80, 0x20, 0x41, 0x93, 0x47, 0x0F, 0x16, 0x66, 0x38, 0x61,
  0x86, 0x10, 0x43, 0x3F, 0x7C, 0xA9, 0x56, 0xAB, 0x54, 0x80, 0x7D, 0x94,
  0x53, 0xCF, 0x20, 0x3D, 0x94, 0x73, 0xCD, 0xE0, 0x7D, 0x94, 0x53, 0xCF,
  0xEC, 0x20, 0x35, 0xB4, 0xF3, 0xC9, 0xE0, 0x86, 0x5B, 0x31, 0x8C, 0x40,
  0x3D, 0x87, 0x07, 0x0D, 0xE0, 0x21, 0x3E, 0xC4, 0x23, 0x0E, 0x65, 0x94,
  0xD3, 0xC9, 0xE0, 0x8F, 0x2D, 0xB4, 0x61, 0x80, 0x42, 0xAD, 0xD3, 0xA4,
  0x99, 0x00, 0x64, 0x50, 0xE1, 0x87, 0x99, 0x80, 0x46, 0xC9, 0xB1, 0xC3,
  0x06, 0x08, 0x60, 0x7C, 0x21, 0x0C, 0x63, 0xE0, 0x3C, 0x82, 0x18, 0xC1,
  0x04, 0x10, 0x41, 0xC0, 0xFF, 0xC0, 0x38, 0x21, 0x86, 0x0C, 0x41, 0x0C,
  0x33, 0x80, 0xE1, 0xC0,
};

const GFXglyph LiberationMono_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 7, 7, 2, -7 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 7, 7, 0, -7 },
  { 13, 7, 9, 7, 0, -8 },
  { 21, 7, 7, 7, 0, -7 },
  { 28, 6, 7, 7, 0, -7 },
  { 34, 2, 3, 7, 3, -8 },
  { 35, 4, 10, 7, 2, -8 },
  { 40, 4, 10, 7, 1, -8 },
  { 45, 4, 4, 7, 2, -8 },
  { 47, 5, 5, 7, 1, -6 },
  { 51, 4, 4, 7, 0, -2 },
  { 53, 3, 1, 7, 2, -4 },
  { 54, 2, 2, 7, 2, -2 },
  { 55, 7, 8, 7, 0, -8 },
  { 62, 5, 7, 7, 1, -7 },
  { 67, 6, 7, 7, 0, -7 },
  { 73, 6, 7, 7, 0, -7 },
  { 79, 6, 7, 7, 0, -7 },
  { 85, 6, 7, 7, 0, -7 },
  { 91, 6, 7, 7, 0, -7 },
  { 97, 5, 7, 7, 1, -7 },
  { 102, 6, 7, 7, 1, -7 },
  { 108, 6, 7, 7, 0, -7 },
  { 114, 6, 7, 7, 0, -7 },
  { 120, 3, 6, 7, 2, -6 },
  { 123, 4, 8, 7, 1, -6 },
  { 127, 5, 5, 7, 1, -6 },
  { 131, 5, 4, 7, 1, -5 },
  { 134, 5, 5, 7, 1, -6 },
  { 138, 5, 7, 7, 1, -7 },
  { 143, 7, 10, 7, 0, -8 },
  { 152, 7, 7, 7, -1, -7 },
  { 159, 6, 7, 7, 0, -7 },
  { 165, 7, 7, 7, 0, -7 },
  { 172, 6, 7, 7, 0, -7 },
  { 178, 7, 7, 7, 0, -7 },
  { 185, 7, 7, 7, 0, -7 },
  { 192, 6, 7, 7, 0, -7 },
  { 198, 7, 7, 7, 0, -7 },
  { 205, 7, 7, 7, 0, -7 },
  { 212, 6, 7, 7, 0, -7 },
  { 218, 7, 7, 7, 0, -7 },
  { 225, 5, 7, 7, 1, -7 },
  { 230, 7, 7, 7, 0, -7 },
  { 237, 7, 7, 7, 0, -7 },
  { 244, 7, 7, 7, 0, -7 },
  { 251, 7, 7, 7, 0, -7 },
  { 258, 7, 9, 7, 0, -7 },
  { 266, 7, 7, 7, 0, -7 },
  { 273, 7, 7, 7, 0, -7 },
  { 280, 6, 7, 7, 1, -7 },
  { 286, 6, 7, 7, 1, -7 },
  { 292, 6, 7, 7, 1, -7 },
  { 298, 6, 7, 7, 1, -7 },
  { 304, 8, 7, 7, -1, -7 },
  { 311, 6, 7, 7, 1, -7 },
  { 317, 7, 7, 7, 0, -7 },
  { 324, 5, 10, 7, 1, -8 },
  { 331, 5, 8, 7, 1, -8 },
  { 336, 6, 10, 7, 0, -8 },
  { 344, 6, 5, 7, 0, -7 },
  { 348, 7, 1, 7, -1, 1 },
  { 349, 2, 2, 7, 3, -8 },
  { 350, 6, 6, 7, 0, -6 },
  { 355, 6, 8, 7, 0, -8 },
  { 361, 6, 6, 7, 0, -6 },
  { 366, 7, 8, 7, 0, -8 },
  { 373, 6, 6, 7, 0, -6 },
  { 378, 6, 8, 7, 1, -8 },
  { 384, 7, 8, 7, 0, -6 },
  { 391, 6, 8, 7, 0, -8 },
  { 397, 6, 8, 7, 0, -8 },
  { 403, 6, 10, 7, 0, -8 },
  { 411, 7, 8, 7, 0, -8 },
  { 418, 6, 8, 7, 0, -8 },
  { 424, 7, 6, 7, 0, -6 },
  { 430, 6, 6, 7, 0, -6 },
  { 435, 6, 6, 7, 0, -6 },
  { 440, 6, 8, 7, 0, -6 },
  { 446, 6, 8, 7, 0, -6 },
  { 452, 5, 6, 7, 1, -6 },
  { 456, 6, 6, 7, 0, -6 },
  { 461, 5, 8, 7, 1, -8 },
  { 466, 6, 6, 7, 0, -6 },
  { 471, 6, 6, 7, 1, -6 },
  { 476, 7, 6, 7, 0, -6 },
  { 482, 7, 6, 7, 0, -6 },
  { 488, 7, 8, 7, 0, -6 },
  { 495, 6, 6, 7, 0, -6 },
  { 500, 6, 10, 7, 1, -8 },
  { 508, 1, 10, 7, 3, -8 },
  { 510, 6, 10, 7, 0, -8 },
  { 518, 5, 2, 7, 1, -5 },
};

const GFXfont LiberationMono_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic11pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _LIBERATIONMONO_BOLDITALIC11PT7B_H_
