#ifndef _LIBERATIONMONO_BOLDITALIC48PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F,
  0x9F, 0x87, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x07,
  0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x81, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x07, 0xF9, 0xDF, 0xE1, 0xFC, 0x31, 0xFC, 0x3F, 0x06, 0x1F, 0x87, 0xE1,
  0xC3, 0xC0, 0xFC, 0x38, 0x00, 0x1F, 0x87, 0x00, 0x03, 0xFC, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0x8F, 0xE0, 0x00, 0x70, 0xFE, 0x00, 0x0C, 0x1F, 0xC7, 0x81, 0x83,
  0xF3, 0xF0, 0x70, 0x7E, 0x7F, 0x0E, 0x0F, 0xCF, 0xE1, 0xC3, 0xF1, 0xFF,
  0x31, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0x01, 0xFF, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0x3C, 0x07, 0x8F, 0x80,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x0F, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x83,
  0xC0, 0x1E, 0x07, 0x87, 0xC0, 0x1E, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x0F,
  0x00, 0x1E, 0x0F, 0x1E, 0x00, 0x1E, 0x1F, 0x3C, 0x00, 0x1F, 0x3E, 0x78,
  0x00, 0x1F, 0xFC, 0xF0, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07, 0x9F, 0xF0, 0x00, 0x0F, 0x3F,
  0xF8, 0x00, 0x1E, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x78, 0x00, 0x78, 0xF0,
  0x78, 0x00, 0xF0, 0xF0, 0x78, 0x01, 0xF1, 0xF0, 0x78, 0x01, 0xE1, 0xE0,
  0x78, 0x03, 0xC1, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x01, 0xF1, 0xE0, 0x3C, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0xFF,
  0x80, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x07, 0xE0, 0x03, 0xE3, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x1E, 0x0F,
  0xFE, 0x03, 0xC3, 0xFF, 0xC0, 0xF8, 0xFC, 0xFC, 0x1F, 0x3F, 0x0F, 0x87,
  0xC7, 0xE1, 0xF9, 0xF9, 0xF8, 0x1F, 0xBE, 0x3F, 0x03, 0xFF, 0x87, 0xC0,
  0x3F, 0xF0, 0xF8, 0x07, 0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xF8,
  0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xCF, 0xFF,
  0x87, 0xF0, 0x7F, 0x80, 0x3E, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x20, 0xF0, 0xDE, 0x3C, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xE0, 0x1F,
  0x7C, 0x0F, 0x9F, 0x07, 0xC7, 0xE3, 0xF0, 0xF8, 0x38, 0x38, 0x04, 0x0C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0x7E, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x3E,
  0x7F, 0x7E, 0x3E, 0x7F, 0xFE, 0x3E, 0x7F, 0xFE, 0x7C, 0x7F, 0xFE, 0x7C,
  0x7E, 0xFE, 0x7C, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07,
  0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFB, 0xF8, 0x0F, 0xF3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE1, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x03, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F,
  0xC1, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xFC, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0x80,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xF8, 0x07, 0xF3, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xC3, 0xFE, 0x7F, 0x80, 0x7F, 0x3F,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3,
  0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x1F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFE, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xE0,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xE1, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0,
  0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFF,
  0x01, 0xFE, 0x7F, 0xC3, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xCF, 0xE0, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x04, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC,
  0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0x7F,
  0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x38, 0x1C, 0x0F, 0x01, 0xC1, 0xE0, 0xFC, 0xEE, 0x0E, 0x1F, 0xF7,
  0x70, 0xF1, 0xF3, 0xFB, 0x87, 0x0E, 0x0F, 0x9C, 0x78, 0xF0, 0x7C, 0xE3,
  0x8F, 0x03, 0xC7, 0x1C, 0x70, 0x1E, 0x39, 0xE7, 0x80, 0xF1, 0xCE, 0x38,
  0x0F, 0x0E, 0x73, 0xC0, 0x78, 0xE7, 0x9E, 0x03, 0x87, 0x38, 0xE0, 0x3C,
  0x39, 0xC7, 0x01, 0xE3, 0xCE, 0x78, 0x0E, 0x1C, 0x73, 0xC0, 0xF0, 0xE3,
  0x9E, 0x07, 0x0E, 0x3C, 0xF0, 0x78, 0x71, 0xE7, 0x07, 0xC7, 0x0F, 0x3C,
  0x3E, 0x38, 0x79, 0xE7, 0x73, 0x83, 0xCF, 0xFB, 0xF8, 0x1E, 0x3F, 0x1F,
  0x80, 0xF0, 0xF0, 0x78, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x03,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x0F,
  0xE7, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x20, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x78, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xE1, 0xFF, 0x81, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x1F,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0x7F,
  0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x3F, 0xFE, 0xFE, 0x0F, 0xFF, 0xBF, 0x83, 0xFF, 0xEF, 0xE0, 0xFF, 0xFB,
  0xF8, 0x3F, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03,
  0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF8,
  0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE,
  0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x87, 0xBE, 0x0F, 0xBE, 0x3F, 0xF8, 0x3E, 0xF8, 0xF7, 0xC0,
  0xFB, 0xE7, 0xDF, 0x03, 0xEF, 0x9F, 0x7C, 0x0F, 0xBE, 0xF9, 0xF0, 0x7E,
  0xFB, 0xEF, 0xC1, 0xF3, 0xEF, 0x3E, 0x07, 0xC7, 0xFC, 0xF8, 0x1F, 0x1F,
  0xE3, 0xE0, 0x7C, 0x7F, 0x8F, 0x83, 0xF1, 0xFC, 0x7E, 0x0F, 0x87, 0xF1,
  0xF0, 0x3E, 0x1F, 0x87, 0xC0, 0xF8, 0x7E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C,
  0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xFC,
  0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0x3F,
  0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0xFF,
  0xE0, 0x7E, 0x0F, 0xFE, 0x07, 0xE0, 0xFF, 0xE0, 0xFE, 0x0F, 0xBF, 0x0F,
  0xC0, 0xFB, 0xF0, 0xFC, 0x1F, 0x9F, 0x0F, 0xC1, 0xF9, 0xF0, 0xFC, 0x1F,
  0x9F, 0x0F, 0xC1, 0xF9, 0xF9, 0xF8, 0x1F, 0x9F, 0x9F, 0x83, 0xF9, 0xF9,
  0xF8, 0x3F, 0x0F, 0x9F, 0x83, 0xF0, 0xF9, 0xF8, 0x3F, 0x0F, 0x9F, 0x03,
  0xF0, 0xFD, 0xF0, 0x3F, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0xF0, 0x7E, 0x07,
  0xFF, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0,
  0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0x01,
  0xFF, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFF, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0xFF,
  0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xC1, 0xF8, 0xFE, 0x3F,
  0x07, 0xE7, 0xF8, 0xF8, 0x1F, 0x9F, 0xE3, 0xE0, 0x7E, 0x7F, 0x9F, 0x81,
  0xFB, 0xFE, 0x7C, 0x07, 0xCF, 0x7D, 0xF0, 0x1F, 0x7D, 0xFF, 0xC0, 0x7D,
  0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1,
  0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xF8, 0x1F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xC3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0x8F, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0,
  0xFF, 0x8F, 0xF0, 0xFF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFF, 0xF3, 0xFE, 0xFF,
  0xF1, 0xFF, 0x3F, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0xF0, 0x1F, 0x9F, 0xFE,
  0x0F, 0xEF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFF,
  0xFF, 0xC1, 0xFB, 0xFF, 0xE0, 0xFE, 0xFF, 0xF0, 0x3F, 0x9F, 0xF8, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x00,
  0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x9F, 0xE0, 0x3F, 0x87, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xE1, 0xFC,
  0x01, 0xFF, 0x9F, 0xC0, 0x3F, 0xF9, 0xF8, 0x07, 0xFF, 0xDF, 0x80, 0xFF,
  0xFD, 0xF8, 0x1F, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xF9, 0xF8, 0x03, 0xFF, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xFC, 0x7E, 0x01, 0xFF, 0xE7, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0xE7,
  0xE0, 0x0F, 0xFC, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x3F, 0xF0, 0x3F, 0x9F, 0xFE, 0x0F, 0xEF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xFC, 0x3F, 0xC0, 0x7F, 0x1F,
  0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x83, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC7, 0x81, 0xF0, 0x3E,
  0x7E, 0x3F, 0xC1, 0xF7, 0xFB, 0xFE, 0x0F, 0xFF, 0xDF, 0xF0, 0xFE, 0x7F,
  0x9F, 0x87, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3E,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xFC, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xC7, 0xE1, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0xFF,
  0xC0, 0xFE, 0x7F, 0xF8, 0x3F, 0xBF, 0xFE, 0x0F, 0xDF, 0xFF, 0xC3, 0xFF,
  0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0x83, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xF0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xF8,
  0x03, 0xF9, 0xFF, 0xC0, 0x3F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xBF,
  0xFE, 0x03, 0xFB, 0xFF, 0xC0, 0x3F, 0x9F, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x7F, 0xC7, 0xF0, 0x3F, 0xF9, 0xF8, 0x1F, 0xFF, 0x7E,
  0x0F, 0xFF, 0xDF, 0x87, 0xF8, 0x7F, 0xE1, 0xFC, 0x0F, 0xF8, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xDF, 0xC1, 0xFF, 0xE7, 0xE0, 0x3F, 0xF3, 0xF8, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x87,
  0xF1, 0xFF, 0xC3, 0xF9, 0xFF, 0xC1, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x03,
  0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x03, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x81, 0xFF, 0xE7,
  0xE0, 0x3F, 0xE1, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x7C,
  0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0x3E,
  0x3E, 0x1F, 0xC3, 0xE1, 0xF0, 0xFF, 0x1F, 0x0F, 0x8F, 0x78, 0xF8, 0x7C,
  0x7B, 0xCF, 0x83, 0xE7, 0x9E, 0x7C, 0x1F, 0x3C, 0xF3, 0xC0, 0xFB, 0xC7,
  0xBE, 0x07, 0xDE, 0x3D, 0xF0, 0x3F, 0xE1, 0xEF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x17, 0xFF, 0xF8, 0x1D, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x98, 0x1F,
  0xFF, 0xE8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
};

const GFXglyph LiberationMono_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 13, 32, 29, 9, -32 },
  { 53, 19, 15, 29, 8, -35 },
  { 89, 28, 32, 29, 1, -32 },
  { 201, 27, 39, 29, 1, -35 },
  { 333, 32, 32, 29, -1, -32 },
  { 461, 27, 32, 29, 0, -32 },
  { 569, 9, 15, 29, 13, -35 },
  { 586, 19, 45, 29, 7, -35 },
  { 693, 19, 45, 29, 3, -35 },
  { 800, 18, 18, 29, 8, -35 },
  { 841, 24, 25, 29, 2, -29 },
  { 916, 14, 16, 29, 2, -7 },
  { 944, 15, 6, 29, 7, -15 },
  { 956, 8, 7, 29, 9, -7 },
  { 963, 31, 35, 29, 0, -35 },
  { 1099, 24, 32, 29, 3, -32 },
  { 1195, 24, 32, 29, 1, -32 },
  { 1291, 28, 32, 29, 0, -32 },
  { 1403, 27, 32, 29, 1, -32 },
  { 1511, 26, 32, 29, 1, -32 },
  { 1615, 26, 32, 29, 2, -32 },
  { 1719, 25, 32, 29, 3, -32 },
  { 1819, 24, 32, 29, 5, -32 },
  { 1915, 26, 32, 29, 2, -32 },
  { 2019, 25, 32, 29, 2, -32 },
  { 2119, 11, 26, 29, 9, -26 },
  { 2155, 16, 35, 29, 4, -26 },
  { 2225, 24, 25, 29, 2, -28 },
  { 2300, 24, 18, 29, 2, -25 },
  { 2354, 24, 25, 29, 2, -28 },
  { 2429, 24, 32, 29, 4, -32 },
  { 2525, 29, 42, 29, 0, -35 },
  { 2678, 28, 32, 29, -2, -32 },
  { 2790, 27, 32, 29, 1, -32 },
  { 2898, 27, 32, 29, 2, -32 },
  { 3006, 27, 32, 29, 1, -32 },
  { 3114, 29, 32, 29, 1, -32 },
  { 3230, 29, 32, 29, 1, -32 },
  { 3346, 26, 32, 29, 2, -32 },
  { 3450, 28, 32, 29, 1, -32 },
  { 3562, 28, 32, 29, 1, -32 },
  { 3674, 26, 32, 29, 2, -32 },
  { 3778, 31, 32, 29, 1, -32 },
  { 3902, 23, 32, 29, 2, -32 },
  { 3994, 30, 32, 29, 0, -32 },
  { 4114, 28, 32, 29, 1, -32 },
  { 4226, 26, 32, 29, 2, -32 },
  { 4330, 28, 32, 29, 1, -32 },
  { 4442, 26, 41, 29, 2, -32 },
  { 4576, 28, 32, 29, 1, -32 },
  { 4688, 29, 32, 29, 0, -32 },
  { 4804, 27, 32, 29, 4, -32 },
  { 4912, 27, 32, 29, 2, -32 },
  { 5020, 28, 32, 29, 4, -32 },
  { 5132, 30, 32, 29, 2, -32 },
  { 5252, 34, 32, 29, -2, -32 },
  { 5388, 28, 32, 29, 4, -32 },
  { 5500, 29, 32, 29, 0, -32 },
  { 5616, 23, 45, 29, 4, -35 },
  { 5746, 18, 35, 29, 6, -35 },
  { 5825, 22, 45, 29, 2, -35 },
  { 5949, 26, 21, 29, 1, -33 },
  { 6018, 30, 2, 29, -4, 3 },
  { 6026, 11, 6, 29, 12, -34 },
  { 6035, 25, 26, 29, 1, -26 },
  { 6117, 26, 35, 29, 1, -35 },
  { 6231, 25, 26, 29, 2, -26 },
  { 6313, 28, 35, 29, 2, -35 },
  { 6436, 25, 26, 29, 2, -26 },
  { 6518, 27, 35, 29, 4, -35 },
  { 6637, 28, 36, 29, 1, -26 },
  { 6763, 26, 35, 29, 1, -35 },
  { 6877, 25, 35, 29, 0, -35 },
  { 6987, 26, 45, 29, -1, -35 },
  { 7134, 27, 35, 29, 2, -35 },
  { 7253, 25, 35, 29, 0, -35 },
  { 7363, 29, 26, 29, -1, -26 },
  { 7458, 26, 26, 29, 1, -26 },
  { 7543, 25, 26, 29, 2, -26 },
  { 7625, 28, 36, 29, -1, -26 },
  { 7751, 26, 36, 29, 2, -26 },
  { 7868, 25, 26, 29, 3, -26 },
  { 7950, 25, 26, 29, 2, -26 },
  { 8032, 21, 33, 29, 5, -33 },
  { 8119, 26, 26, 29, 2, -26 },
  { 8204, 27, 26, 29, 3, -26 },
  { 8292, 29, 26, 29, 2, -26 },
  { 8387, 31, 26, 29, -1, -26 },
  { 8488, 31, 36, 29, -1, -26 },
  { 8628, 26, 26, 29, 1, -26 },
  { 8713, 25, 45, 29, 4, -35 },
  { 8854, 6, 46, 29, 11, -35 },
  { 8889, 25, 45, 29, 0, -35 },
  { 9030, 26, 8, 29, 2, -20 },
};

const GFXfont LiberationMono_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic48pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _LIBERATIONMONO_BOLDITALIC48PT7B_H_
