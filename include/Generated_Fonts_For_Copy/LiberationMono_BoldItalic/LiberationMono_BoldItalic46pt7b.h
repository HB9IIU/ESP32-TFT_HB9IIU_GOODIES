#ifndef _LIBERATIONMONO_BOLDITALIC46PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7, 0xE0, 0xFD, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x07, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x80, 0x00, 0x0F,
  0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0,
  0x70, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80,
  0x70, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x1C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1C,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF3, 0xBF, 0xC3, 0xF0, 0xE3,
  0xF0, 0xFC, 0x30, 0xFC, 0x3F, 0x0C, 0x30, 0x1F, 0xC7, 0x00, 0x07, 0xF9,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0D, 0xFF,
  0x00, 0x03, 0x1F, 0xC0, 0x01, 0xC3, 0xF0, 0x30, 0x70, 0xFC, 0xFC, 0x18,
  0x3F, 0x3F, 0x06, 0x0F, 0xCF, 0xE3, 0x87, 0xF3, 0xFC, 0xE7, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3C, 0x07, 0xFC, 0x00,
  0x70, 0x1F, 0xFC, 0x01, 0xE0, 0x7C, 0x78, 0x07, 0x80, 0xF0, 0xF0, 0x1E,
  0x01, 0xE1, 0xE0, 0x78, 0x07, 0x83, 0xC1, 0xE0, 0x0F, 0x07, 0x87, 0x80,
  0x1E, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x78, 0x00, 0x78, 0x79, 0xE0, 0x00,
  0xF1, 0xF3, 0xC0, 0x01, 0xFF, 0xCF, 0x00, 0x01, 0xFF, 0x3C, 0x00, 0x01,
  0xF8, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x0F, 0x3F, 0xE0, 0x00,
  0x3C, 0xFF, 0xE0, 0x00, 0xF3, 0xE7, 0xC0, 0x03, 0xC7, 0x87, 0x80, 0x07,
  0x1E, 0x0F, 0x00, 0x1E, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x70, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x07,
  0x8F, 0x01, 0xE0, 0x0F, 0xFC, 0x07, 0x80, 0x0F, 0xF0, 0x1E, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x0F,
  0xBF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x78, 0x3F, 0xF0, 0x1E, 0x1F, 0xFE, 0x0F, 0x8F, 0xCF, 0x83,
  0xC7, 0xE3, 0xF1, 0xF3, 0xF0, 0x7C, 0xF8, 0xFC, 0x1F, 0xBE, 0x3E, 0x03,
  0xFF, 0x0F, 0x80, 0xFF, 0x83, 0xE0, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F,
  0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFD, 0xFF, 0x3F, 0xFE, 0x3F,
  0x83, 0xFC, 0x03, 0xE0, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x30, 0xF0, 0xCF, 0x3D, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0x7C, 0x1F, 0x8F, 0x87, 0xC3, 0xE0, 0xE0, 0xE0, 0x08, 0x10, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0xFE,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE7, 0xC7, 0xEF, 0xCF, 0x9F, 0xFF, 0x9F, 0x3F,
  0xFE, 0x3E, 0x7E, 0xFC, 0x7C, 0xFD, 0xF8, 0xF1, 0xFB, 0xF0, 0x07, 0xF7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x7E,
  0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFB, 0xF0, 0x0F, 0xC7, 0xE0, 0x1C, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xFC, 0x03, 0xF8, 0x7F,
  0x83, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3F,
  0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7F, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3E, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x07, 0xE7, 0xFE,
  0x0F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0x83, 0xFD,
  0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF,
  0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x7F, 0x01, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0x80,
  0x7E, 0x1F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xC3, 0xFF,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7E, 0x0F, 0xFE, 0xFC,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x03, 0xF8,
  0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0xE0, 0xFF, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x03, 0x81, 0xE7, 0x70, 0x78, 0x7E,
  0x77, 0x07, 0x0F, 0xFE, 0x70, 0xE1, 0xE3, 0xE7, 0x0E, 0x3C, 0x3E, 0x71,
  0xC7, 0x83, 0xC7, 0x1C, 0x70, 0x3C, 0x73, 0xCF, 0x03, 0x87, 0x38, 0xE0,
  0x38, 0x73, 0x9E, 0x07, 0x8E, 0x39, 0xC0, 0x70, 0xE7, 0x3C, 0x07, 0x0E,
  0x73, 0xC0, 0xE1, 0xC7, 0x38, 0x0E, 0x1C, 0x73, 0x81, 0xE1, 0xCF, 0x38,
  0x1C, 0x38, 0xE3, 0x83, 0xC3, 0x8E, 0x38, 0x7C, 0x70, 0xE3, 0xCF, 0xCE,
  0x0E, 0x3F, 0xDF, 0xE0, 0xE3, 0xF9, 0xFC, 0x0F, 0x1E, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x03,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x9F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x80, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF0, 0x7F, 0x87, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xF8, 0x3F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7E,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x1F,
  0xC0, 0x10, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xFD, 0xFC, 0x1F, 0xFE, 0xFE, 0x0F, 0xFF,
  0x7F, 0x0F, 0xFF, 0xBF, 0x87, 0xFF, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07,
  0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xFE, 0x01, 0xF8, 0x7F, 0x83,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xDE, 0x0F,
  0xF8, 0x3E, 0xF0, 0xF7, 0xC1, 0xF7, 0x87, 0xBC, 0x0F, 0xBC, 0x7F, 0xE0,
  0x7D, 0xE3, 0xDF, 0x03, 0xEF, 0x3E, 0xF8, 0x3E, 0x79, 0xE7, 0xC1, 0xF3,
  0xCF, 0x7C, 0x0F, 0x9E, 0xF3, 0xE0, 0x7C, 0xF7, 0x9F, 0x03, 0xE7, 0xFC,
  0xF8, 0x3E, 0x3F, 0xC7, 0xC1, 0xF1, 0xFE, 0x7C, 0x0F, 0x8F, 0xE3, 0xE0,
  0x7C, 0x7F, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x1F, 0x0F, 0x87, 0xC1, 0xF0,
  0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0xFF, 0x00, 0xFC, 0x1F,
  0xF0, 0x1F, 0x83, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0xFC, 0x1F, 0xF8, 0x1F,
  0x83, 0xFF, 0x03, 0xF0, 0x7F, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0x81, 0xF7,
  0xC3, 0xF0, 0x7E, 0xF8, 0x7E, 0x0F, 0xDF, 0x0F, 0xC1, 0xFB, 0xE1, 0xF8,
  0x3F, 0x7E, 0x3E, 0x07, 0xC7, 0xCF, 0xC1, 0xF8, 0xF9, 0xF8, 0x3F, 0x1F,
  0x3F, 0x07, 0xE3, 0xE7, 0xE0, 0xFC, 0x7E, 0xF8, 0x1F, 0x8F, 0xDF, 0x03,
  0xE0, 0xFB, 0xE0, 0xFC, 0x1F, 0x7C, 0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x7F,
  0xF0, 0x7E, 0x0F, 0xFC, 0x0F, 0x80, 0xFF, 0x83, 0xF0, 0x1F, 0xF0, 0x7E,
  0x03, 0xFE, 0x0F, 0xC0, 0x7F, 0xC1, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x3F,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F,
  0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07,
  0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x7F, 0x80, 0xFE,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x7F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF1, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0x3F, 0x80, 0x07, 0xE7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0,
  0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0,
  0x7F, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x7E, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xF0,
  0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xE0, 0xFC, 0x7E, 0x1F, 0x07, 0xE7, 0xF1,
  0xF8, 0x3E, 0x3F, 0x8F, 0x81, 0xF3, 0xFE, 0x7C, 0x0F, 0x9F, 0xF7, 0xE0,
  0x7D, 0xFF, 0xBE, 0x03, 0xEF, 0x7D, 0xF0, 0x1F, 0x7B, 0xFF, 0x80, 0xFF,
  0xDF, 0xF8, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x1F, 0xF8,
  0xFF, 0xFD, 0xFF, 0x7F, 0xF9, 0xFF, 0x3F, 0xF1, 0xFE, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xF8, 0x03, 0xF3, 0xFF, 0x03, 0xFB, 0xFF, 0xC1, 0xFB,
  0xFF, 0xE0, 0xFF, 0x87, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3,
  0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x3F,
  0x0F, 0xF0, 0x3F, 0x87, 0xFC, 0x3F, 0x83, 0xFF, 0xFF, 0x83, 0xFB, 0xFF,
  0x81, 0xF8, 0xFF, 0x80, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x3F, 0x80, 0xFF, 0xCF, 0xE0, 0x7F, 0xFB, 0xF0, 0x3F,
  0xFE, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xBF, 0x00, 0xFF, 0xCF, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x7F,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0x7F,
  0x87, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x3F, 0xF3, 0xF0, 0x1F, 0xFE, 0xFC, 0x0F, 0xFF, 0xFF, 0x07,
  0xF8, 0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE0,
  0xFE, 0x07, 0xF8, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xEF,
  0xC0, 0x3F, 0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3C, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x07, 0xF3, 0xFF, 0x03,
  0xF3, 0xFF, 0xC1, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC,
  0x7F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x03,
  0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x06, 0x03,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC7, 0x83,
  0xE0, 0x79, 0xFC, 0xFF, 0x07, 0xBF, 0xCF, 0xF0, 0xFB, 0xFD, 0xFF, 0x0F,
  0xE7, 0xF1, 0xF0, 0xFC, 0x7F, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7E,
  0x1F, 0x1F, 0x87, 0xC1, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x07, 0xC3, 0xE1,
  0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F,
  0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C,
  0x3E, 0x1F, 0x07, 0xC7, 0xE1, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0xC1,
  0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xFC, 0x3E, 0x0F,
  0x80, 0x0F, 0xC0, 0xFC, 0x07, 0xE1, 0xFF, 0x03, 0xF3, 0xFF, 0xC1, 0xFB,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0xC0, 0xFE, 0x3F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x03,
  0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x7F, 0x3F, 0xE0, 0x0F, 0xCF, 0xFE, 0x01, 0xFB, 0xFF,
  0xE0, 0x3F, 0xE1, 0xFC, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x83, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFF, 0x0F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xEF, 0xFF, 0x01, 0xF8, 0xFF, 0x80, 0x3F, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0xFF, 0x9F, 0x81, 0xFF, 0xEF, 0xC1, 0xFF, 0xF7, 0xE1, 0xFE,
  0x1F, 0xF0, 0xFE, 0x0F, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xC0, 0x7F, 0xE7,
  0xE0, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFF, 0x0F, 0xC3, 0xFE, 0x0F, 0xCF, 0xFE, 0x0F, 0xDF, 0xFE,
  0x0F, 0xDF, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x0F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xF1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0x81, 0xFF, 0xCF, 0xC0, 0x7F, 0xC7, 0xE0,
  0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0,
  0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xE3,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8,
  0x1E, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0x87, 0xF1,
  0xF0, 0xF8, 0x7F, 0x1F, 0x0F, 0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x3E, 0x0F,
  0x9E, 0xF3, 0xE0, 0xF9, 0xEF, 0x3E, 0x0F, 0xBC, 0xF7, 0xC0, 0xFB, 0xCF,
  0x7C, 0x0F, 0xF8, 0xF7, 0x80, 0xFF, 0x87, 0x78, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFC, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF6, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0,
};

const GFXglyph LiberationMono_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 30, 28, 8, -30 },
  { 50, 18, 14, 28, 8, -33 },
  { 82, 27, 30, 28, 1, -30 },
  { 184, 26, 37, 28, 1, -33 },
  { 305, 31, 30, 28, -1, -30 },
  { 422, 26, 30, 28, 0, -30 },
  { 520, 8, 14, 28, 13, -33 },
  { 534, 18, 43, 28, 7, -33 },
  { 631, 18, 43, 28, 3, -33 },
  { 728, 18, 17, 28, 7, -33 },
  { 767, 23, 23, 28, 2, -27 },
  { 834, 14, 15, 28, 2, -7 },
  { 861, 14, 5, 28, 7, -15 },
  { 870, 8, 7, 28, 8, -7 },
  { 877, 30, 33, 28, 0, -33 },
  { 1001, 23, 30, 28, 3, -30 },
  { 1088, 23, 30, 28, 1, -30 },
  { 1175, 27, 30, 28, 0, -30 },
  { 1277, 26, 30, 28, 1, -30 },
  { 1375, 26, 30, 28, 0, -30 },
  { 1473, 26, 30, 28, 1, -30 },
  { 1571, 23, 30, 28, 3, -30 },
  { 1658, 23, 30, 28, 5, -30 },
  { 1745, 25, 30, 28, 2, -30 },
  { 1839, 24, 30, 28, 2, -30 },
  { 1929, 11, 25, 28, 8, -25 },
  { 1964, 17, 33, 28, 3, -25 },
  { 2035, 23, 25, 28, 2, -28 },
  { 2107, 23, 17, 28, 2, -24 },
  { 2156, 23, 25, 28, 2, -28 },
  { 2228, 24, 30, 28, 3, -30 },
  { 2318, 28, 39, 28, 0, -33 },
  { 2455, 27, 30, 28, -2, -30 },
  { 2557, 26, 30, 28, 1, -30 },
  { 2655, 26, 30, 28, 2, -30 },
  { 2753, 26, 30, 28, 1, -30 },
  { 2851, 27, 30, 28, 1, -30 },
  { 2953, 27, 30, 28, 1, -30 },
  { 3055, 25, 30, 28, 2, -30 },
  { 3149, 27, 30, 28, 1, -30 },
  { 3251, 27, 30, 28, 1, -30 },
  { 3353, 24, 30, 28, 2, -30 },
  { 3443, 30, 30, 28, 1, -30 },
  { 3556, 22, 30, 28, 2, -30 },
  { 3639, 29, 30, 28, 0, -30 },
  { 3748, 27, 30, 28, 1, -30 },
  { 3850, 25, 30, 28, 2, -30 },
  { 3944, 27, 30, 28, 1, -30 },
  { 4046, 25, 39, 28, 2, -30 },
  { 4168, 27, 30, 28, 1, -30 },
  { 4270, 27, 30, 28, 0, -30 },
  { 4372, 26, 30, 28, 4, -30 },
  { 4470, 26, 30, 28, 2, -30 },
  { 4568, 27, 30, 28, 4, -30 },
  { 4670, 29, 30, 28, 2, -30 },
  { 4779, 32, 30, 28, -2, -30 },
  { 4899, 27, 30, 28, 4, -30 },
  { 5001, 28, 30, 28, 0, -30 },
  { 5106, 22, 43, 28, 4, -33 },
  { 5225, 17, 33, 28, 6, -33 },
  { 5296, 22, 43, 28, 1, -33 },
  { 5415, 25, 20, 28, 1, -32 },
  { 5478, 28, 2, 28, -3, 3 },
  { 5485, 10, 6, 28, 12, -33 },
  { 5493, 24, 25, 28, 1, -25 },
  { 5568, 25, 33, 28, 1, -33 },
  { 5672, 24, 25, 28, 2, -25 },
  { 5747, 26, 33, 28, 2, -33 },
  { 5855, 24, 25, 28, 2, -25 },
  { 5930, 25, 33, 28, 4, -33 },
  { 6034, 26, 35, 28, 1, -25 },
  { 6148, 25, 33, 28, 1, -33 },
  { 6252, 24, 33, 28, 0, -33 },
  { 6351, 25, 43, 28, -1, -33 },
  { 6486, 26, 33, 28, 2, -33 },
  { 6594, 24, 33, 28, 0, -33 },
  { 6693, 28, 25, 28, -1, -25 },
  { 6781, 25, 25, 28, 1, -25 },
  { 6860, 24, 25, 28, 2, -25 },
  { 6935, 27, 35, 28, -1, -25 },
  { 7054, 25, 35, 28, 2, -25 },
  { 7164, 24, 25, 28, 3, -25 },
  { 7239, 23, 25, 28, 2, -25 },
  { 7311, 20, 31, 28, 5, -31 },
  { 7389, 25, 25, 28, 2, -25 },
  { 7468, 26, 25, 28, 3, -25 },
  { 7550, 28, 25, 28, 2, -25 },
  { 7638, 29, 25, 28, -1, -25 },
  { 7729, 30, 35, 28, -1, -25 },
  { 7861, 24, 25, 28, 1, -25 },
  { 7936, 24, 43, 28, 4, -33 },
  { 8065, 6, 43, 28, 11, -33 },
  { 8098, 24, 43, 28, 0, -33 },
  { 8227, 25, 7, 28, 2, -19 },
};

const GFXfont LiberationMono_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic46pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _LIBERATIONMONO_BOLDITALIC46PT7B_H_
