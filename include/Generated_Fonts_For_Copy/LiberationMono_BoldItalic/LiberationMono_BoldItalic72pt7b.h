#ifndef _LIBERATIONMONO_BOLDITALIC72PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF,
  0xC7, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x83, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF1,
  0xEF, 0xFF, 0x80, 0x3F, 0xF0, 0x78, 0xFF, 0xE0, 0x1F, 0xF8, 0x1C, 0x1F,
  0xF8, 0x07, 0xFC, 0x0F, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3C, 0x08, 0x00, 0x0F, 0xF8,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xE1, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x9F, 0xFF, 0x80, 0x00, 0x01, 0xE1, 0xFF, 0xE0, 0x00, 0x00,
  0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x3C, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x01,
  0xFF, 0x80, 0x7C, 0x03, 0xC0, 0x7F, 0xE3, 0xFF, 0x00, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x38, 0x07, 0xFC, 0x3F, 0xF0, 0x1E, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0x80, 0xFF, 0xC1, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x78,
  0x3F, 0xF8, 0x1F, 0xFF, 0x1C, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x87, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC7, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC7, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF1, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0xFE,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF3, 0xFE, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0x81,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x03, 0xFE, 0x07, 0xFC, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x8F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF7, 0xF8, 0x1F, 0xE0,
  0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0xF0, 0x5F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x07, 0xF0, 0x10, 0xF0, 0xFE, 0x0F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xFF, 0xF7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF,
  0xC0, 0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xC0, 0x3C,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF3, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF,
  0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xF3, 0xFF, 0x0F, 0xE1, 0xFF, 0x9F, 0xF8, 0xFF, 0x0F, 0xF9,
  0xFF, 0x87, 0xF8, 0xFF, 0xCF, 0xFC, 0x3F, 0xC7, 0xFE, 0x7F, 0xE1, 0xFC,
  0x3F, 0xF3, 0xFF, 0x0F, 0xE1, 0xFF, 0x9F, 0xF8, 0xFF, 0x0F, 0xFD, 0xFF,
  0x87, 0xF8, 0xFF, 0xCF, 0xFC, 0x3F, 0xC7, 0xFE, 0x7F, 0xE0, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x40, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xF8,
  0x00, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFF, 0x00, 0x7F,
  0xE7, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F,
  0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xBF,
  0xF0, 0x07, 0xFF, 0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xC0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x07,
  0xFC, 0x7D, 0xF0, 0x0F, 0x80, 0xFF, 0xE7, 0xDF, 0x01, 0xF0, 0x1F, 0xFE,
  0xF9, 0xF0, 0x1F, 0x03, 0xF1, 0xEF, 0x9F, 0x03, 0xE0, 0x7C, 0x0F, 0xF1,
  0xF0, 0x3E, 0x0F, 0x80, 0xFF, 0x1F, 0x07, 0xC1, 0xF8, 0x07, 0xF1, 0xF0,
  0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x07, 0x83, 0xE0, 0x0F, 0xE1, 0xF0, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x0F, 0x87, 0xC0, 0x0F, 0xC1, 0xE0, 0xF0, 0xFC,
  0x00, 0xFC, 0x1E, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE1, 0xF1, 0xF8, 0x01,
  0xF8, 0x3E, 0x1E, 0x1F, 0x80, 0x1F, 0x83, 0xE3, 0xE1, 0xF0, 0x01, 0xF0,
  0x3C, 0x3E, 0x3F, 0x00, 0x3F, 0x07, 0xC3, 0xE3, 0xF0, 0x03, 0xE0, 0x7C,
  0x3E, 0x3E, 0x00, 0x3E, 0x07, 0x87, 0xC3, 0xE0, 0x07, 0xE0, 0x78, 0x7C,
  0x7E, 0x00, 0x7C, 0x0F, 0x87, 0xC7, 0xE0, 0x0F, 0xC0, 0xF0, 0x7C, 0x7E,
  0x00, 0xF8, 0x1F, 0x07, 0xC7, 0xC0, 0x1F, 0x81, 0xF0, 0x7C, 0x7C, 0x01,
  0xF8, 0x1E, 0x07, 0x87, 0xC0, 0x3F, 0x03, 0xE0, 0xF8, 0x7C, 0x03, 0xF0,
  0x7C, 0x0F, 0x87, 0xC0, 0x7F, 0x07, 0x80, 0xF8, 0x7E, 0x0E, 0xF0, 0xF8,
  0x0F, 0x87, 0xE3, 0xCF, 0x1F, 0x00, 0xF8, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F,
  0x83, 0xFF, 0x0F, 0xFC, 0x00, 0x7C, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x02, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFE,
  0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x00, 0x03,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xFF, 0xCF,
  0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xF1,
  0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0x7F, 0x03, 0xFB,
  0xF8, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC1, 0xFD, 0xFE,
  0x01, 0xFE, 0xFE, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x00,
  0x7F, 0xBF, 0x87, 0xF7, 0xF8, 0x03, 0xF9, 0xFC, 0x3F, 0xBF, 0xC0, 0x1F,
  0xCF, 0xF3, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x9F, 0xCF, 0xF0, 0x0F, 0xF3,
  0xFD, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xEF, 0xE7, 0xF8, 0x03, 0xFC, 0x7F,
  0x7E, 0x3F, 0xC0, 0x1F, 0xC3, 0xF7, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xBF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xFF, 0x87,
  0xF8, 0x03, 0xFC, 0x3F, 0xFC, 0x3F, 0xC0, 0x1F, 0xC1, 0xFF, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00,
  0x7F, 0x83, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8,
  0x0F, 0xF8, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF3, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xC7, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F,
  0xC7, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x7F, 0x80,
  0x3F, 0xF0, 0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0x0F, 0xFB, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xFE, 0x3F, 0xE0, 0x0F,
  0xF1, 0xFF, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0x8F, 0xF0, 0x03, 0xFC,
  0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0x7F,
  0x7F, 0x3F, 0xC0, 0x0F, 0xFB, 0xFB, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0x8F,
  0xDF, 0xE0, 0x03, 0xFD, 0xFC, 0x7E, 0xFF, 0x00, 0x1F, 0xFF, 0xC3, 0xF7,
  0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF9,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xF7, 0xFF, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0xF0, 0x01, 0xFF,
  0x8F, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFF,
  0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0xFC, 0x00,
  0x7F, 0xC3, 0xFF, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF,
  0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x1F,
  0xF8, 0x00, 0x7F, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC1, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x06, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xE3, 0xFE, 0x00, 0x3F, 0xFF, 0xFD, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xF7,
  0xFE, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x7F, 0xE0,
  0x00, 0x7F, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0xFC,
  0x01, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xF8, 0x07, 0xFE,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC3, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x7F,
  0xE1, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0x3F, 0xFE, 0x01, 0xFD, 0xFF, 0xF3,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFC, 0x7F, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7,
  0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xFF, 0x81, 0xFF, 0xBE, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xC0,
  0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0x8F, 0xFF, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE1, 0xFF, 0xF0, 0x03,
  0xFE, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x7F, 0xEF,
  0xFF, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF,
  0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0x80,
  0x01, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF,
  0xFF, 0x01, 0xFF, 0x1F, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF, 0xFF, 0xC0, 0x7F,
  0xDF, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x20, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x1E, 0xFF, 0x80, 0x7F,
  0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0xCF,
  0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x01,
  0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFF, 0x01, 0xFE,
  0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFF, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xFF, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xDF, 0x87, 0xF8, 0x07, 0xF0, 0xFD,
  0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xDF, 0x8F, 0xF0, 0x07, 0xF1, 0xF9, 0xF8,
  0xFF, 0x00, 0x7F, 0x3F, 0x9F, 0x8F, 0xE0, 0x0F, 0xF3, 0xF1, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xE0, 0xFD, 0xFC, 0x00,
  0xFE, 0xFC, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0C, 0xFF, 0xFF, 0xFE, 0x00, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x03, 0xFF, 0xFF, 0xF9,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph LiberationMono_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 19, 47, 43, 13, -47 },
  { 113, 29, 23, 43, 12, -52 },
  { 197, 43, 47, 43, 1, -47 },
  { 450, 42, 59, 43, 1, -53 },
  { 760, 49, 49, 43, -2, -48 },
  { 1061, 42, 48, 43, -1, -47 },
  { 1313, 13, 23, 43, 20, -52 },
  { 1351, 28, 67, 43, 11, -52 },
  { 1586, 28, 67, 43, 4, -52 },
  { 1821, 27, 27, 43, 12, -52 },
  { 1913, 36, 36, 43, 4, -42 },
  { 2075, 21, 23, 43, 3, -11 },
  { 2136, 22, 9, 43, 11, -23 },
  { 2161, 12, 11, 43, 13, -11 },
  { 2178, 47, 53, 43, -1, -52 },
  { 2490, 37, 49, 43, 4, -48 },
  { 2717, 36, 47, 43, 2, -47 },
  { 2929, 41, 48, 43, 1, -48 },
  { 3175, 40, 49, 43, 2, -48 },
  { 3420, 40, 47, 43, 1, -47 },
  { 3655, 40, 48, 43, 2, -47 },
  { 3895, 37, 49, 43, 4, -48 },
  { 4122, 36, 47, 43, 8, -47 },
  { 4334, 40, 49, 43, 2, -48 },
  { 4579, 38, 49, 43, 3, -48 },
  { 4812, 17, 38, 43, 13, -38 },
  { 4893, 26, 50, 43, 5, -38 },
  { 5056, 36, 39, 43, 4, -43 },
  { 5232, 36, 27, 43, 4, -37 },
  { 5354, 36, 39, 43, 4, -43 },
  { 5530, 37, 48, 43, 5, -48 },
  { 5752, 44, 62, 43, 0, -52 },
  { 6093, 44, 47, 43, -4, -47 },
  { 6352, 41, 47, 43, 1, -47 },
  { 6593, 40, 49, 43, 3, -48 },
  { 6838, 41, 47, 43, 1, -47 },
  { 7079, 43, 47, 43, 1, -47 },
  { 7332, 42, 47, 43, 2, -47 },
  { 7579, 39, 49, 43, 3, -48 },
  { 7818, 43, 47, 43, 1, -47 },
  { 8071, 41, 47, 43, 2, -47 },
  { 8312, 38, 48, 43, 3, -47 },
  { 8540, 47, 47, 43, 1, -47 },
  { 8817, 33, 47, 43, 4, -47 },
  { 9011, 45, 47, 43, 0, -47 },
  { 9276, 43, 47, 43, 1, -47 },
  { 9529, 40, 49, 43, 3, -48 },
  { 9774, 42, 47, 43, 1, -47 },
  { 10021, 40, 62, 43, 3, -48 },
  { 10331, 43, 47, 43, 1, -47 },
  { 10584, 43, 49, 43, 0, -48 },
  { 10848, 41, 47, 43, 6, -47 },
  { 11089, 40, 48, 43, 4, -47 },
  { 11329, 43, 47, 43, 6, -47 },
  { 11582, 45, 47, 43, 4, -47 },
  { 11847, 51, 47, 43, -4, -47 },
  { 12147, 43, 47, 43, 6, -47 },
  { 12400, 45, 47, 43, -1, -47 },
  { 12665, 35, 67, 43, 6, -52 },
  { 12959, 26, 53, 43, 10, -52 },
  { 13132, 35, 67, 43, 2, -52 },
  { 13426, 39, 31, 43, 1, -50 },
  { 13578, 44, 3, 43, -5, 4 },
  { 13595, 17, 10, 43, 18, -52 },
  { 13617, 37, 40, 43, 2, -39 },
  { 13802, 40, 53, 43, 1, -52 },
  { 14067, 37, 40, 43, 3, -39 },
  { 14252, 41, 53, 43, 3, -52 },
  { 14524, 37, 40, 43, 3, -39 },
  { 14709, 40, 53, 43, 6, -53 },
  { 14974, 42, 54, 43, 1, -39 },
  { 15258, 39, 52, 43, 1, -52 },
  { 15512, 38, 52, 43, 0, -52 },
  { 15759, 39, 67, 43, -2, -52 },
  { 16086, 42, 52, 43, 2, -52 },
  { 16359, 38, 52, 43, 0, -52 },
  { 16606, 44, 39, 43, -1, -39 },
  { 16821, 39, 39, 43, 1, -39 },
  { 17012, 38, 40, 43, 3, -39 },
  { 17202, 42, 54, 43, -1, -39 },
  { 17486, 39, 54, 43, 3, -39 },
  { 17750, 37, 39, 43, 5, -39 },
  { 17931, 38, 40, 43, 2, -39 },
  { 18121, 31, 49, 43, 8, -48 },
  { 18311, 39, 39, 43, 3, -38 },
  { 18502, 41, 38, 43, 5, -38 },
  { 18697, 44, 38, 43, 3, -38 },
  { 18906, 46, 38, 43, -2, -38 },
  { 19125, 47, 53, 43, -1, -38 },
  { 19437, 39, 38, 43, 1, -38 },
  { 19623, 37, 67, 43, 6, -52 },
  { 19933, 9, 68, 43, 17, -52 },
  { 20010, 37, 67, 43, 0, -52 },
  { 20320, 39, 11, 43, 3, -30 },
};

const GFXfont LiberationMono_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic72pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _LIBERATIONMONO_BOLDITALIC72PT7B_H_
