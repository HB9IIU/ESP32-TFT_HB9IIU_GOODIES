#ifndef _NOTOSANS_MEDIUM7PT7B_H_
#define _NOTOSANS_MEDIUM7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xB4, 0x5F, 0x6F, 0x60, 0x7C, 0x65, 0xE0, 0xCA, 0xCE, 0x8D,
  0x48, 0x63, 0x1B, 0x27, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0x4F, 0x60,
  0x4F, 0x40, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x69, 0x99, 0x60, 0xF5, 0x40,
  0xE1, 0x24, 0xF0, 0xE1, 0x61, 0xE0, 0x26, 0x6F, 0x20, 0x68, 0x61, 0xE0,
  0x68, 0xE9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60, 0x69, 0xF1, 0x60,
  0x90, 0x98, 0x3C, 0x30, 0xFF, 0xC3, 0xC0, 0xE5, 0x24, 0x39, 0x5A, 0xEF,
  0x40, 0xE0, 0x23, 0x14, 0xE9, 0x80, 0xF7, 0xDE, 0x78, 0x88, 0x70, 0xE9,
  0x99, 0xE0, 0xEE, 0xC0, 0xEE, 0x80, 0x7C, 0x27, 0x17, 0x80, 0x99, 0xF9,
  0x90, 0xD5, 0xC0, 0x55, 0x70, 0xBB, 0x6A, 0x92, 0x4E, 0x8C, 0xF7, 0xDA,
  0x80, 0x9D, 0xDB, 0x90, 0x74, 0x63, 0x17, 0x00, 0xF7, 0xC8, 0x74, 0x63,
  0x17, 0x0C, 0xF7, 0x6A, 0x68, 0x61, 0xE0, 0xF4, 0x44, 0x40, 0x99, 0x99,
  0xE0, 0x99, 0x56, 0x20, 0x93, 0x69, 0xB3, 0x64, 0x80, 0x96, 0x26, 0x90,
  0x96, 0x62, 0x20, 0xF2, 0x44, 0xF0, 0xFC, 0x91, 0x22, 0xD5, 0x70, 0x46,
  0x90, 0xE0, 0xC0, 0x67, 0xF0, 0x9A, 0xDE, 0x72, 0x30, 0x17, 0x99, 0x70,
  0x69, 0xE6, 0x79, 0x24, 0x79, 0x97, 0x16, 0x9E, 0xDA, 0xF8, 0xFE, 0x97,
  0x6A, 0xF8, 0xDD, 0x6B, 0x50, 0xF6, 0xD0, 0x69, 0x96, 0xD6, 0xF9, 0x00,
  0x79, 0x97, 0x11, 0xEA, 0x78, 0xF0, 0x59, 0x26, 0xB6, 0xF0, 0x9A, 0x64,
  0xA6, 0xE5, 0x92, 0x96, 0x6B, 0x9A, 0x64, 0x48, 0xE5, 0x70, 0x57, 0x50,
  0xFE, 0xC9, 0x35, 0x80, 0xF0,
};

const GFXglyph NotoSans_Medium7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 3, 2, 3, 0, -5 },
  { 3, 4, 5, 5, 0, -5 },
  { 6, 4, 5, 4, 0, -5 },
  { 9, 6, 5, 6, 0, -5 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 1, 2, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 2, 6, 2, 0, -5 },
  { 22, 4, 3, 4, 0, -5 },
  { 24, 4, 3, 4, 0, -4 },
  { 26, 1, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 2, 5, 4, 1, -5 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 1, 4, 2, 0, -4 },
  { 61, 1, 5, 2, 0, -4 },
  { 62, 4, 3, 4, 0, -4 },
  { 64, 4, 2, 4, 0, -3 },
  { 65, 4, 3, 4, 0, -4 },
  { 67, 3, 5, 3, 0, -5 },
  { 69, 6, 6, 6, 0, -5 },
  { 74, 5, 5, 5, 0, -5 },
  { 78, 3, 5, 5, 1, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 5, 1, -5 },
  { 86, 2, 5, 4, 1, -5 },
  { 88, 2, 5, 4, 1, -5 },
  { 90, 5, 5, 5, 0, -5 },
  { 94, 4, 5, 5, 1, -5 },
  { 97, 2, 5, 2, 0, -5 },
  { 99, 2, 6, 2, -1, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 3, 5, 4, 1, -5 },
  { 105, 5, 5, 6, 1, -5 },
  { 109, 4, 5, 5, 1, -5 },
  { 112, 5, 5, 5, 0, -5 },
  { 116, 3, 5, 4, 1, -5 },
  { 118, 5, 6, 5, 0, -5 },
  { 122, 3, 5, 4, 1, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 4, 5, 5, 1, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 7, 5, 7, 0, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 4, 5, 4, 0, -5 },
  { 147, 4, 5, 4, 0, -5 },
  { 150, 1, 6, 2, 1, -5 },
  { 151, 3, 5, 3, 0, -5 },
  { 153, 2, 6, 2, 0, -5 },
  { 155, 4, 3, 4, 0, -5 },
  { 157, 3, 1, 3, 0, 0 },
  { 158, 2, 1, 2, 0, -5 },
  { 159, 3, 4, 4, 0, -4 },
  { 161, 3, 5, 4, 1, -5 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 4, 4, 4, 0, -4 },
  { 170, 3, 5, 3, 0, -5 },
  { 172, 4, 6, 4, 0, -4 },
  { 175, 3, 5, 4, 1, -5 },
  { 177, 1, 5, 2, 0, -5 },
  { 178, 1, 7, 2, 0, -5 },
  { 179, 3, 5, 4, 1, -5 },
  { 181, 1, 5, 2, 0, -5 },
  { 182, 5, 4, 7, 1, -4 },
  { 185, 3, 4, 4, 1, -4 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 3, 6, 4, 1, -4 },
  { 192, 4, 6, 4, 0, -4 },
  { 195, 2, 4, 3, 1, -4 },
  { 196, 3, 4, 3, 0, -4 },
  { 198, 3, 5, 3, 0, -5 },
  { 200, 3, 4, 4, 1, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 6, 4, 6, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 6, 4, 0, -4 },
  { 212, 3, 4, 3, 0, -4 },
  { 214, 2, 6, 3, 0, -5 },
  { 216, 1, 7, 4, 1, -5 },
  { 217, 3, 6, 3, 0, -5 },
  { 220, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Medium7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium7pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_MEDIUM7PT7B_H_
