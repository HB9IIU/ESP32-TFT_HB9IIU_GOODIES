#ifndef _NOTOSANS_MEDIUM40PT7B_H_
#define _NOTOSANS_MEDIUM40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0xF7, 0xFF, 0xFF, 0x90, 0xF1, 0xFF, 0x1F, 0xF1,
  0xEF, 0x1E, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x03, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83,
  0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xC7, 0x0C, 0xF8,
  0xE0, 0x1E, 0x1C, 0x03, 0xE3, 0x80, 0x7C, 0x70, 0x07, 0xEE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xBF, 0x00, 0x71, 0xF0, 0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0xFE, 0x07,
  0x1E, 0xFE, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0xFF, 0x00, 0x1C, 0x07, 0xFE, 0x00, 0xF0, 0x1C, 0x78, 0x07, 0x80, 0xF0,
  0xE0, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x0E, 0x0F, 0x03, 0x80, 0x38, 0x1C,
  0x1E, 0x00, 0xE0, 0x70, 0x70, 0x03, 0x81, 0xC3, 0xC0, 0x0E, 0x07, 0x0E,
  0x00, 0x38, 0x3C, 0x78, 0x20, 0xF0, 0xF3, 0xC7, 0xE3, 0xC3, 0x8E, 0x3F,
  0xC7, 0x1E, 0x79, 0xFF, 0x9F, 0xF9, 0xC7, 0x0F, 0x3F, 0xCF, 0x3C, 0x3C,
  0x7C, 0x38, 0xF0, 0x70, 0x01, 0xE3, 0xC1, 0xC0, 0x07, 0x0E, 0x07, 0x00,
  0x3C, 0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x70, 0x07, 0x03, 0xC1, 0xC0, 0x3C,
  0x0F, 0x07, 0x00, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0x70, 0xF0, 0x1C, 0x01,
  0xFF, 0x80, 0xF0, 0x03, 0xFC, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x01, 0xF0,
  0xFF, 0xE0, 0x3E, 0x3E, 0x7E, 0x07, 0x8F, 0x87, 0xE0, 0xF3, 0xE0, 0x7E,
  0x3E, 0x7C, 0x07, 0xE7, 0x8F, 0x00, 0x7F, 0xF1, 0xE0, 0x07, 0xFC, 0x3E,
  0x00, 0x7F, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x03, 0xFE, 0x0F, 0xE1, 0xFF,
  0xE0, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xC7, 0xE0, 0xFF, 0xE0, 0x7E, 0xFF,
  0xFF, 0xFF, 0xEE, 0xEE, 0xE0, 0x07, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0xC1, 0xE0,
  0x78, 0x3C, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x30, 0x70, 0x3F, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x38, 0x03, 0xCF,
  0x01, 0xE1, 0xE0, 0xF8, 0x7C, 0x1C, 0x1E, 0x01, 0x02, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7D, 0xF7,
  0xDE, 0x79, 0xEF, 0x3C, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x90, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0x0F,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3E,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x3C, 0x07, 0x87, 0xE3, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x1F, 0x03, 0xF0,
  0xFF, 0x1F, 0xF3, 0xEF, 0xFC, 0xF7, 0x8F, 0x30, 0xF2, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0x80, 0xF8, 0x60, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0x00, 0xF8,
  0x40, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x80, 0x07, 0xDE,
  0x03, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00,
  0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3D, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x80,
  0x0F, 0xDF, 0x07, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFD, 0xC1, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x7E, 0x0F, 0x3F, 0xF1, 0xEF, 0xFF, 0x3F, 0xC3, 0xF7, 0xE0,
  0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0xE1,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0x9F, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x8F, 0x81, 0xFF, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x3F, 0x8F, 0x81, 0xFB,
  0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x87,
  0xC0, 0xF9, 0xF0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xDF,
  0x03, 0xFB, 0xFF, 0xEF, 0x3F, 0xFD, 0xE1, 0xFE, 0x3C, 0x04, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x08, 0x0F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x77,
  0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF,
  0xFC, 0x80, 0x1C, 0x7C, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x70,
  0xE3, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x03, 0xF8,
  0x1E, 0x38, 0x0F, 0xFE, 0x0E, 0x78, 0x1F, 0xFE, 0x0E, 0x78, 0x3C, 0x0E,
  0x0F, 0x70, 0x78, 0x0E, 0x0F, 0x70, 0x70, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E,
  0x07, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E,
  0x0E, 0xF0, 0xF0, 0x1E, 0x0E, 0xF0, 0xF0, 0x1E, 0x0E, 0xF0, 0x78, 0x3E,
  0x1E, 0x70, 0x7C, 0x7F, 0x3C, 0x70, 0x3F, 0xE7, 0xF8, 0x78, 0x1F, 0xC3,
  0xF0, 0x78, 0x02, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x78, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF,
  0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xC0, 0x38, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x08, 0x3F, 0xE3, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0xFF, 0x1E, 0x00, 0x7E, 0x3C, 0x00,
  0x3E, 0x78, 0x00, 0x7E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0x78,
  0x00, 0xF8, 0xF0, 0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0x0E, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3F, 0x00,
  0x0F, 0x1F, 0x80, 0x0F, 0x0F, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x07, 0xDF, 0xFB, 0xFE, 0x7F, 0x87, 0xC0, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xBC, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0,
  0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x7C, 0x01,
  0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFD, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x07,
  0xC7, 0x80, 0x1F, 0x3C, 0x00, 0xFD, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1D, 0xFE,
  0xE0, 0x01, 0xEF, 0xF7, 0x80, 0x0E, 0x7F, 0xBC, 0x00, 0xF3, 0xFC, 0xF0,
  0x07, 0x9F, 0xE7, 0x80, 0x38, 0xFF, 0x3C, 0x03, 0xC7, 0xF8, 0xF0, 0x1E,
  0x3F, 0xC7, 0x80, 0xE1, 0xFE, 0x3C, 0x0F, 0x0F, 0xF0, 0xF0, 0x78, 0x7F,
  0x87, 0x87, 0x83, 0xFC, 0x1C, 0x3C, 0x1F, 0xE0, 0xF1, 0xC0, 0xFF, 0x07,
  0x9E, 0x07, 0xF8, 0x1C, 0xF0, 0x3F, 0xC0, 0xF7, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x1F,
  0xE0, 0x1F, 0x00, 0xFF, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFB, 0xE0, 0x07, 0xF3, 0xC0, 0x0F, 0xF7, 0xC0, 0x1F, 0xE7, 0xC0,
  0x3F, 0xCF, 0x80, 0x7F, 0x8F, 0x80, 0xFF, 0x0F, 0x81, 0xFE, 0x1F, 0x03,
  0xFC, 0x1F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3E, 0x1F, 0xE0, 0x3E, 0x3F,
  0xC0, 0x7C, 0x7F, 0x80, 0x7C, 0xFF, 0x00, 0x7D, 0xFE, 0x00, 0xFB, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x03,
  0xF0, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x01, 0xFE, 0x3F, 0xE0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF0, 0x1F, 0xBC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x1F, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFC, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00,
  0x7C, 0x1F, 0x80, 0x3F, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x01, 0xFC, 0x78, 0x03, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0x83, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x80, 0x03,
  0xFC, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7C, 0x03, 0x9E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x0F, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xBE, 0x00, 0x3E, 0x7C, 0x01, 0xF8, 0xFE, 0x1F, 0xC3, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xE1, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xC0, 0x03, 0xDE, 0x00,
  0x3E, 0x00, 0x3E, 0xF8, 0x01, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0xC0, 0x0F,
  0x1E, 0x00, 0xFE, 0x00, 0x78, 0xF0, 0x07, 0xF8, 0x07, 0xC7, 0xC0, 0x3B,
  0xC0, 0x3C, 0x3E, 0x03, 0xDE, 0x01, 0xE0, 0xF0, 0x1E, 0x78, 0x0F, 0x07,
  0x80, 0xF3, 0xC0, 0xF8, 0x3E, 0x0F, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0xF0,
  0x3C, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x3C, 0x1E, 0x1E, 0x1F, 0x01, 0xF1,
  0xE0, 0xF0, 0xF0, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x0F, 0x3C, 0x07, 0x9E, 0x00, 0x3D, 0xE0,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x07, 0xB8, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x81,
  0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xF7,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x81,
  0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x83, 0xC0, 0x1F,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0x80,
  0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0E, 0x70, 0x00, 0xF3, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x78, 0x03, 0x81, 0xC0, 0x1C, 0x0F, 0x01, 0xE0,
  0x38, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x3C, 0x78, 0x00, 0xE7,
  0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x7C,
  0xFE, 0x18, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7C, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFD, 0xFF,
  0xEF, 0x7F, 0xF3, 0xC7, 0xF8, 0x70, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0xFC, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFE, 0x07, 0xCF, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0xFF,
  0x0F, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF, 0x0F, 0x1F, 0xE0, 0x01, 0xFC, 0x07,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x02, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0x3F, 0x07, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x03, 0xF1, 0xF0, 0xFF, 0xDF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7E,
  0x07, 0xF7, 0xC0, 0x3F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x3F, 0x0F,
  0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0x7F, 0x8F, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xCF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9E, 0x00,
  0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x08, 0xFC, 0x07, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0x70, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xFF, 0xFF, 0x3E, 0x07,
  0xF7, 0xC0, 0x3F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x3F, 0x0F, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x40, 0x03, 0xE3, 0x00, 0x7C, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xE0, 0x7D, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E,
  0xFF, 0xBF, 0xCF, 0xE1, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xE1,
  0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x1E, 0xF8, 0x03,
  0xDF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xF9, 0xF0, 0x3E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0x7D, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0xFC, 0x03, 0xF0, 0xF3, 0xFF, 0x1F, 0xF8, 0xF7, 0xFF, 0xBF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFE, 0x07, 0xF0, 0x3E, 0xFC, 0x07, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x0F,
  0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F,
  0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F,
  0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F,
  0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F,
  0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0xFE, 0x1E, 0x7F, 0xE3, 0xDF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xE0, 0x7D, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x03, 0xE7, 0xC0, 0x1E,
  0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80,
  0x1F, 0x7C, 0x01, 0xE3, 0xC0, 0x3E, 0x3F, 0x07, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x3F, 0xE0, 0xF0, 0xFC, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFE, 0x07, 0xCF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0xC0,
  0x7E, 0xFF, 0x0F, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF, 0x0F, 0x1F, 0xE0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xFF, 0xFF, 0x7E, 0x07,
  0xF7, 0xC0, 0x3F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x3F, 0x0F, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x8F, 0xFC,
  0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xF0, 0x3F, 0xFE,
  0x7F, 0xFE, 0xFC, 0x7C, 0xF0, 0x04, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x23, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFD, 0xF8, 0x7F, 0xBF, 0xFE, 0xF3, 0xFF,
  0xDE, 0x3F, 0xE3, 0xC0, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xDE, 0x00, 0x3C,
  0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x78, 0x07, 0xE0, 0x1F, 0x78, 0x07,
  0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x3C, 0x07, 0xF0, 0x3E, 0x3C, 0x0F,
  0xF0, 0x3C, 0x3C, 0x0F, 0x70, 0x3C, 0x3E, 0x0E, 0x78, 0x3C, 0x1E, 0x1E,
  0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x38, 0x78, 0x0F, 0x1C,
  0x3C, 0x78, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F, 0x38,
  0x1C, 0xF0, 0x07, 0xB8, 0x1E, 0xF0, 0x07, 0xF8, 0x1E, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x7C,
  0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x9F, 0x00,
  0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBE, 0x00, 0xF9, 0xF0, 0x1F, 0x0F,
  0x01, 0xE0, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xEF, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF8, 0x01, 0xE3,
  0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1F, 0x0F, 0x00, 0x78, 0xF8, 0x03,
  0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x08, 0x07, 0xC0, 0xFE, 0x07, 0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0xFE, 0x07, 0xC0, 0x3F, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x7E,
  0x07, 0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0xFF, 0x07, 0xF0,
  0x3E, 0x00, 0x3F, 0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8,
  0x07, 0xFD, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 30, 11, 3, -29 },
  { 20, 12, 11, 17, 3, -29 },
  { 37, 24, 29, 26, 1, -29 },
  { 124, 19, 32, 23, 2, -30 },
  { 200, 30, 29, 34, 2, -29 },
  { 309, 27, 29, 29, 2, -29 },
  { 407, 4, 11, 9, 3, -29 },
  { 413, 9, 35, 12, 2, -29 },
  { 453, 10, 35, 12, 1, -29 },
  { 497, 18, 18, 22, 2, -30 },
  { 538, 19, 20, 23, 2, -24 },
  { 586, 6, 10, 11, 2, -5 },
  { 594, 10, 4, 13, 1, -13 },
  { 599, 5, 6, 11, 3, -5 },
  { 603, 15, 29, 15, 0, -29 },
  { 658, 19, 29, 23, 2, -29 },
  { 727, 12, 29, 23, 3, -29 },
  { 771, 19, 29, 23, 2, -29 },
  { 840, 19, 29, 23, 2, -29 },
  { 909, 21, 29, 23, 1, -29 },
  { 986, 19, 29, 23, 2, -29 },
  { 1055, 19, 29, 23, 2, -29 },
  { 1124, 19, 29, 23, 2, -29 },
  { 1193, 19, 29, 23, 2, -29 },
  { 1262, 19, 29, 23, 2, -29 },
  { 1331, 5, 23, 11, 3, -22 },
  { 1346, 7, 27, 11, 1, -22 },
  { 1370, 19, 21, 23, 2, -25 },
  { 1420, 19, 11, 23, 2, -20 },
  { 1447, 19, 21, 23, 2, -25 },
  { 1497, 17, 30, 18, 0, -29 },
  { 1561, 32, 32, 36, 2, -29 },
  { 1689, 26, 29, 26, 0, -29 },
  { 1784, 20, 29, 26, 4, -29 },
  { 1857, 22, 29, 25, 2, -29 },
  { 1937, 23, 29, 29, 4, -29 },
  { 2021, 16, 29, 22, 4, -29 },
  { 2079, 16, 29, 21, 4, -29 },
  { 2137, 24, 29, 29, 2, -29 },
  { 2224, 22, 29, 30, 4, -29 },
  { 2304, 11, 29, 14, 2, -29 },
  { 2344, 11, 37, 12, -3, -29 },
  { 2395, 21, 29, 25, 4, -29 },
  { 2472, 16, 29, 21, 4, -29 },
  { 2530, 29, 29, 37, 4, -29 },
  { 2636, 23, 29, 31, 4, -29 },
  { 2720, 27, 29, 31, 2, -29 },
  { 2818, 18, 29, 24, 4, -29 },
  { 2884, 27, 36, 31, 2, -29 },
  { 3006, 21, 29, 25, 4, -29 },
  { 3083, 18, 29, 22, 2, -29 },
  { 3149, 21, 29, 22, 1, -29 },
  { 3226, 22, 29, 30, 4, -29 },
  { 3306, 25, 29, 25, 0, -29 },
  { 3397, 37, 29, 38, 0, -29 },
  { 3532, 24, 29, 24, 0, -29 },
  { 3619, 23, 29, 23, 0, -29 },
  { 3703, 21, 29, 23, 1, -29 },
  { 3780, 9, 35, 13, 3, -29 },
  { 3820, 15, 29, 15, 0, -29 },
  { 3875, 9, 35, 13, 1, -29 },
  { 3915, 21, 18, 23, 1, -29 },
  { 3963, 17, 2, 17, 0, 4 },
  { 3968, 9, 7, 12, 2, -31 },
  { 3976, 18, 22, 23, 2, -22 },
  { 4026, 20, 30, 25, 3, -30 },
  { 4101, 16, 22, 20, 2, -22 },
  { 4145, 20, 30, 25, 2, -30 },
  { 4220, 19, 22, 23, 2, -22 },
  { 4273, 15, 31, 14, 1, -31 },
  { 4332, 20, 32, 25, 2, -22 },
  { 4412, 19, 30, 25, 3, -30 },
  { 4484, 5, 30, 11, 3, -30 },
  { 4503, 10, 40, 11, -2, -30 },
  { 4553, 19, 30, 22, 3, -30 },
  { 4625, 5, 30, 11, 3, -30 },
  { 4644, 32, 22, 38, 3, -22 },
  { 4732, 19, 22, 25, 3, -22 },
  { 4785, 20, 22, 24, 2, -22 },
  { 4840, 20, 32, 25, 3, -22 },
  { 4920, 20, 32, 25, 2, -22 },
  { 5000, 13, 22, 17, 3, -22 },
  { 5036, 16, 22, 19, 2, -22 },
  { 5080, 13, 26, 15, 1, -26 },
  { 5123, 19, 22, 25, 3, -22 },
  { 5176, 21, 22, 21, 0, -22 },
  { 5234, 32, 22, 32, 0, -22 },
  { 5322, 20, 22, 22, 1, -22 },
  { 5377, 21, 32, 21, 0, -22 },
  { 5461, 17, 22, 19, 1, -22 },
  { 5508, 13, 35, 15, 1, -29 },
  { 5565, 4, 39, 22, 9, -30 },
  { 5585, 13, 35, 15, 1, -29 },
  { 5642, 19, 6, 23, 2, -17 },
};

const GFXfont NotoSans_Medium40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium40pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_MEDIUM40PT7B_H_
