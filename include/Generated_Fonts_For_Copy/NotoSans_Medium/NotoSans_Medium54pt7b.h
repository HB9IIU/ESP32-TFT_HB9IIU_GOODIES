#ifndef _NOTOSANS_MEDIUM54PT7B_H_
#define _NOTOSANS_MEDIUM54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xE3, 0xC0, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0xFC, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x07, 0x9F, 0x03, 0xCF,
  0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xEE, 0x7F, 0x1F, 0x87, 0x03, 0x9F, 0x83, 0x80,
  0x0F, 0xC1, 0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xF0, 0x70, 0x01, 0xF8, 0x38,
  0x00, 0xFE, 0x1C, 0x00, 0x3F, 0xCE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x7F, 0x80, 0x07, 0x0F, 0xE0,
  0x03, 0x83, 0xF0, 0x01, 0xC1, 0xF8, 0x00, 0xE0, 0xFC, 0x00, 0x70, 0x7F,
  0x00, 0x38, 0x3F, 0xE0, 0x1C, 0x3F, 0x7F, 0x8F, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xFE,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3C, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80,
  0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x78,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x81, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0x01,
  0xE0, 0x3E, 0x1F, 0x07, 0x80, 0x78, 0x0F, 0x8F, 0x87, 0xF8, 0x1F, 0x03,
  0xC3, 0xE3, 0xFF, 0x87, 0xC1, 0xF1, 0xF1, 0xFF, 0xE0, 0xF8, 0xFC, 0x7C,
  0xFC, 0xFC, 0x3F, 0xFE, 0x3E, 0x3E, 0x0F, 0x07, 0xFF, 0x8F, 0x0F, 0x03,
  0xE0, 0xFF, 0x87, 0xC7, 0xC0, 0xF8, 0x1F, 0xC3, 0xE1, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x78,
  0x00, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC1, 0xFF, 0xFC, 0x00, 0xFC,
  0x1F, 0xEF, 0xF0, 0x07, 0xE0, 0xFE, 0x3F, 0xC0, 0x3F, 0x0F, 0xE0, 0xFF,
  0x03, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0x87, 0xE0, 0x0F, 0xF0, 0xFC, 0x3F,
  0x00, 0x1F, 0xCF, 0xC1, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x01, 0xFF,
  0xE0, 0x7E, 0x00, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xF0,
  0x1F, 0xFC, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF,
  0xE1, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x79, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x80, 0x3C, 0x01, 0x78, 0x1E, 0x0F, 0xBF, 0xCF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0,
  0x1F, 0x03, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xC7,
  0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0x80,
  0x07, 0xE7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x3F, 0xDF, 0x7F, 0x1F, 0xFE, 0x3F, 0x7C,
  0x3F, 0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xE0, 0x03, 0xF0, 0x60, 0x00, 0xFE, 0x10,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0xC3,
  0x80, 0x03, 0xF0, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xB8, 0x00, 0x1F, 0xEF, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x7F, 0x70, 0x00, 0x7F, 0x3F, 0x81,
  0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFF, 0x80, 0xF8, 0xFF, 0xF8,
  0x3E, 0x7F, 0xFF, 0x0F, 0xBF, 0xFF, 0xE3, 0xFF, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F,
  0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFD, 0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xDF, 0xC0, 0x07, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7,
  0xF0, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xF7, 0xC7, 0xFF, 0xFD,
  0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0xFE, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x01, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x39,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8E, 0x00, 0x0E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xF0, 0x0F, 0xE6, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0xFC, 0x07, 0xC3, 0xE0, 0x0F, 0xFF, 0xE0,
  0x78, 0x7C, 0x03, 0xFF, 0xFC, 0x0F, 0x9F, 0x00, 0xFF, 0xFF, 0x80, 0xF3,
  0xE0, 0x3F, 0x01, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x3E, 0x03, 0xCF, 0x01,
  0xF0, 0x07, 0xC0, 0x7B, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0x80,
  0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x03, 0xE0, 0x3F, 0xF0, 0x3E, 0x00, 0x7C,
  0x07, 0xBC, 0x07, 0x80, 0x0F, 0x00, 0xF7, 0x80, 0xF0, 0x01, 0xE0, 0x1E,
  0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xDF, 0x03, 0xE0, 0x0F, 0x80, 0xFB, 0xE0,
  0x7C, 0x01, 0xF0, 0x1E, 0x7C, 0x0F, 0xC0, 0x7F, 0x07, 0xCF, 0x80, 0xFC,
  0x1F, 0xE1, 0xF0, 0xF0, 0x1F, 0xFF, 0xDF, 0xFE, 0x1F, 0x01, 0xFF, 0xF3,
  0xFF, 0x83, 0xE0, 0x1F, 0xFC, 0x3F, 0xE0, 0x7C, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0x1F, 0xF8,
  0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xEF, 0xC0,
  0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0x00, 0x03, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0xFF,
  0xF8, 0x3F, 0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07,
  0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x3F, 0x00,
  0x01, 0xFE, 0x7E, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x1F, 0xE1, 0xF8, 0x01,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x7C, 0x0F, 0xF8,
  0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x3F, 0x0F, 0xF8,
  0x00, 0x3F, 0x07, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xB0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xEE, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7F,
  0xF0, 0xFF, 0x80, 0x30, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xBF, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xC0,
  0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0xBF, 0xF7,
  0xE0, 0x00, 0x1F, 0x7F, 0xE7, 0xC0, 0x00, 0x7C, 0xFF, 0xCF, 0x80, 0x00,
  0xF9, 0xFF, 0x8F, 0x80, 0x01, 0xF3, 0xFF, 0x1F, 0x00, 0x07, 0xC7, 0xFE,
  0x3E, 0x00, 0x0F, 0x8F, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0xF8, 0x7C, 0x00,
  0x7C, 0x3F, 0xF0, 0xFC, 0x00, 0xF8, 0x7F, 0xE0, 0xF8, 0x03, 0xE0, 0xFF,
  0xC1, 0xF0, 0x07, 0xC1, 0xFF, 0x83, 0xF0, 0x0F, 0x83, 0xFF, 0x03, 0xE0,
  0x3E, 0x07, 0xFE, 0x07, 0xC0, 0x7C, 0x0F, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F,
  0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0xF0, 0x1F, 0x07, 0xC0, 0x7F, 0xE0, 0x3F,
  0x0F, 0x80, 0xFF, 0xC0, 0x3E, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x7C, 0x03,
  0xFF, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xF0,
  0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0x3F, 0xF9, 0xFC,
  0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x3F, 0xF8, 0x7F,
  0x00, 0x3F, 0xF8, 0x3F, 0x80, 0x3F, 0xF8, 0x1F, 0x80, 0x3F, 0xF8, 0x1F,
  0xC0, 0x3F, 0xF8, 0x0F, 0xC0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x07,
  0xF0, 0x3F, 0xF8, 0x03, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x3F, 0xF8, 0x01,
  0xFC, 0x3F, 0xF8, 0x00, 0xFC, 0x3F, 0xF8, 0x00, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0x1F, 0xF8, 0x00, 0x7F, 0x1F, 0xF8, 0x00, 0x3F, 0x9F, 0xF8, 0x00,
  0x1F, 0x9F, 0xF8, 0x00, 0x1F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x7F, 0xFB, 0xF0, 0x03, 0xFD,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00,
  0x3F, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x01,
  0xFF, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF8, 0x3F, 0x03, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0,
  0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0x80, 0x7C, 0x7E, 0x00, 0x0C, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0xFF, 0xCF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0xA0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE,
  0x7F, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0xCF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xA0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0x83, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x00, 0xFC,
  0x3F, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x7C,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x80,
  0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1E, 0xF8, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x0F, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0xF8, 0x18, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xBF, 0xC0, 0x0F, 0xDF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0xDF,
  0xFF, 0xFB, 0xE7, 0xFF, 0xF9, 0xF1, 0xFF, 0xF8, 0xF8, 0x3F, 0xF0, 0x7C,
  0x01, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xC0, 0x0F, 0xC3, 0xFF, 0x01, 0xF9,
  0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x1F, 0xF0, 0x07, 0xF3, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xFC, 0x00,
  0x7E, 0x7F, 0xC0, 0x1F, 0xCF, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xFE, 0x3E,
  0x7F, 0xFF, 0x87, 0xC7, 0xFF, 0xE0, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0x83, 0xE3, 0xF8, 0x01, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x08, 0xFF, 0xC3,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0xF0, 0x3F, 0x03, 0xFF, 0x8F, 0xC1, 0xFF, 0xF3,
  0xF0, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0xDF, 0x3F, 0xE0, 0xFF, 0xCF, 0xE0,
  0x0F, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0xFD, 0xF0, 0xFF, 0xFE, 0x7C, 0x1F, 0xFF,
  0x1F, 0x03, 0xFF, 0x07, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFE, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0x0F, 0xF8, 0x0F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x28, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xCE, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xE1, 0xF0, 0x7F, 0xFC, 0x7C, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF,
  0xF7, 0xCF, 0xF0, 0x3F, 0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x7E,
  0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF,
  0x7C, 0x3F, 0xFF, 0xBF, 0x07, 0xFF, 0xCF, 0xC0, 0x7F, 0xE3, 0xF0, 0x01,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x20, 0x00, 0x3F, 0x8F, 0x00, 0x1F,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0xFC, 0x3F, 0xF8, 0x3F,
  0x3F, 0xFF, 0x0F, 0xDF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF,
  0xBF, 0xE0, 0x0F, 0xEF, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x79, 0xFB, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF0, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xCF, 0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x01,
  0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x3F,
  0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xBF,
  0x00, 0x3F, 0xC7, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x1F, 0x07, 0xFE, 0x01, 0xFF, 0xC3, 0xE3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xBF, 0xE0, 0x1F, 0xF8,
  0x03, 0xF7, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x3E, 0x0F, 0xFE,
  0x0F, 0x8F, 0xFF, 0xE3, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8,
  0x3F, 0xEF, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x07, 0xFE, 0x03,
  0xE3, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1,
  0xFE, 0x3F, 0xE0, 0x0F, 0xE7, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xF7, 0xF8,
  0x00, 0xFC, 0xFF, 0x80, 0x3F, 0x9F, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7E, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xC1, 0xF8, 0x7F, 0xE0, 0x3F, 0x01,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xE1, 0xF0, 0x7F, 0xFC, 0x7C, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0xF7, 0xCF,
  0xF0, 0x3F, 0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F,
  0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x3F, 0xF1, 0xFF, 0xFF, 0x7C, 0x3F,
  0xFF, 0xBF, 0x07, 0xFF, 0xCF, 0xC0, 0xFF, 0xC3, 0xF0, 0x01, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xBE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0x00, 0xF3, 0xF0, 0x00, 0x9F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x03, 0xF7, 0xC0, 0x3F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC1, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0x7F, 0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFB, 0xE3, 0xFF, 0xF8,
  0xF0, 0x7F, 0xF0, 0x78, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x01, 0xF9, 0xF0, 0x01, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0xFF, 0x80, 0x1F, 0x9F, 0x80, 0x3F, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x7C,
  0x03, 0xF0, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x3F, 0x01, 0xF3, 0xC0, 0x3F,
  0x0F, 0xC0, 0x7C, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0x8F, 0x81, 0xF8, 0x1F, 0x83, 0xE1, 0xF0, 0x7C, 0x07, 0xE0, 0xF8,
  0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x07, 0xC3,
  0xF0, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x00,
  0x7C, 0xF8, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x07, 0xEF,
  0x80, 0x7D, 0xF0, 0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x07,
  0xDF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF1, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xBF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xF9, 0x00, 0x01, 0xF0,
};

const GFXglyph NotoSans_Medium54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 40, 15, 4, -39 },
  { 36, 17, 14, 23, 3, -39 },
  { 66, 33, 39, 35, 1, -39 },
  { 227, 25, 44, 31, 3, -41 },
  { 365, 42, 40, 46, 2, -39 },
  { 575, 37, 40, 40, 3, -39 },
  { 760, 6, 14, 13, 3, -39 },
  { 771, 13, 48, 17, 2, -39 },
  { 849, 13, 48, 17, 2, -39 },
  { 927, 25, 25, 30, 2, -41 },
  { 1006, 25, 26, 31, 3, -32 },
  { 1088, 9, 13, 15, 2, -6 },
  { 1103, 13, 5, 17, 2, -17 },
  { 1112, 7, 8, 15, 4, -7 },
  { 1119, 20, 39, 21, 0, -39 },
  { 1217, 26, 40, 31, 2, -39 },
  { 1347, 16, 39, 31, 4, -39 },
  { 1425, 26, 39, 31, 2, -39 },
  { 1552, 26, 40, 31, 2, -39 },
  { 1682, 29, 39, 31, 1, -39 },
  { 1824, 25, 40, 31, 3, -39 },
  { 1949, 26, 40, 31, 3, -39 },
  { 2079, 27, 39, 31, 2, -39 },
  { 2211, 26, 40, 31, 2, -39 },
  { 2341, 26, 40, 31, 2, -39 },
  { 2471, 7, 31, 15, 4, -30 },
  { 2499, 9, 37, 15, 2, -30 },
  { 2541, 25, 27, 31, 3, -33 },
  { 2626, 25, 16, 31, 3, -27 },
  { 2676, 25, 27, 31, 3, -33 },
  { 2761, 22, 40, 24, 1, -39 },
  { 2871, 43, 44, 49, 3, -39 },
  { 3108, 35, 39, 35, 0, -39 },
  { 3279, 28, 39, 35, 5, -39 },
  { 3416, 30, 40, 34, 3, -39 },
  { 3566, 31, 39, 39, 5, -39 },
  { 3718, 22, 39, 30, 5, -39 },
  { 3826, 22, 39, 29, 5, -39 },
  { 3934, 32, 40, 39, 3, -39 },
  { 4094, 30, 39, 40, 5, -39 },
  { 4241, 15, 39, 19, 2, -39 },
  { 4315, 15, 50, 16, -4, -39 },
  { 4409, 29, 39, 34, 5, -39 },
  { 4551, 22, 39, 29, 5, -39 },
  { 4659, 39, 39, 50, 5, -39 },
  { 4850, 32, 39, 42, 5, -39 },
  { 5006, 36, 40, 42, 3, -39 },
  { 5186, 25, 39, 33, 5, -39 },
  { 5308, 36, 48, 42, 3, -39 },
  { 5524, 29, 39, 34, 5, -39 },
  { 5666, 24, 40, 30, 3, -39 },
  { 5786, 29, 39, 30, 1, -39 },
  { 5928, 30, 40, 40, 5, -39 },
  { 6078, 33, 39, 33, 0, -39 },
  { 6239, 50, 39, 51, 0, -39 },
  { 6483, 33, 39, 33, 0, -39 },
  { 6644, 32, 39, 32, 0, -39 },
  { 6800, 27, 39, 31, 2, -39 },
  { 6932, 12, 48, 18, 4, -39 },
  { 7004, 20, 39, 21, 0, -39 },
  { 7102, 13, 48, 18, 1, -39 },
  { 7180, 27, 25, 31, 2, -39 },
  { 7265, 24, 3, 23, 0, 5 },
  { 7274, 12, 8, 17, 2, -41 },
  { 7286, 25, 31, 31, 2, -30 },
  { 7383, 27, 42, 33, 4, -41 },
  { 7525, 22, 31, 27, 3, -30 },
  { 7611, 26, 42, 33, 3, -41 },
  { 7748, 25, 31, 31, 3, -30 },
  { 7845, 21, 41, 19, 1, -41 },
  { 7953, 26, 43, 33, 3, -30 },
  { 8093, 26, 41, 34, 4, -41 },
  { 8227, 7, 40, 15, 4, -40 },
  { 8262, 14, 53, 15, -3, -40 },
  { 8355, 26, 41, 30, 4, -41 },
  { 8489, 6, 41, 15, 4, -41 },
  { 8520, 43, 30, 51, 4, -30 },
  { 8682, 26, 30, 34, 4, -30 },
  { 8780, 27, 31, 33, 3, -30 },
  { 8885, 27, 43, 33, 4, -30 },
  { 9031, 26, 43, 33, 3, -30 },
  { 9171, 18, 30, 23, 4, -30 },
  { 9239, 21, 31, 26, 3, -30 },
  { 9321, 18, 37, 21, 1, -36 },
  { 9405, 25, 30, 34, 4, -29 },
  { 9499, 28, 29, 28, 0, -29 },
  { 9601, 42, 29, 44, 1, -29 },
  { 9754, 28, 29, 29, 1, -29 },
  { 9856, 29, 42, 29, 0, -29 },
  { 10009, 22, 29, 26, 2, -29 },
  { 10089, 18, 48, 21, 1, -39 },
  { 10197, 4, 54, 30, 13, -41 },
  { 10224, 17, 48, 21, 2, -39 },
  { 10326, 25, 8, 31, 3, -23 },
};

const GFXfont NotoSans_Medium54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium54pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_MEDIUM54PT7B_H_
