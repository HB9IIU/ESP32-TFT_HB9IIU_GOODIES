#ifndef _NOTOSANS_MEDIUM32PT7B_H_
#define _NOTOSANS_MEDIUM32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFF, 0xC0, 0xF3, 0xF8, 0xFE, 0x3F, 0x8E, 0xE1, 0xB8, 0x66,
  0x19, 0x86, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xE1, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x18, 0x01, 0xC3, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x1E, 0x01, 0xFF, 0xE7, 0xFF, 0xDF, 0x67, 0x38, 0xC0, 0x71, 0x80,
  0xE3, 0x01, 0xE6, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0x8E, 0x03, 0x1E, 0x06, 0x3E, 0x0C, 0x77, 0xDF, 0xEF, 0xFF,
  0x9F, 0xFE, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1F, 0x00,
  0x70, 0x1F, 0xC0, 0x38, 0x1C, 0xE0, 0x38, 0x0E, 0x38, 0x1C, 0x06, 0x1C,
  0x1C, 0x07, 0x0E, 0x0C, 0x03, 0x87, 0x0E, 0x01, 0xC3, 0x8E, 0x00, 0xE1,
  0xC7, 0x00, 0x30, 0xE7, 0x1E, 0x1C, 0x73, 0xBF, 0x8E, 0x73, 0x9D, 0xE3,
  0xF9, 0xDC, 0x30, 0xF9, 0xCE, 0x1C, 0x00, 0xC7, 0x0E, 0x00, 0xE3, 0x87,
  0x00, 0xE1, 0xC3, 0x80, 0x70, 0xE1, 0xC0, 0x70, 0x70, 0xE0, 0x38, 0x38,
  0x60, 0x38, 0x0E, 0x70, 0x1C, 0x07, 0xF8, 0x1C, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x3C, 0x00,
  0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x1C, 0x7F, 0xE0, 0xF3, 0xE7, 0xC3,
  0xCF, 0x0F, 0x8E, 0x38, 0x1F, 0x78, 0xE0, 0x3F, 0xC3, 0x80, 0x3F, 0x0F,
  0x00, 0xF8, 0x3C, 0x07, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xE3, 0xC1, 0xFE,
  0x07, 0xC0, 0xFE, 0xEE, 0xEE, 0x66, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0x70,
  0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38,
  0x70, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x04, 0x18, 0x7F,
  0xBF, 0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0xC0, 0x0D, 0xC0, 0x3B, 0xC0, 0xF3,
  0x83, 0xC7, 0x81, 0x86, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x39, 0xDE,
  0xF7, 0x39, 0x9C, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xE0, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x1C,
  0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0x87, 0xC7, 0xE7, 0xF7, 0xBF,
  0x9D, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xFC, 0x78, 0x3E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC,
  0x70, 0x3E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0xC0, 0x1E, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x0E, 0x78, 0x0E, 0x3C, 0x07,
  0x1E, 0x07, 0x0F, 0x07, 0x07, 0x83, 0x83, 0xC3, 0x81, 0xE3, 0x80, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF4, 0x03, 0xEF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xCF, 0xE3, 0xBF, 0xE7, 0xE3, 0xEF,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0,
  0x7B, 0xC1, 0xE3, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x78, 0x0E, 0x38, 0x1E, 0x3C,
  0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78,
  0x1E, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0E, 0x7E,
  0x3E, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78,
  0x3C, 0x70, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0x70,
  0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xEF, 0x03, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x33, 0xF8, 0x3F,
  0xE0, 0x3F, 0xC0, 0x67, 0xBF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xDF, 0xFF, 0x80, 0x31, 0xE7, 0xDE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x9E, 0x79, 0xC7, 0x1C, 0xE3, 0x80, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0x3C, 0x00, 0x60,
  0x00, 0x1F, 0xC3, 0xFF, 0xC7, 0xFF, 0x98, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xFE, 0xFE, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0xE0, 0x7C, 0x1C, 0xE0, 0xFF, 0x86, 0x60, 0xFF, 0xC3, 0xF0, 0xE0,
  0xE1, 0xF8, 0x70, 0x70, 0xFC, 0x70, 0x38, 0x7C, 0x38, 0x1C, 0x3E, 0x1C,
  0x0E, 0x1F, 0x0E, 0x07, 0x0F, 0xC7, 0x07, 0x86, 0xE1, 0xC3, 0xC7, 0x70,
  0xFF, 0x7F, 0x38, 0x3F, 0x1F, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0x71,
  0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x78, 0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0x00,
  0xE0, 0x38, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3C, 0x01,
  0xC1, 0xE0, 0x0F, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x38,
  0x00, 0x3B, 0xC0, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFE, 0xE0,
  0x3E, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x3C, 0xFF, 0xF8, 0xFF, 0xF8, 0xE0, 0xFE, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x23,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x11, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x70,
  0x1F, 0x8E, 0x00, 0xF9, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x00, 0x1E, 0xE0,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1D, 0xC0,
  0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0xF3, 0x80,
  0x3E, 0x70, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x80,
  0x63, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07,
  0x9F, 0x00, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3C, 0xFF, 0xFF, 0xDF, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0xE7, 0xFF, 0xFE, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFE, 0xFE, 0xF8, 0xF0, 0x07, 0xF8,
  0x07, 0xBC, 0x07, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0x81,
  0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xDF, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1E, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x07, 0xFD, 0xC0, 0x1D, 0xFB, 0x80, 0x3B, 0xF7, 0x80, 0x77, 0xE7,
  0x01, 0xCF, 0xCE, 0x03, 0x9F, 0x8E, 0x07, 0x3F, 0x1C, 0x1C, 0x7E, 0x38,
  0x38, 0xFC, 0x38, 0xE1, 0xF8, 0x71, 0xC3, 0xF0, 0xE3, 0x87, 0xE0, 0xEE,
  0x0F, 0xC1, 0xDC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0x81, 0xF8, 0x0E, 0x03, 0x80, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xDE, 0x01, 0xFB, 0xC0, 0x3F,
  0x3C, 0x07, 0xE3, 0x80, 0xFC, 0x78, 0x1F, 0x87, 0x83, 0xF0, 0xF0, 0x7E,
  0x0F, 0x0F, 0xC0, 0xF1, 0xF8, 0x1E, 0x3F, 0x01, 0xE7, 0xE0, 0x1C, 0xFC,
  0x03, 0xDF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x07,
  0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0,
  0x07, 0x9F, 0x00, 0x7C, 0x7C, 0x07, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xF7,
  0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x1F,
  0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x9F, 0x00,
  0x7C, 0x7C, 0x07, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1C, 0x0F, 0x8E, 0x01, 0xE7,
  0x00, 0xF3, 0x80, 0x79, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x1F,
  0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xE0,
  0x78, 0x70, 0x1C, 0x38, 0x0F, 0x1C, 0x03, 0xCE, 0x01, 0xE7, 0x00, 0x7B,
  0x80, 0x1E, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0xBE, 0x06, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xE0,
  0x0F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xEF, 0x00, 0x79, 0xE0, 0x3E, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0x80, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80,
  0x1E, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x3C, 0x03, 0x81, 0xC0, 0x38, 0x1C,
  0x07, 0x81, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x1E, 0x00, 0x79, 0xC0, 0x03, 0x9C, 0x00, 0x3B, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x3D, 0xC0, 0x1E, 0x00, 0xE7, 0x00, 0x78, 0x03,
  0x9E, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x78, 0xE0, 0x3F, 0x01, 0xC3,
  0x81, 0xFE, 0x07, 0x0F, 0x07, 0x38, 0x3C, 0x3C, 0x1C, 0xE0, 0xF0, 0x70,
  0x73, 0x83, 0x81, 0xC3, 0x87, 0x0E, 0x07, 0x8E, 0x1C, 0x78, 0x1E, 0x38,
  0x71, 0xE0, 0x39, 0xE1, 0xE7, 0x00, 0xE7, 0x03, 0x9C, 0x03, 0xDC, 0x0E,
  0xF0, 0x07, 0x70, 0x3B, 0xC0, 0x1D, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xEF, 0x00, 0x78, 0xF0, 0x0E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF0, 0x1E, 0x1C, 0x01, 0xC7, 0x80, 0x3C, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xEF, 0x00, 0x3C, 0xF0, 0x0F, 0x1E, 0x01, 0xC1, 0xE0, 0x78,
  0x1E, 0x1E, 0x03, 0xC3, 0x80, 0x3C, 0xF0, 0x03, 0xBC, 0x00, 0x78, 0xF0,
  0x01, 0xEE, 0x00, 0x79, 0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x3C,
  0x1E, 0x07, 0x83, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x00, 0xF7, 0x80, 0x0E,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xF8, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38,
  0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x0E, 0x70, 0x0E, 0x60, 0x07,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x80, 0x3F, 0xF0, 0xFF, 0xF0, 0xE1, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x0F, 0xFE, 0x7F, 0xFD, 0xE0, 0x7B, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xDC, 0x0F, 0xBE, 0x7F, 0x7F, 0xEE, 0x3F, 0x1C, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x20, 0x73,
  0xF8, 0xFF, 0xF9, 0xF8, 0xFB, 0xC0, 0xF7, 0x80, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x03, 0xDF, 0xFF, 0xBB, 0xFE, 0x63, 0xF8, 0x01, 0x80, 0xFF, 0xCF, 0xFC,
  0xF8, 0xE7, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x2F, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x83, 0x8F, 0xE7, 0x3F, 0xEE, 0xF8, 0xFD, 0xE0, 0x7F, 0x80, 0xFF,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0xF7, 0x81, 0xEF, 0xDF, 0xCF, 0xFB, 0x8F, 0xE7, 0x01, 0x00,
  0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x01, 0x3F, 0xBE, 0x3F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x1E,
  0x21, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x0F, 0xFC, 0xFF, 0xC3, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x02, 0x00, 0x3F, 0x9C,
  0xFF, 0xBB, 0xE3, 0xF7, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xDE, 0x07,
  0xBF, 0x7F, 0x3F, 0xEE, 0x3F, 0x9C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xDC, 0x1F, 0x3F, 0xFE, 0x7F, 0xF0, 0x0F, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x20, 0x73, 0xF8,
  0xFF, 0xF9, 0xF8, 0xFB, 0xC0, 0x77, 0x80, 0xEE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x6F, 0xF7, 0x00, 0x07, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x06, 0x0F, 0x0F, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0xFE,
  0xFE, 0x78, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x1E, 0xE0, 0x79, 0xC1, 0xE3, 0x87, 0x87, 0x1E,
  0x0E, 0x78, 0x1D, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xE7, 0x83,
  0x87, 0x87, 0x0F, 0x0E, 0x0F, 0x1C, 0x0F, 0x38, 0x0F, 0x70, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x20, 0x67,
  0xF8, 0xFF, 0x3F, 0xFE, 0xFF, 0xDF, 0x9F, 0xF1, 0xEF, 0x03, 0xE0, 0x7F,
  0x81, 0xE0, 0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x07,
  0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01, 0xFC, 0x07, 0x80, 0xFE, 0x03, 0xC0,
  0x7F, 0x01, 0xE0, 0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x3C,
  0x07, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0xC1, 0x8F, 0xE3, 0xFF, 0xE7, 0xE3,
  0xEF, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3C, 0x01, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x3C, 0x78,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x3E, 0x7C, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x81, 0xCF, 0xE3, 0xFF, 0xE7, 0xE3, 0xEF, 0x03,
  0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x7F, 0xFE, 0xEF, 0xF9, 0xCF,
  0xE3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0x9C, 0xFF, 0xBB, 0xE3, 0xF7,
  0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xDE, 0x07, 0xBF, 0x7F, 0x3F, 0xEE,
  0x3F, 0x9C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xB1, 0xFE, 0xFF, 0xFF, 0xF8, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xEF, 0x06, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x70,
  0x07, 0x80, 0x7F, 0x1F, 0xFF, 0xEF, 0xF8, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0xFF, 0xFF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xE4, 0x7F, 0x0F, 0xC0, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x03,
  0xDF, 0xBF, 0x9F, 0xFF, 0x1F, 0xC6, 0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x03,
  0xCF, 0x01, 0xC3, 0x80, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x1E,
  0x3C, 0x07, 0x1C, 0x03, 0x9E, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x03, 0xB8, 0x0F,
  0x01, 0xDE, 0x0F, 0xC1, 0xEF, 0x07, 0xE0, 0xE3, 0x83, 0x70, 0x71, 0xC3,
  0x98, 0x38, 0xF1, 0xCE, 0x3C, 0x38, 0xE7, 0x1C, 0x1C, 0xE3, 0x8E, 0x0E,
  0x70, 0xEF, 0x07, 0xB8, 0x77, 0x01, 0xDC, 0x3B, 0x80, 0xFC, 0x1D, 0xC0,
  0x7E, 0x06, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x0F, 0x9E, 0x07, 0x07, 0x07, 0x83, 0xC7, 0x80, 0xF3, 0x80,
  0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xEF, 0x00, 0xE3, 0xC0, 0xF0, 0xE0, 0xF0, 0x78, 0xF0, 0x1E, 0xF8,
  0x07, 0x80, 0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xC7, 0x01, 0xC3, 0x80,
  0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x0E, 0x3C, 0x07, 0x1C, 0x03,
  0xCE, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xC1, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x7C, 0x3E, 0x0F, 0x03, 0xF0, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xF0, 0x7C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x03, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xF8, 0x0F, 0xC0, 0xF8, 0x7E, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x1F, 0x83, 0xE0,
  0x78, 0x00, 0x10, 0x03, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xE8, 0x0F, 0x80,
};

const GFXglyph NotoSans_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 10, 8, 14, 2, -23 },
  { 26, 19, 23, 21, 1, -23 },
  { 81, 15, 26, 18, 2, -24 },
  { 130, 25, 23, 27, 1, -23 },
  { 202, 22, 23, 24, 2, -23 },
  { 266, 4, 8, 8, 2, -23 },
  { 270, 8, 28, 10, 1, -23 },
  { 298, 8, 28, 10, 1, -23 },
  { 326, 15, 14, 18, 1, -24 },
  { 353, 15, 15, 18, 2, -19 },
  { 382, 5, 8, 9, 1, -4 },
  { 387, 8, 3, 10, 1, -10 },
  { 390, 5, 4, 9, 2, -4 },
  { 393, 12, 23, 12, 0, -23 },
  { 428, 16, 23, 18, 1, -23 },
  { 474, 9, 23, 18, 3, -23 },
  { 500, 16, 23, 18, 1, -23 },
  { 546, 16, 23, 18, 1, -23 },
  { 592, 17, 23, 18, 1, -23 },
  { 641, 15, 23, 18, 2, -23 },
  { 685, 15, 23, 18, 2, -23 },
  { 729, 16, 23, 18, 1, -23 },
  { 775, 16, 23, 18, 1, -23 },
  { 821, 16, 23, 18, 1, -23 },
  { 867, 5, 18, 9, 2, -18 },
  { 879, 6, 22, 9, 1, -18 },
  { 896, 15, 16, 18, 2, -20 },
  { 926, 15, 9, 18, 2, -16 },
  { 943, 15, 16, 18, 2, -20 },
  { 973, 14, 23, 14, 0, -23 },
  { 1014, 25, 26, 29, 2, -23 },
  { 1096, 21, 23, 21, 0, -23 },
  { 1157, 16, 23, 21, 3, -23 },
  { 1203, 17, 23, 20, 2, -23 },
  { 1252, 19, 23, 23, 3, -23 },
  { 1307, 13, 23, 18, 3, -23 },
  { 1345, 13, 23, 17, 3, -23 },
  { 1383, 19, 23, 23, 2, -23 },
  { 1438, 18, 23, 24, 3, -23 },
  { 1490, 9, 23, 11, 1, -23 },
  { 1516, 8, 29, 9, -2, -23 },
  { 1545, 17, 23, 20, 3, -23 },
  { 1594, 13, 23, 17, 3, -23 },
  { 1632, 23, 23, 29, 3, -23 },
  { 1699, 19, 23, 25, 3, -23 },
  { 1754, 21, 23, 25, 2, -23 },
  { 1815, 15, 23, 20, 3, -23 },
  { 1859, 21, 28, 25, 2, -23 },
  { 1933, 17, 23, 20, 3, -23 },
  { 1982, 14, 23, 18, 2, -23 },
  { 2023, 18, 23, 18, 0, -23 },
  { 2075, 18, 23, 24, 3, -23 },
  { 2127, 20, 23, 20, 0, -23 },
  { 2185, 30, 23, 30, 0, -23 },
  { 2272, 19, 23, 20, 0, -23 },
  { 2327, 19, 23, 19, 0, -23 },
  { 2382, 16, 23, 18, 1, -23 },
  { 2428, 8, 28, 11, 2, -23 },
  { 2456, 12, 23, 12, 0, -23 },
  { 2491, 7, 28, 11, 1, -23 },
  { 2516, 16, 15, 18, 1, -23 },
  { 2546, 14, 2, 14, 0, 3 },
  { 2550, 8, 6, 10, 1, -25 },
  { 2556, 15, 18, 18, 1, -18 },
  { 2590, 15, 24, 20, 3, -24 },
  { 2635, 13, 18, 16, 2, -18 },
  { 2665, 15, 24, 20, 2, -24 },
  { 2710, 15, 18, 18, 2, -18 },
  { 2744, 12, 24, 11, 1, -24 },
  { 2780, 15, 26, 20, 2, -18 },
  { 2829, 15, 24, 20, 3, -24 },
  { 2874, 4, 24, 9, 2, -24 },
  { 2886, 8, 32, 9, -2, -24 },
  { 2918, 15, 24, 18, 3, -24 },
  { 2963, 3, 24, 9, 3, -24 },
  { 2972, 25, 18, 30, 3, -18 },
  { 3029, 15, 18, 20, 3, -18 },
  { 3063, 16, 18, 20, 2, -18 },
  { 3099, 15, 26, 20, 3, -18 },
  { 3148, 15, 26, 20, 2, -18 },
  { 3197, 10, 18, 14, 3, -18 },
  { 3220, 12, 18, 16, 2, -18 },
  { 3247, 10, 21, 12, 1, -21 },
  { 3274, 15, 17, 20, 2, -17 },
  { 3306, 17, 17, 17, 0, -17 },
  { 3343, 25, 17, 26, 0, -17 },
  { 3397, 17, 17, 17, 0, -17 },
  { 3434, 17, 25, 17, 0, -17 },
  { 3488, 13, 17, 15, 1, -17 },
  { 3516, 10, 28, 12, 1, -23 },
  { 3551, 3, 32, 18, 7, -24 },
  { 3563, 11, 28, 12, 1, -23 },
  { 3602, 15, 5, 18, 2, -14 },
};

const GFXfont NotoSans_Medium32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium32pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_MEDIUM32PT7B_H_
