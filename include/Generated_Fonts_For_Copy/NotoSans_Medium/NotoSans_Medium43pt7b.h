#ifndef _NOTOSANS_MEDIUM43PT7B_H_
#define _NOTOSANS_MEDIUM43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0xCF, 0xBF, 0xFF, 0xFF,
  0x8C, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC1,
  0xDE, 0x0E, 0xF0, 0x77, 0x83, 0x9C, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x03, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7C, 0x70, 0xC7, 0x87,
  0x00, 0xF8, 0x70, 0x0F, 0x87, 0x00, 0x78, 0x70, 0x07, 0xC7, 0x00, 0x7F,
  0x70, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x77, 0xF0, 0x07, 0x1F, 0x00, 0x70, 0xF0, 0x07, 0x0F,
  0x00, 0x70, 0xF8, 0x07, 0x1F, 0xF0, 0x73, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0xF0,
  0x01, 0xE0, 0x1F, 0xF8, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0xF0, 0x0F, 0x07,
  0x00, 0x70, 0x07, 0x83, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x78, 0x01, 0xE0,
  0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x8F, 0x0F, 0x07,
  0x83, 0xC7, 0x1F, 0xE1, 0xC1, 0xC7, 0x9F, 0xF8, 0xF1, 0xE7, 0x8F, 0x3C,
  0x3F, 0xF3, 0xCF, 0x0F, 0x1F, 0xF3, 0xC7, 0x83, 0x83, 0xE1, 0xE3, 0x81,
  0xC0, 0x01, 0xE1, 0xC0, 0xF0, 0x00, 0xF1, 0xE0, 0x78, 0x00, 0xF0, 0xF0,
  0x3C, 0x00, 0x70, 0x78, 0x1E, 0x00, 0x78, 0x1C, 0x0F, 0x00, 0x78, 0x0E,
  0x07, 0x80, 0x3C, 0x07, 0x83, 0x80, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x1F, 0xF0, 0x0F, 0x00,
  0x07, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x7C, 0x1F, 0xFE, 0x01, 0xF0, 0xFC, 0xFC, 0x07, 0x87, 0xE1, 0xF8,
  0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0xF8, 0x07, 0xE7, 0xC3, 0xE0, 0x0F, 0xDF,
  0x0F, 0x80, 0x1F, 0xF8, 0x3E, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x7F, 0x03,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07,
  0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0xC0, 0xE0, 0x2F, 0x8E, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00,
  0xF1, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF8, 0x0E, 0x0F, 0x00, 0x20, 0x40,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x78,
  0xF1, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0xEF, 0xFF, 0xFF,
  0xE2, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xE0, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x00,
  0x3E, 0x78, 0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C,
  0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xE1, 0xE0, 0x1F,
  0x0F, 0x81, 0xF8, 0x3F, 0xBF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xBD,
  0xF9, 0xFF, 0x8F, 0x78, 0xF9, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xC0, 0x7E, 0x18, 0x01, 0xF0, 0x80, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFC, 0x78, 0x07, 0xE2, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xEF, 0xC3,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xE0, 0x01,
  0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0,
  0x7C, 0x03, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x07,
  0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFB, 0x00, 0x3F, 0x7E, 0x3F, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x8F, 0xF0, 0x7D, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF0, 0xFC, 0xFE,
  0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF1, 0xE0,
  0x0F, 0x8F, 0x80, 0xFC, 0x3F, 0x1F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7,
  0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x78, 0x01,
  0xF3, 0xE0, 0x0F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0x81, 0xF9, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xF8, 0xFE,
  0x1F, 0x81, 0xF8, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x7C,
  0xFC, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xE0, 0x7C,
  0x3E, 0x01, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0xFD,
  0xF0, 0x0F, 0xEF, 0xC0, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xF7, 0x83, 0xFF,
  0x3C, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x40, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x33, 0xEF, 0xFF,
  0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3E,
  0xFF, 0xFF, 0xFE, 0x20, 0x1C, 0x3E, 0x3F, 0x3F, 0x3F, 0x3E, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x38,
  0x0F, 0xC8, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x30, 0x07, 0x8F, 0x00, 0xFF, 0xE0, 0xE3, 0xC0, 0xFF, 0xF8,
  0x3C, 0xE0, 0x7F, 0xFE, 0x0F, 0x78, 0x3E, 0x07, 0x81, 0xDE, 0x0F, 0x01,
  0xE0, 0x77, 0x07, 0x80, 0x78, 0x1D, 0xC1, 0xE0, 0x1E, 0x07, 0xF0, 0x78,
  0x07, 0x81, 0xFC, 0x1E, 0x01, 0xE0, 0x7F, 0x07, 0x80, 0x78, 0x1F, 0xC1,
  0xE0, 0x1E, 0x0F, 0xF0, 0x78, 0x0F, 0x83, 0xFC, 0x1E, 0x03, 0xE0, 0xE7,
  0x03, 0xC1, 0xF8, 0x79, 0xE0, 0xFF, 0xEF, 0xFC, 0x78, 0x1F, 0xF9, 0xFE,
  0x1E, 0x03, 0xF8, 0x3F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x0C, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF8, 0x07, 0xF3, 0xE0, 0x07,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x0F,
  0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x03,
  0xC7, 0xF0, 0x00, 0x8F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x30, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0xFF, 0x87, 0xC0, 0x0F, 0xE3, 0xE0,
  0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0xFE, 0x3E, 0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0xE0, 0xFC, 0x00, 0x10,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0x9F,
  0x80, 0x07, 0xC7, 0xF0, 0x03, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFE,
  0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x07,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xE0, 0x00, 0xF7, 0xFB, 0xC0, 0x01, 0xEF,
  0xF7, 0xC0, 0x03, 0xDF, 0xE7, 0x80, 0x0F, 0x3F, 0xCF, 0x00, 0x1E, 0x7F,
  0x8F, 0x00, 0x3C, 0xFF, 0x1E, 0x00, 0xF1, 0xFE, 0x3C, 0x01, 0xE3, 0xFC,
  0x3C, 0x03, 0xC7, 0xF8, 0x78, 0x0F, 0x0F, 0xF0, 0xF8, 0x1E, 0x1F, 0xE0,
  0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0x7F, 0x83, 0xE1, 0xE0, 0xFF, 0x03,
  0xC7, 0x81, 0xFE, 0x07, 0x8F, 0x03, 0xFC, 0x0F, 0x9E, 0x07, 0xF8, 0x0F,
  0x78, 0x0F, 0xF0, 0x1E, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xF8,
  0x03, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xEF, 0x80, 0x0F, 0xF3, 0xE0, 0x07, 0xF9, 0xF0,
  0x03, 0xFC, 0x7C, 0x01, 0xFE, 0x3F, 0x00, 0xFF, 0x0F, 0x80, 0x7F, 0x83,
  0xE0, 0x3F, 0xC1, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x1F, 0x07, 0xF8,
  0x0F, 0x83, 0xFC, 0x03, 0xE1, 0xFE, 0x01, 0xF8, 0xFF, 0x00, 0x7C, 0x7F,
  0x80, 0x1F, 0x3F, 0xC0, 0x0F, 0xDF, 0xE0, 0x03, 0xEF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F,
  0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xEF, 0x80, 0x7E, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0x81, 0xFE, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x07, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x01, 0xC7, 0xC0, 0x04,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3E, 0xE0, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xC0,
  0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x78, 0x00, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x7E,
  0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x7F, 0x00, 0x3E,
  0x3C, 0x00, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0xFF, 0x00, 0x3C, 0x3E, 0x00,
  0xFF, 0x80, 0x3C, 0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x1E, 0x01, 0xE7, 0x80,
  0x7C, 0x1F, 0x01, 0xE7, 0x80, 0x78, 0x1F, 0x01, 0xE7, 0xC0, 0x78, 0x0F,
  0x03, 0xE3, 0xC0, 0xF8, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0x0F, 0x83, 0xC3,
  0xE0, 0xF0, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x07, 0x87, 0x81, 0xE1, 0xF0,
  0x07, 0x87, 0x81, 0xE1, 0xF0, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x07, 0xCF,
  0x80, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0xF3,
  0xE0, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x01,
  0xFE, 0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1E, 0x00,
  0x70, 0x38, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x07, 0x81, 0xE0,
  0x0E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0xE7, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x3E, 0x1F, 0x87, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x60, 0x01, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xE0, 0x7E, 0x20, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xFF, 0x87, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xE1, 0xFE, 0xFF, 0xFB, 0xCF,
  0xFE, 0x38, 0xFF, 0x87, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x03, 0x00, 0xF1, 0xFE, 0x0F, 0x7F, 0xF8, 0xFF, 0xFF,
  0xCF, 0xF0, 0xFE, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0xFC, 0x07, 0xEF, 0xF9, 0xFC, 0xFF, 0xFF, 0xCE, 0x7F, 0xF8,
  0xE1, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0x87, 0x8F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x02,
  0x3F, 0xEF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x02, 0x03, 0xC1,
  0xFF, 0x1E, 0x1F, 0xFC, 0xF1, 0xFF, 0xF7, 0x9F, 0xC3, 0xFC, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0xC7, 0xFC, 0x7F, 0xFD, 0xE1, 0xFF, 0xCF, 0x07, 0xFC, 0x78,
  0x00, 0x30, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0,
  0x7E, 0x1F, 0x00, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF7,
  0xC0, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x41, 0xFE, 0x3E, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE, 0xF3, 0xF8, 0x7F, 0x9F, 0x00,
  0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x7C,
  0x03, 0xF3, 0xF8, 0xFF, 0x8F, 0xFF, 0xBC, 0x3F, 0xF9, 0xE0, 0xFF, 0x8F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x98, 0x01, 0xF8, 0xFF, 0x7F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x01, 0x80, 0xF1, 0xFF, 0x0F, 0x7F, 0xFC, 0xFF, 0xFF, 0xCF,
  0xF0, 0xFE, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xF0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x03, 0x81,
  0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xFD, 0xFF, 0xFE,
  0xFF, 0x3F, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xEF, 0x00, 0xFC, 0xF0, 0x1F, 0x8F,
  0x03, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00,
  0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xDF, 0x80, 0xF8, 0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x03,
  0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x7E, 0xF0,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x71,
  0xFF, 0x83, 0xFE, 0x39, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0xFB, 0xFF, 0xEF,
  0xF0, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x0F, 0xC0, 0x3F,
  0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x03,
  0xFC, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x00,
  0x7F, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC0,
  0x0F, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xF8,
  0x01, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x1F,
  0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x38,
  0x0E, 0x1F, 0xF0, 0xE7, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0,
  0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x70,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF0,
  0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x87, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x0E, 0x1F, 0xF0, 0xF7, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0xFF, 0x9F, 0xCF, 0xFF, 0xFC, 0xF7,
  0xFF, 0x8F, 0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE3, 0xC3, 0xFF,
  0x9E, 0x3F, 0xFE, 0xF3, 0xF8, 0x7F, 0x9F, 0x00, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x03, 0xF3, 0xF8, 0x7F,
  0x8F, 0xFF, 0xBC, 0x3F, 0xF9, 0xE0, 0xFF, 0x8F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3B, 0x87, 0xFE, 0x3F, 0xBD, 0xFE, 0xFF, 0xFB, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0xEF,
  0xFF, 0xEF, 0xC0, 0xF7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xFF,
  0x83, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0xC4, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xF1, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xE7, 0x0F, 0xF8, 0x70, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0xC0, 0x1F,
  0x07, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0xF0, 0x00,
  0xF1, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0xFC, 0x01, 0xF7, 0xC0,
  0x3F, 0x80, 0x79, 0xF0, 0x0F, 0xE0, 0x1E, 0x3C, 0x07, 0xF8, 0x0F, 0x8F,
  0x81, 0xEF, 0x03, 0xE3, 0xE0, 0x7B, 0xC0, 0xF0, 0x78, 0x1C, 0xF0, 0x3C,
  0x1E, 0x0F, 0x3C, 0x1F, 0x07, 0xC3, 0xC7, 0x87, 0xC1, 0xF0, 0xF1, 0xE1,
  0xE0, 0x3C, 0x78, 0x78, 0x78, 0x0F, 0x1E, 0x0F, 0x3E, 0x03, 0xE7, 0x83,
  0xCF, 0x00, 0x79, 0xC0, 0xF3, 0xC0, 0x1E, 0xF0, 0x3C, 0xF0, 0x07, 0xBC,
  0x07, 0xFC, 0x01, 0xEF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xC3, 0xE0, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x01, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C,
  0x01, 0xF1, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF8,
  0x00, 0xF1, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x03, 0xBC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x08, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x03, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x83, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0xFC, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F,
  0x03, 0xFC, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7E,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x17, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x3F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 32, 12, 3, -31 },
  { 25, 13, 11, 18, 3, -31 },
  { 43, 26, 31, 28, 1, -31 },
  { 144, 20, 36, 25, 2, -33 },
  { 234, 33, 31, 37, 2, -31 },
  { 362, 30, 31, 32, 2, -31 },
  { 479, 4, 11, 10, 3, -31 },
  { 485, 10, 38, 13, 2, -31 },
  { 533, 11, 38, 13, 1, -31 },
  { 586, 20, 20, 24, 2, -33 },
  { 636, 20, 21, 25, 2, -26 },
  { 689, 7, 11, 12, 2, -5 },
  { 699, 10, 4, 14, 2, -14 },
  { 704, 6, 7, 12, 3, -6 },
  { 710, 16, 31, 17, 0, -31 },
  { 772, 21, 31, 25, 2, -31 },
  { 854, 13, 31, 25, 3, -31 },
  { 905, 21, 31, 25, 2, -31 },
  { 987, 20, 31, 25, 2, -31 },
  { 1065, 23, 31, 25, 1, -31 },
  { 1155, 19, 31, 25, 3, -31 },
  { 1229, 21, 31, 25, 2, -31 },
  { 1311, 21, 31, 25, 2, -31 },
  { 1393, 21, 31, 25, 2, -31 },
  { 1475, 21, 31, 25, 2, -31 },
  { 1557, 6, 25, 12, 3, -24 },
  { 1576, 8, 30, 12, 1, -24 },
  { 1606, 20, 21, 25, 2, -26 },
  { 1659, 20, 12, 25, 2, -21 },
  { 1689, 20, 21, 25, 2, -26 },
  { 1742, 18, 32, 19, 0, -31 },
  { 1814, 34, 35, 39, 2, -31 },
  { 1963, 28, 31, 28, 0, -31 },
  { 2072, 22, 31, 28, 4, -31 },
  { 2158, 23, 31, 27, 3, -31 },
  { 2248, 25, 31, 31, 4, -31 },
  { 2345, 17, 31, 24, 4, -31 },
  { 2411, 17, 31, 23, 4, -31 },
  { 2477, 25, 31, 31, 3, -31 },
  { 2574, 24, 31, 32, 4, -31 },
  { 2667, 12, 31, 15, 2, -31 },
  { 2714, 12, 39, 12, -3, -31 },
  { 2773, 23, 31, 27, 4, -31 },
  { 2863, 18, 31, 23, 4, -31 },
  { 2933, 31, 31, 39, 4, -31 },
  { 3054, 25, 31, 33, 4, -31 },
  { 3151, 28, 31, 34, 3, -31 },
  { 3260, 20, 31, 26, 4, -31 },
  { 3338, 28, 38, 34, 3, -31 },
  { 3471, 23, 31, 27, 4, -31 },
  { 3561, 20, 31, 24, 2, -31 },
  { 3639, 23, 31, 24, 1, -31 },
  { 3729, 24, 31, 32, 4, -31 },
  { 3822, 26, 31, 26, 0, -31 },
  { 3923, 40, 31, 40, 0, -31 },
  { 4078, 26, 31, 26, 0, -31 },
  { 4179, 25, 31, 25, 0, -31 },
  { 4276, 22, 31, 25, 1, -31 },
  { 4362, 10, 38, 14, 3, -31 },
  { 4410, 16, 31, 17, 0, -31 },
  { 4472, 10, 38, 14, 1, -31 },
  { 4520, 22, 20, 25, 1, -31 },
  { 4575, 19, 3, 19, 0, 4 },
  { 4583, 9, 7, 13, 2, -33 },
  { 4591, 19, 24, 25, 2, -24 },
  { 4648, 20, 33, 27, 4, -33 },
  { 4731, 18, 24, 21, 2, -24 },
  { 4785, 21, 33, 27, 2, -33 },
  { 4872, 21, 24, 25, 2, -24 },
  { 4935, 16, 33, 15, 1, -33 },
  { 5001, 21, 34, 27, 2, -24 },
  { 5091, 20, 33, 27, 4, -33 },
  { 5174, 5, 32, 12, 3, -32 },
  { 5194, 10, 42, 12, -2, -32 },
  { 5247, 20, 33, 24, 4, -33 },
  { 5330, 4, 33, 12, 4, -33 },
  { 5347, 33, 24, 41, 4, -24 },
  { 5446, 20, 24, 27, 4, -24 },
  { 5506, 22, 24, 26, 2, -24 },
  { 5572, 20, 34, 27, 4, -24 },
  { 5657, 21, 34, 27, 2, -24 },
  { 5747, 14, 24, 18, 4, -24 },
  { 5789, 17, 24, 21, 2, -24 },
  { 5840, 14, 28, 16, 1, -28 },
  { 5889, 20, 23, 27, 3, -23 },
  { 5947, 23, 23, 23, 0, -23 },
  { 6014, 34, 23, 35, 0, -23 },
  { 6112, 22, 23, 23, 1, -23 },
  { 6176, 23, 33, 23, 0, -23 },
  { 6271, 17, 23, 21, 2, -23 },
  { 6320, 14, 38, 17, 1, -31 },
  { 6387, 4, 43, 24, 10, -33 },
  { 6409, 14, 38, 17, 1, -31 },
  { 6476, 20, 6, 25, 2, -18 },
};

const GFXfont NotoSans_Medium43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium43pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_MEDIUM43PT7B_H_
