#ifndef _NOTOSANS_MEDIUM53PT7B_H_
#define _NOTOSANS_MEDIUM53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x8E, 0x00,
  0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E,
  0x78, 0x0E, 0x78, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0x9E, 0x1E, 0x3F, 0x0F, 0x01, 0x1F, 0x87,
  0x80, 0x0F, 0x83, 0xC0, 0x07, 0xE1, 0xE0, 0x03, 0xF0, 0xF0, 0x01, 0xF8,
  0x78, 0x00, 0x7F, 0x3C, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3D, 0xFF, 0x00, 0x1E, 0x3F, 0x80, 0x0F, 0x0F,
  0xC0, 0x07, 0x83, 0xF0, 0x03, 0xC1, 0xF8, 0x01, 0xE0, 0xFE, 0x00, 0xF0,
  0x7D, 0xC0, 0x78, 0x7E, 0xFE, 0x3D, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x07,
  0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xE0, 0x07,
  0xC1, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x3C,
  0x01, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0xF8,
  0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x7C,
  0x3E, 0x00, 0x03, 0xE0, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x1F, 0x0F,
  0xE0, 0x78, 0x0F, 0x0F, 0x0F, 0xF8, 0x3E, 0x0F, 0x8F, 0x8F, 0xFE, 0x1F,
  0x07, 0xC7, 0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xC7, 0xC3, 0xE1, 0xFF, 0xC7,
  0xC7, 0xC1, 0xF0, 0xFF, 0xE3, 0xE3, 0xE0, 0x78, 0x1F, 0xC3, 0xE1, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x0F, 0x80,
  0x00, 0xF0, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x00, 0x78,
  0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xC0,
  0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x1E, 0x00,
  0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0xDF, 0x80, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x1F, 0xFF, 0xC0, 0x0F, 0x83, 0xF8, 0xFE,
  0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x81, 0xF0, 0xFC,
  0x01, 0xFC, 0x3F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0xFC, 0x00, 0x7F, 0x7E,
  0x0F, 0x80, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x7F,
  0x01, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xC0, 0x78, 0x06, 0x7E, 0x1C, 0x3F, 0x7F, 0xEE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x01,
  0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x0E, 0x03, 0x80, 0x01, 0x01, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x79, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xF3, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F,
  0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF,
  0xFF, 0x3F, 0x7E, 0x3F, 0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF7, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xC0, 0x03, 0xF0, 0x60,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xE3, 0xFE, 0x0F, 0x80, 0x1F, 0xC1,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFA, 0x00, 0x00, 0xFE,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1C, 0x0F, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0xE0, 0x00, 0xFE, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xC0,
  0x40, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x01, 0xF1, 0xFF, 0xE0, 0xF9,
  0xFF, 0xF8, 0x7D, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0x9F, 0xF0, 0x0F, 0xEF,
  0xE0, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7C, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07,
  0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x7F,
  0x00, 0x1F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x60, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F,
  0xE3, 0xFE, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xF3, 0xF0, 0x07, 0xFC,
  0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xEF, 0xC3, 0xFF, 0xFB, 0xF0, 0x7F, 0xF8,
  0xF8, 0x07, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x04, 0x03, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x34, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0x1F, 0x1F, 0x8F, 0xEF,
  0xF3, 0xF9, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x3F,
  0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0x38, 0x01, 0xFD, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xFF, 0xF0, 0x3C, 0x3E, 0x01, 0xFF, 0xFC, 0x0F, 0x8F, 0x00, 0xFF,
  0xFF, 0x01, 0xE7, 0xC0, 0x7E, 0x03, 0xC0, 0x79, 0xE0, 0x3F, 0x00, 0xF0,
  0x1E, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0xFE, 0x07, 0xC0, 0x1F, 0x01, 0xFF,
  0x81, 0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x78, 0x01, 0xF0, 0x1F, 0xF0, 0x1E,
  0x00, 0x7C, 0x07, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x07,
  0xC0, 0x7B, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0xF0, 0x1E, 0x00, 0x7C, 0x07,
  0xBC, 0x07, 0xC0, 0x3F, 0x03, 0xEF, 0x81, 0xF0, 0x0F, 0xC0, 0xF3, 0xE0,
  0x7E, 0x07, 0xF8, 0x7C, 0xF8, 0x0F, 0xFF, 0xDF, 0xFE, 0x1E, 0x01, 0xFF,
  0xE7, 0xFF, 0x07, 0xC0, 0x3F, 0xF0, 0xFF, 0x81, 0xF0, 0x07, 0xF8, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0xFE, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFC, 0x00, 0x70, 0x3F, 0xC0, 0x00, 0x83, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x30, 0x3F, 0xFE, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0x80, 0x1F, 0xF8, 0x3F, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x07, 0xF8,
  0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0xFE, 0x3F, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x08, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xE0, 0x00,
  0x3F, 0x0F, 0xF8, 0x00, 0x3F, 0x07, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xA0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC1, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFD,
  0xF0, 0x00, 0x07, 0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0x7F, 0xF7, 0xE0, 0x00,
  0x3E, 0xFF, 0xE7, 0xC0, 0x00, 0x7D, 0xFF, 0xCF, 0x80, 0x01, 0xF3, 0xFF,
  0x9F, 0x80, 0x03, 0xE7, 0xFF, 0x1F, 0x00, 0x07, 0x8F, 0xFE, 0x3E, 0x00,
  0x1F, 0x1F, 0xFC, 0x3E, 0x00, 0x3E, 0x3F, 0xF8, 0x7C, 0x00, 0xF8, 0x7F,
  0xF0, 0xF8, 0x01, 0xF0, 0xFF, 0xE0, 0xF8, 0x03, 0xE1, 0xFF, 0xC1, 0xF0,
  0x0F, 0x83, 0xFF, 0x83, 0xE0, 0x1F, 0x07, 0xFF, 0x03, 0xE0, 0x3E, 0x0F,
  0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0xF8, 0x0F,
  0x87, 0xC0, 0x7F, 0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0xE0, 0x3F, 0x1F, 0x01,
  0xFF, 0xC0, 0x3E, 0x7C, 0x03, 0xFF, 0x80, 0x7C, 0xF8, 0x07, 0xFF, 0x00,
  0xFD, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFB, 0xF0, 0x00, 0x3F, 0xF7, 0xF0, 0x00, 0x7F, 0xE7, 0xE0,
  0x00, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0x0F, 0xC0,
  0x07, 0xFE, 0x1F, 0xC0, 0x0F, 0xFC, 0x1F, 0xC0, 0x1F, 0xF8, 0x1F, 0x80,
  0x3F, 0xF0, 0x3F, 0x80, 0x7F, 0xE0, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x01,
  0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0xFE, 0x0F,
  0xFC, 0x00, 0xFE, 0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0xF0, 0x01, 0xFC, 0x7F,
  0xE0, 0x01, 0xF8, 0xFF, 0xC0, 0x01, 0xF9, 0xFF, 0x80, 0x03, 0xFB, 0xFF,
  0x00, 0x03, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xF3, 0xF0, 0x03, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x01,
  0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7F, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x00, 0x3C, 0x7E, 0x00,
  0x04, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x80, 0x00, 0x7E, 0xE0, 0x00, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE1, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xBE,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF1,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x3E,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xC0, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x03, 0xE3,
  0xF0, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x00, 0xFC,
  0xF8, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFC, 0x1F, 0x7F, 0x80, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x03, 0xFF, 0x7F, 0xFF, 0xDF, 0x3F, 0xFF,
  0xDF, 0x1F, 0xFF, 0x0F, 0x0F, 0xFE, 0x0F, 0x00, 0x60, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x7F, 0xF0, 0x3F, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0x3F, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFB,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0xC0, 0x0F,
  0xEF, 0xF8, 0x07, 0xF3, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xFE, 0x3E, 0x7F,
  0xFF, 0x0F, 0x8F, 0xFF, 0x83, 0xE1, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xE0, 0x19, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x01, 0x3F, 0xE0, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x07, 0xFF,
  0x8F, 0xC3, 0xFF, 0xFB, 0xF1, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0x80, 0x7F, 0xDF, 0xC0, 0x0F, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xF7, 0xF0, 0x03,
  0xFC, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFC, 0x7C, 0x0F, 0xFC, 0x1F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x1F,
  0xC1, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00,
  0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x04,
  0x1F, 0xE0, 0x1E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x68, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x02, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFE, 0x07, 0xC1, 0xFF, 0xE1, 0xF0, 0xFF, 0xFE, 0x7C,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xF7, 0xF0, 0x03,
  0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x3F, 0x03, 0xFF, 0x0F,
  0xC0, 0x04, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x80, 0x00, 0xFC, 0x3C,
  0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xFC, 0x0F, 0xC7, 0xFF, 0x87,
  0xEF, 0xFF, 0xF3, 0xF7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7F,
  0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xDF, 0xFE,
  0xFF, 0xF7, 0xFF, 0x3F, 0xF0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xF7,
  0xE0, 0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF3,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x8F,
  0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3E,
  0x1F, 0xFE, 0x0F, 0xFF, 0x8F, 0x9F, 0xFF, 0xC7, 0xFF, 0xF3, 0xEF, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xEF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x3F, 0xFC, 0x3E, 0x7F, 0xFF,
  0x9F, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFC, 0x03, 0xFB, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x3E, 0x1F, 0xFE, 0x0F, 0x9F,
  0xFF, 0xC3, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xCF,
  0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xEF, 0xF0, 0x03, 0xFB, 0xFE, 0x01, 0xFC, 0xFF, 0xE0,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xC3, 0xF3, 0xFF, 0xE0, 0xFC,
  0x3F, 0xF0, 0x3F, 0x01, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07,
  0xC1, 0xFF, 0xE1, 0xF0, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0xBF, 0x3F, 0xF7,
  0xFF, 0xCF, 0xE0, 0x1F, 0xF7, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xFD,
  0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE,
  0xFC, 0x1F, 0xFF, 0x3F, 0x03, 0xFF, 0x0F, 0xC0, 0x04, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFB, 0xE7, 0xFE, 0xFB,
  0xFF, 0xBF, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x07, 0xEF, 0xC0, 0x0C, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x08, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x04, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x30, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0xFC, 0x00, 0xFF, 0x7F,
  0x81, 0xFF, 0xBF, 0xFF, 0xF7, 0xCF, 0xFF, 0xF3, 0xE3, 0xFF, 0xF1, 0xF0,
  0x7F, 0xF0, 0xF8, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xDE, 0x00, 0xF8,
  0x7C, 0x03, 0xEF, 0x80, 0x7C, 0x3E, 0x01, 0xF7, 0xC0, 0x7E, 0x1F, 0x80,
  0xF3, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x3E, 0x0F, 0xC0, 0xFC, 0x3E, 0x1F, 0x07, 0xE0,
  0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x0F, 0x87,
  0x81, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x0F, 0xBF, 0x00,
  0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFE, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xF4, 0x00, 0x7F, 0xF2, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Medium53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 39, 14, 4, -38 },
  { 36, 16, 14, 23, 3, -38 },
  { 64, 32, 38, 34, 1, -38 },
  { 216, 25, 43, 30, 3, -40 },
  { 351, 41, 39, 45, 2, -38 },
  { 551, 36, 39, 39, 3, -38 },
  { 727, 6, 14, 13, 3, -38 },
  { 738, 13, 46, 17, 2, -38 },
  { 813, 12, 46, 17, 2, -38 },
  { 882, 25, 24, 29, 2, -40 },
  { 957, 25, 26, 30, 3, -32 },
  { 1039, 9, 13, 14, 2, -6 },
  { 1054, 13, 5, 17, 2, -17 },
  { 1063, 7, 8, 14, 4, -7 },
  { 1070, 20, 38, 20, 0, -38 },
  { 1165, 26, 39, 30, 2, -38 },
  { 1292, 16, 38, 30, 4, -38 },
  { 1368, 26, 38, 30, 2, -38 },
  { 1492, 26, 39, 30, 2, -38 },
  { 1619, 28, 38, 30, 1, -38 },
  { 1752, 24, 39, 30, 3, -38 },
  { 1869, 25, 39, 30, 3, -38 },
  { 1991, 26, 38, 30, 2, -38 },
  { 2115, 26, 39, 30, 2, -38 },
  { 2242, 26, 39, 30, 2, -38 },
  { 2369, 7, 30, 14, 4, -29 },
  { 2396, 9, 36, 14, 2, -29 },
  { 2437, 25, 26, 30, 3, -32 },
  { 2519, 24, 15, 30, 3, -26 },
  { 2564, 25, 26, 30, 3, -32 },
  { 2646, 21, 39, 24, 1, -38 },
  { 2749, 42, 43, 48, 3, -38 },
  { 2975, 35, 38, 35, 0, -38 },
  { 3142, 27, 38, 35, 5, -38 },
  { 3271, 29, 39, 34, 3, -38 },
  { 3413, 31, 38, 39, 5, -38 },
  { 3561, 21, 38, 30, 5, -38 },
  { 3661, 21, 38, 28, 5, -38 },
  { 3761, 32, 39, 39, 3, -38 },
  { 3917, 30, 38, 40, 5, -38 },
  { 4060, 15, 38, 19, 2, -38 },
  { 4132, 15, 48, 15, -4, -38 },
  { 4222, 29, 38, 34, 5, -38 },
  { 4360, 22, 38, 28, 5, -38 },
  { 4465, 39, 38, 49, 5, -38 },
  { 4651, 31, 38, 41, 5, -38 },
  { 4799, 35, 39, 42, 3, -38 },
  { 4970, 25, 38, 32, 5, -38 },
  { 5089, 35, 47, 42, 3, -38 },
  { 5295, 28, 38, 34, 5, -38 },
  { 5428, 24, 39, 29, 3, -38 },
  { 5545, 28, 38, 30, 1, -38 },
  { 5678, 29, 39, 39, 5, -38 },
  { 5820, 33, 38, 33, 0, -38 },
  { 5977, 49, 38, 50, 0, -38 },
  { 6210, 32, 38, 32, 0, -38 },
  { 6362, 31, 38, 31, 0, -38 },
  { 6510, 27, 38, 30, 2, -38 },
  { 6639, 12, 46, 17, 4, -38 },
  { 6708, 20, 38, 20, 0, -38 },
  { 6803, 12, 46, 17, 1, -38 },
  { 6872, 27, 24, 30, 2, -38 },
  { 6953, 23, 3, 23, 0, 5 },
  { 6962, 12, 9, 16, 2, -41 },
  { 6976, 24, 30, 30, 2, -29 },
  { 7066, 26, 41, 33, 4, -40 },
  { 7200, 21, 30, 26, 3, -29 },
  { 7279, 26, 41, 33, 3, -40 },
  { 7413, 25, 30, 30, 3, -29 },
  { 7507, 20, 41, 19, 1, -41 },
  { 7610, 26, 42, 33, 3, -29 },
  { 7747, 25, 40, 33, 4, -40 },
  { 7872, 6, 39, 14, 4, -39 },
  { 7902, 13, 52, 14, -3, -39 },
  { 7987, 25, 40, 30, 4, -40 },
  { 8112, 6, 40, 14, 4, -40 },
  { 8142, 42, 29, 50, 4, -29 },
  { 8295, 25, 29, 33, 4, -29 },
  { 8386, 27, 30, 32, 3, -29 },
  { 8488, 26, 42, 33, 4, -29 },
  { 8625, 26, 42, 33, 3, -29 },
  { 8762, 18, 29, 22, 4, -29 },
  { 8828, 20, 30, 26, 3, -29 },
  { 8903, 18, 36, 20, 1, -35 },
  { 8984, 25, 30, 33, 4, -29 },
  { 9078, 28, 29, 28, 0, -29 },
  { 9180, 41, 29, 43, 1, -29 },
  { 9329, 27, 29, 29, 1, -29 },
  { 9427, 28, 42, 28, 0, -29 },
  { 9574, 21, 29, 25, 2, -29 },
  { 9651, 18, 46, 20, 1, -38 },
  { 9755, 5, 53, 29, 12, -40 },
  { 9789, 17, 46, 20, 2, -38 },
  { 9887, 25, 7, 30, 3, -22 },
};

const GFXfont NotoSans_Medium53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium53pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_MEDIUM53PT7B_H_
