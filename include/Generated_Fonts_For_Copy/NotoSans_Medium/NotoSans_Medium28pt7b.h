#ifndef _NOTOSANS_MEDIUM28PT7B_H_
#define _NOTOSANS_MEDIUM28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x00, 0x4F, 0xFE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE3, 0xC3, 0xC3, 0x03, 0x0C, 0x03, 0x0C, 0x07, 0x1C,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xC0, 0x30, 0xC0, 0x06, 0x00,
  0x30, 0x07, 0xF0, 0xFF, 0xEF, 0xFF, 0x73, 0x0B, 0x98, 0x1C, 0xC0, 0xF6,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0x38, 0x18, 0xE0, 0xC7,
  0x86, 0x77, 0xFF, 0xBF, 0xF0, 0x7E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x3E, 0x01, 0xC1, 0xFC, 0x0E, 0x06, 0x30, 0x30, 0x38, 0xE1, 0xC0, 0xE3,
  0x86, 0x03, 0x8E, 0x38, 0x0E, 0x38, 0xC0, 0x38, 0xE7, 0x00, 0xE3, 0xB9,
  0xF1, 0x8C, 0xCF, 0xE7, 0xF7, 0x71, 0x8F, 0x99, 0xC6, 0x00, 0xE6, 0x1C,
  0x03, 0x18, 0x70, 0x1C, 0x61, 0xC0, 0x61, 0x87, 0x03, 0x87, 0x18, 0x0C,
  0x1C, 0x60, 0x60, 0x3F, 0x83, 0x80, 0x7C, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x3C, 0x70, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x1C, 0x70,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xC1, 0xC7, 0x9E,
  0x1C, 0x70, 0xF1, 0xCF, 0x07, 0xB8, 0xF0, 0x3F, 0x8F, 0x01, 0xF0, 0x70,
  0x1F, 0x07, 0xCF, 0xF8, 0x3F, 0xFB, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0xB0,
  0x0E, 0x38, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x07, 0xE0, 0xE1, 0xC1,
  0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x1C,
  0x38, 0x71, 0xC3, 0x86, 0x1C, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x06,
  0x1F, 0x37, 0xFF, 0xFC, 0xFF, 0xC1, 0xF0, 0x0D, 0xC0, 0xEE, 0x0E, 0x38,
  0x31, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x7B, 0x9C, 0xE6, 0x73, 0x00, 0xFF, 0xFF, 0xF8, 0x4F,
  0xFE, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0xC0, 0xFF, 0x83, 0xCF, 0x1C, 0x0E,
  0x70, 0x39, 0xC0, 0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x03, 0x9C, 0x0E, 0x70, 0x38, 0xF3,
  0xC1, 0xFF, 0x03, 0xF0, 0x07, 0x0F, 0x1F, 0x7B, 0xF3, 0x67, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x1F, 0xC1, 0xFF, 0xCF, 0x8F, 0x18, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xC3, 0xFF, 0xC7, 0x0F, 0x10, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x1F, 0xE0, 0x7E, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x80, 0x3B, 0x83, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0x70, 0x1D, 0xC0, 0xE7, 0x03, 0x1C,
  0x1C, 0x70, 0xE1, 0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x73, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x80,
  0x77, 0x1F, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xC1, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x70, 0x6F, 0xF3, 0xBF, 0xEF,
  0x83, 0xBC, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDC, 0x07, 0x78, 0x38,
  0xF1, 0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0x8F, 0x3C, 0x1F, 0xE0, 0x3F, 0x01, 0xFE, 0x0E,
  0x3C, 0x70, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x39, 0xE1, 0xE3,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x1C, 0x0E, 0xE0, 0x3B,
  0x80, 0x6E, 0x01, 0xF8, 0x07, 0xF0, 0x3D, 0xC1, 0xF7, 0xFF, 0xCF, 0xF7,
  0x0E, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x83, 0xFC,
  0x0F, 0xE0, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xE0, 0x7B, 0xDE,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0x39, 0xCC, 0xE7, 0x30, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0xF0, 0x02,
  0x00, 0x00, 0x3F, 0xCF, 0xFE, 0x71, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xF0, 0x3E, 0x07, 0x00, 0x3C, 0x38, 0x00, 0x31, 0xC0, 0xE0,
  0xE6, 0x1F, 0xF1, 0xB8, 0xF1, 0xC6, 0xC3, 0x87, 0x1F, 0x1C, 0x18, 0x7C,
  0x70, 0x61, 0xF1, 0xC1, 0x87, 0xC7, 0x06, 0x1B, 0x1C, 0x38, 0x6C, 0x38,
  0xF3, 0xB0, 0xFE, 0xFC, 0xE0, 0xF1, 0xC1, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x40, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xB0, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x70, 0x38,
  0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0x80, 0x70, 0xE0, 0x1E, 0x70, 0x03, 0x9C,
  0x00, 0xE7, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8,
  0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xFF, 0xF3, 0xFF, 0x0F,
  0xFF, 0x38, 0x1E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3B,
  0x8F, 0xEF, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xFC, 0xFC, 0xF3, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x7E, 0x38, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF,
  0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x3F,
  0x1E, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0x70, 0x07, 0x78, 0x07, 0x3F, 0x0F, 0x1F, 0xFF, 0x07, 0xFE, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x70, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x1E, 0xFE, 0xFC, 0xE0, 0x1D,
  0xC0, 0x73, 0x81, 0xC7, 0x07, 0x0E, 0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x73,
  0x80, 0xEE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xBC, 0x0E, 0x38, 0x1C, 0x38,
  0x38, 0x78, 0x70, 0x78, 0xE0, 0x71, 0xC0, 0xF3, 0x80, 0xF7, 0x00, 0xF0,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xDC, 0x03, 0xFD, 0xC0, 0x37, 0xCC, 0x07, 0x7C, 0xE0, 0x77,
  0xCE, 0x06, 0x7C, 0x60, 0xE7, 0xC7, 0x0C, 0x7C, 0x71, 0xC7, 0xC3, 0x1C,
  0x7C, 0x39, 0x87, 0xC3, 0xB8, 0x7C, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x7C, 0x0E, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xDC, 0x07, 0xDE, 0x07, 0xCE, 0x07, 0xC7, 0x07, 0xC7, 0x87,
  0xC3, 0x87, 0xC3, 0xC7, 0xC1, 0xE7, 0xC0, 0xE7, 0xC0, 0xF7, 0xC0, 0x77,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xE1, 0xF1, 0xE0, 0x1E, 0x70, 0x03, 0xBC, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x07,
  0x8F, 0xCF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD,
  0xC0, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x77, 0x0F, 0xBF,
  0xF9, 0xFF, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xE1, 0xF1, 0xE0,
  0x1E, 0x70, 0x03, 0xBC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0xCF, 0xC1, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xEE,
  0x03, 0xB8, 0x1E, 0xE0, 0x73, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xE3, 0xC3,
  0x87, 0x0E, 0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xB8, 0x07,
  0x1F, 0xF1, 0xFF, 0xDF, 0x3C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x3F, 0xCF, 0xBF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x0E, 0x3E, 0x3E, 0x1F,
  0xFC, 0x0F, 0xF0, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x70, 0xE0, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E,
  0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0, 0x1E,
  0x01, 0xDC, 0x07, 0x80, 0x77, 0x01, 0xE0, 0x39, 0xC0, 0x7C, 0x0E, 0x70,
  0x3F, 0x03, 0x8E, 0x0E, 0xC0, 0xE3, 0x83, 0x38, 0x70, 0xE1, 0xCE, 0x1C,
  0x38, 0x73, 0x87, 0x07, 0x1C, 0x61, 0xC1, 0xC6, 0x1C, 0xE0, 0x73, 0x87,
  0x38, 0x1C, 0xE1, 0xCE, 0x03, 0xB8, 0x33, 0x80, 0xEC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0xF0, 0x07, 0xBC, 0x07, 0x8E, 0x03, 0x83, 0x83, 0x81,
  0xE3, 0xC0, 0x71, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x38,
  0x38, 0x3C, 0x1E, 0x1C, 0x07, 0x1C, 0x01, 0xDE, 0x00, 0xF0, 0xF0, 0x07,
  0x70, 0x0F, 0x78, 0x0E, 0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x38, 0x1E, 0x38,
  0x0E, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xF0, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x03, 0x00, 0x1C, 0x00,
  0x78, 0x03, 0x60, 0x0D, 0xC0, 0x73, 0x01, 0x8E, 0x0E, 0x18, 0x30, 0x71,
  0xC0, 0xC6, 0x03, 0xB8, 0x06, 0xC0, 0x1C, 0xFF, 0xF0, 0xF0, 0xE1, 0xC3,
  0x1F, 0xE1, 0xFF, 0x84, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x3F, 0xE7,
  0xFF, 0x78, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFF, 0x0F, 0xBF, 0xFC, 0xFC,
  0x60, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x7E, 0x3B, 0xFC, 0xF8, 0x7B, 0xC0, 0xEF, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xEF, 0x87, 0xBB, 0xFC,
  0xE7, 0xE0, 0x0F, 0xF1, 0xFE, 0x3C, 0x27, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x33, 0xFF, 0x0F,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x71,
  0xFD, 0xCF, 0xFF, 0x3C, 0x7D, 0xC0, 0xF7, 0x01, 0xDC, 0x07, 0xF0, 0x1F,
  0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xF3, 0xC7, 0xCF, 0xFF,
  0x1F, 0xCC, 0x0F, 0xE0, 0x7F, 0xC3, 0x87, 0x9C, 0x0E, 0x70, 0x19, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x18, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xE1, 0xFC, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x1F, 0xF7, 0xFE, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1F, 0xCC,
  0xFF, 0xF3, 0xC7, 0xDC, 0x0F, 0x70, 0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x3C, 0x7C, 0xFF, 0xF1, 0xFD,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x74, 0x03, 0x8F, 0xFE, 0x3F, 0xF0, 0x3F,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F,
  0x9D, 0xFE, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80,
  0x7F, 0xA0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x1C, 0x38, 0x20,
  0x00, 0x03, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xF3, 0x80, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xFC, 0x1E, 0xE1, 0xE7,
  0x1E, 0x39, 0xE1, 0xDE, 0x0E, 0xE0, 0x7F, 0x83, 0xFE, 0x1E, 0x70, 0xE1,
  0xC7, 0x0F, 0x38, 0x3D, 0xC0, 0xEE, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xE7, 0xE3, 0xF3, 0xFF, 0xDF, 0xEF, 0x87, 0xE3,
  0xFC, 0x1F, 0x07, 0xF0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x81, 0xF8,
  0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x0E,
  0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x81, 0xC0, 0xE7, 0xE7,
  0x7F, 0xBE, 0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0x0F,
  0xE0, 0x3F, 0xF0, 0xF1, 0xE3, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x03,
  0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x73, 0xC0, 0xE3, 0xC7, 0x83,
  0xFE, 0x03, 0xF8, 0x00, 0xE7, 0xE3, 0xBF, 0xCF, 0x87, 0xBC, 0x0E, 0xF0,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xFC,
  0x0E, 0xF8, 0x7B, 0xBF, 0xCE, 0x7E, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xCC, 0xFF, 0xF3, 0x87,
  0xDC, 0x0F, 0x70, 0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x1D, 0xC0,
  0x77, 0x01, 0xDC, 0x0F, 0x3C, 0x7C, 0xFF, 0xF1, 0xFD, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xE7, 0xF7,
  0xFF, 0xBF, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0x3F, 0xEF, 0xFD, 0xC1, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x1C, 0x03, 0x80, 0x7C, 0x0F, 0xFF, 0x9F, 0xE0,
  0x1C, 0x07, 0x01, 0xC1, 0xFF, 0xFF, 0xC7, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1F, 0xC3, 0xF0, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xF7, 0x8F, 0xBF, 0xEC, 0xFE, 0x60,
  0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xC3, 0x83, 0x87, 0x07, 0x06,
  0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x19, 0xC0, 0x3B, 0x80, 0x76, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0xE0, 0x78, 0x1D, 0xC1, 0xE0, 0x77, 0x07,
  0xC1, 0xDC, 0x1B, 0x0E, 0x38, 0xEC, 0x38, 0xE3, 0xB8, 0xE3, 0x8C, 0xE3,
  0x0E, 0x71, 0x9C, 0x1D, 0xC6, 0x70, 0x76, 0x1D, 0xC1, 0xD8, 0x76, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x70,
  0x1E, 0x70, 0x70, 0xF1, 0xE0, 0xE3, 0x80, 0xEE, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x1D, 0xC0, 0x3B, 0xC0, 0xE3, 0x83, 0x83, 0x8F,
  0x07, 0xBC, 0x07, 0x80, 0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x1D, 0xC0, 0x3B,
  0x80, 0x36, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x07, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0x87, 0xC7, 0xC3, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x1F, 0x0F, 0x07, 0xC0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x3E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x1E, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xF0, 0x78, 0x7C, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC3, 0xE1, 0xE0, 0x3C, 0x07, 0xFE, 0x3E,
  0xFF, 0xE0, 0x7E,
};

const GFXglyph NotoSans_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 20, 8, 2, -20 },
  { 11, 8, 7, 12, 2, -20 },
  { 18, 16, 20, 18, 1, -20 },
  { 58, 13, 23, 16, 2, -21 },
  { 96, 22, 20, 24, 1, -20 },
  { 151, 20, 20, 21, 1, -20 },
  { 201, 3, 7, 7, 2, -20 },
  { 204, 7, 24, 9, 1, -20 },
  { 225, 7, 24, 9, 1, -20 },
  { 246, 13, 12, 15, 1, -21 },
  { 266, 14, 14, 16, 1, -17 },
  { 291, 5, 7, 8, 1, -3 },
  { 296, 7, 3, 9, 1, -9 },
  { 299, 4, 4, 8, 2, -4 },
  { 301, 11, 20, 11, 0, -20 },
  { 329, 14, 20, 16, 1, -20 },
  { 364, 8, 20, 16, 2, -20 },
  { 384, 14, 20, 16, 1, -20 },
  { 419, 14, 20, 16, 1, -20 },
  { 454, 14, 20, 16, 1, -20 },
  { 489, 13, 20, 16, 2, -20 },
  { 522, 14, 20, 16, 1, -20 },
  { 557, 14, 20, 16, 1, -20 },
  { 592, 14, 20, 16, 1, -20 },
  { 627, 14, 20, 16, 1, -20 },
  { 662, 4, 15, 8, 2, -15 },
  { 670, 5, 19, 8, 1, -15 },
  { 682, 14, 14, 16, 1, -17 },
  { 707, 14, 8, 16, 1, -14 },
  { 721, 14, 14, 16, 1, -17 },
  { 746, 12, 20, 13, 0, -20 },
  { 776, 22, 22, 25, 2, -20 },
  { 837, 18, 20, 18, 0, -20 },
  { 882, 14, 20, 18, 3, -20 },
  { 917, 15, 20, 18, 2, -20 },
  { 955, 16, 20, 20, 3, -20 },
  { 995, 11, 20, 16, 3, -20 },
  { 1023, 11, 20, 15, 3, -20 },
  { 1051, 16, 20, 20, 2, -20 },
  { 1091, 15, 20, 21, 3, -20 },
  { 1129, 8, 20, 10, 1, -20 },
  { 1149, 8, 25, 8, -2, -20 },
  { 1174, 15, 20, 18, 3, -20 },
  { 1212, 11, 20, 15, 3, -20 },
  { 1240, 20, 20, 26, 3, -20 },
  { 1290, 16, 20, 22, 3, -20 },
  { 1330, 18, 20, 22, 2, -20 },
  { 1375, 13, 20, 17, 3, -20 },
  { 1408, 18, 25, 22, 2, -20 },
  { 1465, 14, 20, 18, 3, -20 },
  { 1500, 13, 20, 15, 1, -20 },
  { 1533, 15, 20, 16, 0, -20 },
  { 1571, 16, 20, 21, 2, -20 },
  { 1611, 17, 20, 17, 0, -20 },
  { 1654, 26, 20, 26, 0, -20 },
  { 1719, 17, 20, 17, 0, -20 },
  { 1762, 16, 20, 16, 0, -20 },
  { 1802, 14, 20, 16, 1, -20 },
  { 1837, 7, 24, 9, 2, -20 },
  { 1858, 11, 20, 11, 0, -20 },
  { 1886, 6, 24, 9, 1, -20 },
  { 1904, 14, 13, 16, 1, -20 },
  { 1927, 12, 1, 12, 0, 3 },
  { 1929, 6, 4, 9, 1, -21 },
  { 1932, 13, 15, 16, 1, -15 },
  { 1957, 14, 21, 17, 2, -21 },
  { 1994, 12, 15, 14, 1, -15 },
  { 2017, 14, 21, 17, 1, -21 },
  { 2054, 14, 15, 16, 1, -15 },
  { 2081, 11, 21, 10, 0, -21 },
  { 2110, 14, 22, 17, 1, -15 },
  { 2149, 13, 21, 18, 2, -21 },
  { 2184, 3, 21, 8, 2, -21 },
  { 2192, 7, 28, 8, -2, -21 },
  { 2217, 13, 21, 16, 2, -21 },
  { 2252, 3, 21, 8, 2, -21 },
  { 2260, 22, 15, 27, 2, -15 },
  { 2302, 13, 15, 18, 2, -15 },
  { 2327, 15, 15, 17, 1, -15 },
  { 2356, 14, 22, 17, 2, -15 },
  { 2395, 14, 22, 17, 1, -15 },
  { 2434, 9, 15, 12, 2, -15 },
  { 2451, 11, 15, 14, 1, -15 },
  { 2472, 10, 18, 11, 0, -18 },
  { 2495, 13, 15, 18, 2, -15 },
  { 2520, 15, 15, 15, 0, -15 },
  { 2549, 22, 15, 23, 0, -15 },
  { 2591, 15, 15, 15, 0, -15 },
  { 2620, 15, 22, 15, 0, -15 },
  { 2662, 11, 15, 13, 1, -15 },
  { 2683, 9, 24, 11, 1, -20 },
  { 2710, 2, 28, 15, 7, -21 },
  { 2717, 9, 24, 11, 1, -20 },
  { 2744, 14, 4, 16, 1, -12 },
};

const GFXfont NotoSans_Medium28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium28pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_MEDIUM28PT7B_H_
