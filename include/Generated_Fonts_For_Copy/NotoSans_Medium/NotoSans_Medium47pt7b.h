#ifndef _NOTOSANS_MEDIUM47PT7B_H_
#define _NOTOSANS_MEDIUM47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xDF, 0xBF, 0xFF, 0xFE, 0xF8, 0xE0, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDE, 0x0F, 0x78, 0x3D,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x7F, 0xF7, 0xF7, 0xE3, 0x83, 0x3E, 0x1C, 0x01, 0xF0,
  0xE0, 0x0F, 0x87, 0x00, 0x7C, 0x38, 0x03, 0xF1, 0xC0, 0x1F, 0xCE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xCF, 0xE0, 0x0E, 0x3F, 0x00, 0x70, 0xF8,
  0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE1, 0xFC, 0x07, 0x1F, 0xFF, 0x3F,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x3F, 0xF8,
  0x00, 0xF0, 0x07, 0xEF, 0x80, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0x07,
  0x83, 0xC0, 0x3E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x3E,
  0x0F, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x0F,
  0x03, 0xC3, 0xC1, 0xC0, 0xF0, 0x3C, 0x7C, 0x7F, 0x07, 0x83, 0xC7, 0x8F,
  0xFC, 0x78, 0x7C, 0xF9, 0xFF, 0xC7, 0xEF, 0x8F, 0x3E, 0x3E, 0x3F, 0xF9,
  0xE3, 0xC1, 0xE1, 0xFF, 0x1E, 0x3C, 0x1E, 0x0F, 0xC3, 0xC3, 0xC0, 0xF0,
  0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0xF0, 0x00, 0xF8, 0x7C,
  0x0F, 0x00, 0x0F, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x3C, 0x03, 0xC1, 0xE0,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x00, 0x1F,
  0xFC, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xF3, 0xF8, 0x0F, 0x87, 0xE0, 0xFE, 0x0F,
  0xC3, 0xF0, 0x3F, 0x87, 0xC1, 0xF0, 0x0F, 0xE3, 0xE1, 0xF8, 0x03, 0xFB,
  0xE0, 0xFC, 0x00, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x0F,
  0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xFE, 0x03, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0x7B, 0x9C, 0xE7, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x1E,
  0x0E, 0xFE, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x07,
  0xCF, 0x80, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0x03,
  0x80, 0x04, 0x08, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x7C, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF1, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x0F,
  0xF0, 0xFF, 0x8F, 0xFC, 0xFD, 0xFF, 0xCF, 0xFC, 0x7B, 0x83, 0xC8, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xF8, 0x7F, 0x0F, 0x80, 0x3F, 0x0C, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7E, 0x07, 0xF8, 0xE0, 0x07, 0xE2, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xC0, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x7D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x3C,
  0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07,
  0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3D,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xE1, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x70, 0x03, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0xF0, 0x1E,
  0x7F, 0xF8, 0x7D, 0xFF, 0xF8, 0xFB, 0xFF, 0xF9, 0xFF, 0x03, 0xFB, 0xF8,
  0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0,
  0x3F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF8, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F,
  0x03, 0xF8, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xE0, 0x1F, 0x8F,
  0x80, 0x1F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0,
  0x1F, 0x8F, 0xFB, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xF8, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x7F, 0x7E,
  0x01, 0xFE, 0x7F, 0x0F, 0xFC, 0xFF, 0xFE, 0xF0, 0xFF, 0xF9, 0xE0, 0x7F,
  0xE3, 0xC0, 0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xBF, 0xFF,
  0xFE, 0xF8, 0xE0, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3,
  0xC1, 0xE1, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0x0F, 0xE3, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x03, 0xC0, 0x0F, 0x0F,
  0x00, 0xFF, 0xF0, 0x7C, 0xF8, 0x0F, 0xFF, 0xC1, 0xE7, 0x80, 0xFF, 0xFC,
  0x0F, 0x3C, 0x0F, 0x81, 0xE0, 0x7B, 0xC0, 0xF8, 0x0F, 0x01, 0xFE, 0x07,
  0x80, 0x78, 0x0F, 0xF0, 0x7C, 0x03, 0xC0, 0x7F, 0x83, 0xC0, 0x1E, 0x03,
  0xFC, 0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0xF0, 0x07, 0x80, 0xFE, 0x07, 0x80,
  0x3C, 0x07, 0x70, 0x3C, 0x01, 0xE0, 0x7B, 0xC1, 0xE0, 0x1F, 0x03, 0xDE,
  0x0F, 0x80, 0xF8, 0x1C, 0xF0, 0x3C, 0x0F, 0xE1, 0xE7, 0x81, 0xFF, 0xF7,
  0xBE, 0x3C, 0x07, 0xFF, 0x3F, 0xF0, 0xF0, 0x1F, 0xF0, 0xFF, 0x07, 0x80,
  0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xE7, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFC, 0xFF, 0xE8, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xF0, 0xFF, 0x00, 0x18, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x38, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x1F,
  0xC0, 0xFF, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x1F, 0xC0, 0x01,
  0xF0, 0xFF, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x1F,
  0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xDE, 0x00, 0x03, 0xDF, 0xFB, 0xE0,
  0x00, 0xFB, 0xFF, 0x7C, 0x00, 0x1E, 0x7F, 0xE7, 0x80, 0x03, 0xCF, 0xFC,
  0xF8, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x1E, 0x3F, 0xF1, 0xE0, 0x03, 0xC7,
  0xFE, 0x3E, 0x00, 0xF8, 0xFF, 0xC7, 0xC0, 0x1E, 0x1F, 0xF8, 0x78, 0x03,
  0xC3, 0xFF, 0x0F, 0x80, 0xF8, 0x7F, 0xE0, 0xF0, 0x1E, 0x0F, 0xFC, 0x1F,
  0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xF0, 0x3F, 0xF0, 0x3C, 0x1E, 0x07, 0xFE,
  0x07, 0xC7, 0xC0, 0xFF, 0xC0, 0xF8, 0xF0, 0x1F, 0xF8, 0x0F, 0x1E, 0x03,
  0xFF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x3E, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0x00, 0x7C, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xF0, 0x01, 0xFF,
  0x9F, 0x00, 0x1F, 0xF9, 0xF8, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xF8, 0xFC,
  0x01, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x83, 0xF0, 0x1F,
  0xF8, 0x1F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0xC1, 0xFF, 0x80,
  0x7E, 0x1F, 0xF8, 0x07, 0xE1, 0xFF, 0x80, 0x3F, 0x1F, 0xF8, 0x01, 0xF1,
  0xFF, 0x80, 0x1F, 0x9F, 0xF8, 0x00, 0xFC, 0xFF, 0x80, 0x07, 0xCF, 0xF8,
  0x00, 0x7E, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC,
  0x07, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xE0, 0x1F, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x07, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x0F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xC3, 0xF1, 0xF8, 0x00, 0xC7,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0xC0, 0x01, 0xFB, 0xE0, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x7E, 0x00, 0x3F, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xFC, 0x00, 0x7C,
  0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x3F,
  0x00, 0x7F, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0x9E, 0x00, 0xF8, 0x1F, 0x00,
  0x79, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x9F, 0x00, 0xF8, 0x0F, 0x80, 0xF9,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x78, 0x1F,
  0x00, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x00, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x01,
  0xF7, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x00,
  0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x73,
  0x80, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xF8, 0x3F, 0x06, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFE, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFD, 0xFE, 0xFD, 0xEF, 0xFF, 0xEF, 0x3F, 0xFE, 0x78, 0x7F, 0xC3,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x07, 0xCF, 0xFC, 0x0F,
  0xBF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF1, 0xFE, 0x7F, 0x00, 0xFC, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x07,
  0xDF, 0x80, 0x1F, 0xBF, 0x80, 0x3E, 0x7F, 0x80, 0xFC, 0xFF, 0xFF, 0xF1,
  0xEF, 0xFF, 0xE3, 0xCF, 0xFF, 0x07, 0x87, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xF7, 0xE3, 0xF8, 0x04,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x06, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x1F, 0xF9,
  0xF0, 0xFF, 0xFB, 0xE3, 0xFF, 0xFB, 0xC7, 0xF0, 0xFF, 0x9F, 0x80, 0x7F,
  0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xBC, 0x1F, 0xFE, 0x78, 0x1F, 0xF0, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x3F,
  0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0x79, 0xF0, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x03, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xE0,
  0x83, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFE, 0x3C, 0x3F, 0xFE, 0x78, 0xFF, 0xFE, 0xF1, 0xFC, 0x3F,
  0xE7, 0xE0, 0x1F, 0xCF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xF0,
  0x1F, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xBE, 0x07, 0xFC,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x90, 0x00, 0x3E, 0x3C, 0x01, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xE0, 0x3E, 0x3F, 0xF0, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFC, 0x7F, 0xBF, 0x80, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x7E, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0x8F, 0x80, 0xFC,
  0x3E, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E,
  0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xC7, 0xE0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x3E, 0x07, 0x8F, 0xFE, 0x0F, 0xFE, 0x3C, 0xFF, 0xF8, 0xFF, 0xF9, 0xEF,
  0xFF, 0xEF, 0xFF, 0xEF, 0xFC, 0xFF, 0xF8, 0xFF, 0x7F, 0x01, 0xFF, 0x01,
  0xFB, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3F,
  0x03, 0xC7, 0xFF, 0x0F, 0x3F, 0xFF, 0x3D, 0xFF, 0xFC, 0xFF, 0xC7, 0xFB,
  0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC3,
  0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x01, 0xE3, 0xFF, 0x83, 0xCF, 0xFF,
  0x87, 0xBF, 0xFF, 0x8F, 0xFC, 0x7F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0,
  0x07, 0xEF, 0xE0, 0x1F, 0x9F, 0xE0, 0x7F, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFB, 0xFF, 0xC1, 0xF1, 0xFF, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x3C, 0x3F, 0xFE, 0x78,
  0xFF, 0xFE, 0xF1, 0xFC, 0x3F, 0xE7, 0xE0, 0x1F, 0xCF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x03,
  0xF3, 0xE0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x07, 0xFF, 0xBE, 0x07, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF,
  0xF0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xE0, 0x79, 0xF8, 0x01, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xBF, 0xDF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xF7, 0xCF, 0xFF,
  0x9F, 0x0F, 0xF8, 0x3C, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xCF, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x00, 0xF3, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x03, 0xFC, 0x01,
  0xF7, 0xC0, 0x3F, 0xC0, 0x3E, 0x7C, 0x03, 0xFC, 0x03, 0xE7, 0xC0, 0x3F,
  0xC0, 0x3E, 0x7C, 0x07, 0x9E, 0x03, 0xC3, 0xE0, 0x79, 0xE0, 0x7C, 0x3E,
  0x07, 0x9E, 0x07, 0xC3, 0xE0, 0xF9, 0xF0, 0x7C, 0x1E, 0x0F, 0x0F, 0x0F,
  0x81, 0xF0, 0xF0, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x0F, 0x81, 0xF1, 0xE0,
  0xF8, 0xF8, 0x0F, 0x1E, 0x07, 0x9F, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x0F,
  0xBE, 0x07, 0xDF, 0x00, 0xFB, 0xC0, 0x3D, 0xE0, 0x07, 0xBC, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00,
  0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC7,
  0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0xC3,
  0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00,
  0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0x9F, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x02, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0x07,
  0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x83, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x02, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xD8, 0x03, 0xFF, 0x20, 0x00, 0x78, 0x00,
};

const GFXglyph NotoSans_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 35, 13, 3, -34 },
  { 32, 14, 13, 20, 3, -34 },
  { 55, 28, 34, 30, 1, -34 },
  { 174, 21, 39, 27, 3, -36 },
  { 277, 36, 34, 40, 2, -34 },
  { 430, 33, 34, 35, 2, -34 },
  { 571, 5, 13, 11, 3, -34 },
  { 580, 11, 41, 15, 2, -34 },
  { 637, 12, 41, 15, 1, -34 },
  { 699, 22, 22, 26, 2, -36 },
  { 760, 23, 23, 27, 2, -28 },
  { 827, 7, 11, 13, 2, -5 },
  { 837, 11, 5, 15, 2, -15 },
  { 844, 7, 7, 13, 3, -6 },
  { 851, 18, 34, 18, 0, -34 },
  { 928, 23, 34, 27, 2, -34 },
  { 1026, 13, 34, 27, 4, -34 },
  { 1082, 23, 34, 27, 2, -34 },
  { 1180, 22, 34, 27, 2, -34 },
  { 1274, 25, 34, 27, 1, -34 },
  { 1381, 21, 34, 27, 3, -34 },
  { 1471, 23, 34, 27, 2, -34 },
  { 1569, 23, 34, 27, 2, -34 },
  { 1667, 23, 34, 27, 2, -34 },
  { 1765, 23, 34, 27, 2, -34 },
  { 1863, 7, 27, 13, 3, -26 },
  { 1887, 9, 32, 13, 1, -26 },
  { 1923, 23, 24, 27, 2, -29 },
  { 1992, 22, 13, 27, 2, -23 },
  { 2028, 23, 24, 27, 2, -29 },
  { 2097, 20, 35, 21, 0, -34 },
  { 2185, 37, 38, 42, 3, -34 },
  { 2361, 31, 34, 31, 0, -34 },
  { 2493, 24, 34, 31, 4, -34 },
  { 2595, 25, 34, 30, 3, -34 },
  { 2702, 28, 34, 34, 4, -34 },
  { 2821, 19, 34, 26, 4, -34 },
  { 2902, 19, 34, 25, 4, -34 },
  { 2983, 28, 34, 34, 3, -34 },
  { 3102, 27, 34, 35, 4, -34 },
  { 3217, 13, 34, 17, 2, -34 },
  { 3273, 13, 43, 14, -4, -34 },
  { 3343, 26, 34, 30, 4, -34 },
  { 3454, 20, 34, 25, 4, -34 },
  { 3539, 35, 34, 43, 4, -34 },
  { 3688, 28, 34, 36, 4, -34 },
  { 3807, 31, 34, 37, 3, -34 },
  { 3939, 22, 34, 29, 4, -34 },
  { 4033, 31, 42, 37, 3, -34 },
  { 4196, 25, 34, 30, 4, -34 },
  { 4303, 22, 34, 26, 2, -34 },
  { 4397, 25, 34, 26, 1, -34 },
  { 4504, 27, 34, 35, 4, -34 },
  { 4619, 29, 34, 29, 0, -34 },
  { 4743, 44, 34, 44, 0, -34 },
  { 4930, 29, 34, 29, 0, -34 },
  { 5054, 27, 34, 27, 0, -34 },
  { 5169, 23, 34, 27, 2, -34 },
  { 5267, 10, 41, 16, 4, -34 },
  { 5319, 18, 34, 18, 0, -34 },
  { 5396, 11, 41, 16, 1, -34 },
  { 5453, 23, 22, 27, 2, -34 },
  { 5517, 20, 3, 20, 0, 4 },
  { 5525, 11, 8, 14, 2, -36 },
  { 5536, 21, 26, 27, 2, -26 },
  { 5605, 23, 36, 29, 4, -36 },
  { 5709, 20, 26, 23, 2, -26 },
  { 5774, 23, 36, 29, 2, -36 },
  { 5878, 23, 26, 27, 2, -26 },
  { 5953, 18, 36, 17, 1, -36 },
  { 6034, 23, 37, 29, 2, -26 },
  { 6141, 22, 36, 29, 4, -36 },
  { 6240, 5, 35, 13, 4, -35 },
  { 6262, 12, 46, 13, -3, -35 },
  { 6331, 22, 36, 26, 4, -36 },
  { 6430, 5, 36, 13, 4, -36 },
  { 6453, 37, 26, 45, 4, -26 },
  { 6574, 22, 26, 29, 4, -26 },
  { 6646, 24, 26, 29, 2, -26 },
  { 6724, 23, 37, 29, 4, -26 },
  { 6831, 23, 37, 29, 2, -26 },
  { 6938, 15, 26, 20, 4, -26 },
  { 6987, 19, 26, 23, 2, -26 },
  { 7049, 16, 31, 18, 1, -31 },
  { 7111, 22, 25, 29, 4, -25 },
  { 7180, 25, 25, 25, 0, -25 },
  { 7259, 36, 25, 38, 1, -25 },
  { 7372, 24, 25, 26, 1, -25 },
  { 7447, 25, 36, 25, 0, -25 },
  { 7560, 19, 25, 22, 2, -25 },
  { 7620, 15, 41, 18, 1, -34 },
  { 7697, 4, 47, 26, 11, -36 },
  { 7721, 15, 41, 18, 2, -34 },
  { 7798, 23, 7, 27, 2, -20 },
};

const GFXfont NotoSans_Medium47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium47pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_MEDIUM47PT7B_H_
