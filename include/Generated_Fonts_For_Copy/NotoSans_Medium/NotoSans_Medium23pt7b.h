#ifndef _NOTOSANS_MEDIUM23PT7B_H_
#define _NOTOSANS_MEDIUM23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x01, 0xBF, 0xE6, 0xCD, 0x9B, 0x36, 0x6C,
  0xC0, 0x0E, 0x60, 0x63, 0x03, 0x18, 0x18, 0xCF, 0xFF, 0xFF, 0xFC, 0x63,
  0x03, 0x18, 0x18, 0xC7, 0xFF, 0xFF, 0xFE, 0x63, 0x03, 0x18, 0x18, 0xC0,
  0xC4, 0x04, 0x60, 0x04, 0x01, 0xC0, 0xFF, 0xBF, 0xEE, 0x41, 0xC8, 0x39,
  0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x17, 0x82, 0x30, 0x47, 0x89, 0xFF, 0xF3,
  0xF8, 0x04, 0x00, 0x80, 0x38, 0x00, 0x1F, 0x03, 0x0E, 0x61, 0x83, 0x18,
  0x60, 0xC6, 0x30, 0x31, 0x8C, 0x0C, 0x66, 0x03, 0x1B, 0xBC, 0xEE, 0xDF,
  0x9F, 0x66, 0x63, 0x99, 0x88, 0x0C, 0xC3, 0x03, 0x30, 0xC1, 0x86, 0x20,
  0x61, 0x98, 0x30, 0x7E, 0x1C, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x39,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x31, 0xC0, 0x3B, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x7F, 0x0E, 0x73, 0x8C, 0xE1, 0xDC, 0xE0, 0xF8, 0xE0, 0x78, 0xF0,
  0xF8, 0x7F, 0xFC, 0x3F, 0x8F, 0xED, 0xB6, 0xC0, 0x19, 0x9C, 0xC6, 0x73,
  0x98, 0xC6, 0x31, 0x8C, 0x71, 0x8C, 0x71, 0x8E, 0x30, 0xE3, 0x1C, 0x63,
  0x9C, 0x63, 0x18, 0xC6, 0x31, 0x9C, 0xE6, 0x33, 0x39, 0x80, 0x0E, 0x01,
  0x80, 0x30, 0x76, 0xFF, 0xFE, 0x1C, 0x07, 0xC1, 0xD8, 0x73, 0x82, 0x20,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x76, 0x6E, 0xCC, 0xFF, 0xF0, 0xDF, 0x80, 0x03,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x03, 0x01, 0x81, 0xC0, 0x0E, 0x07, 0xF1, 0xEF, 0x30, 0x6E, 0x0F,
  0xC1, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x7E, 0x0E, 0xC1,
  0xDC, 0x71, 0xFC, 0x1F, 0x00, 0x1E, 0x7D, 0xFF, 0x74, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0F, 0xF3, 0xCF, 0x20,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x07, 0xFF, 0xFF, 0xE0, 0x1E, 0x0F, 0xF3, 0xCF, 0x20,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x3C, 0x3E, 0x07, 0xF8, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x77, 0xFE, 0xFF, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x0D, 0x80, 0x6C, 0x06, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC3, 0x06, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x7F, 0xCF, 0xF9,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xE3, 0xFE, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x03, 0xBF, 0xF3, 0xF8, 0x03, 0xC3, 0xF8, 0xF1, 0x18,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x7C, 0xFF, 0xDC, 0x1F, 0x81, 0xF0, 0x3E,
  0x06, 0xC1, 0xDC, 0x39, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x0E, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0E,
  0xC1, 0x9C, 0x71, 0xFC, 0x1F, 0x07, 0xF1, 0x87, 0x70, 0x7C, 0x07, 0x80,
  0xF8, 0x3B, 0xFE, 0x3F, 0x80, 0x0E, 0x07, 0xF1, 0xCF, 0x70, 0x6E, 0x0F,
  0x80, 0xF0, 0x1F, 0x07, 0x61, 0xEF, 0xEC, 0xF9, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0xE3, 0xFC, 0x7E, 0x00, 0xDF, 0xE0, 0x00, 0x03, 0x7E, 0x67, 0x76,
  0x00, 0x00, 0x00, 0x66, 0xEE, 0xCC, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x78, 0x3C, 0x3E, 0x1F, 0x03, 0x00, 0x00, 0x1E,
  0x3F, 0xE7, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x1C, 0x0E, 0x03, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x07, 0xFC, 0x03,
  0xC3, 0xC1, 0x80, 0x38, 0xC0, 0x06, 0x61, 0xF8, 0xD8, 0xFE, 0x36, 0x71,
  0x8F, 0x18, 0x61, 0xC6, 0x18, 0x71, 0x86, 0x3C, 0x61, 0x8F, 0x1C, 0xF6,
  0x63, 0xEF, 0x98, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x10, 0x0F, 0xFC, 0x00,
  0xFE, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xEE, 0x01,
  0x8C, 0x03, 0x18, 0x0E, 0x38, 0x18, 0x30, 0x7F, 0xF0, 0xFF, 0xE1, 0x80,
  0xC7, 0x01, 0xCE, 0x03, 0x98, 0x03, 0x70, 0x07, 0xFF, 0xCF, 0xFE, 0xE0,
  0xEE, 0x06, 0xE0, 0x6E, 0x0E, 0xFF, 0xCF, 0xF8, 0xE1, 0xEE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xFF, 0xEF, 0xF8, 0x03, 0xC0, 0x7F, 0xC7,
  0xDC, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x23, 0xFE, 0x0F, 0xF0,
  0xFF, 0xC7, 0xFF, 0x38, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0x70, 0xFB, 0xFF,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0x8E, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0xD8, 0x03, 0x70,
  0x0D, 0xC0, 0x33, 0xC0, 0xC7, 0xFF, 0x0F, 0xFC, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFD, 0xE3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xFF, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1B, 0xF7, 0xC4, 0x00, 0xE0, 0x77, 0x07, 0x38, 0x71, 0xC7, 0x0E,
  0x70, 0x77, 0x03, 0xB0, 0x1F, 0xC0, 0xFE, 0x07, 0x38, 0x38, 0xE1, 0xC7,
  0x0E, 0x1C, 0x70, 0x73, 0x81, 0x9C, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xF6, 0x03, 0x7B, 0x01, 0xBD,
  0x80, 0xDE, 0x60, 0xCF, 0x30, 0x67, 0x9C, 0x73, 0xC6, 0x31, 0xE3, 0x18,
  0xF1, 0xD8, 0x78, 0x6C, 0x3C, 0x36, 0x1E, 0x1E, 0x0F, 0x07, 0x07, 0x83,
  0x83, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xF7, 0x07, 0xDC, 0x1F, 0x38, 0x7C,
  0x71, 0xF1, 0xC7, 0xC3, 0x9F, 0x06, 0x7C, 0x1D, 0xF0, 0x3F, 0xC0, 0xEF,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0xF0, 0x3E, 0x7C, 0x38,
  0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x1F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x9F, 0xFB, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x1E, 0xFF, 0x9F, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x3E, 0x7C, 0x38, 0x1C, 0x70, 0x0E, 0x60,
  0x06, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60,
  0x06, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0xFF, 0x8F, 0xFC, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCF, 0xFC, 0xFF, 0x0E, 0x30, 0xE3, 0x8E,
  0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0x6E, 0x07, 0x0F, 0x07, 0xF9, 0xEF, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xE0, 0x77, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x38, 0xFF, 0x83, 0xF8, 0xE0,
  0x1D, 0x80, 0x67, 0x01, 0x9C, 0x0E, 0x30, 0x30, 0xE0, 0xC3, 0x87, 0x06,
  0x18, 0x1C, 0x60, 0x73, 0x80, 0xCC, 0x03, 0xB0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0xE0, 0x70, 0x1B, 0x03, 0xC1, 0xD8, 0x1E, 0x0E, 0xE1,
  0xF0, 0x67, 0x0D, 0x83, 0x18, 0x6E, 0x38, 0xC3, 0x31, 0xC7, 0x39, 0x8C,
  0x19, 0x8E, 0x60, 0xCC, 0x37, 0x06, 0xE1, 0xB8, 0x3E, 0x0D, 0x80, 0xF0,
  0x7C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0xF0, 0x3C, 0xC0,
  0xC3, 0x87, 0x07, 0x38, 0x0C, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x07,
  0x80, 0x3F, 0x00, 0xCC, 0x07, 0x38, 0x38, 0x70, 0xC0, 0xC7, 0x03, 0xB8,
  0x07, 0xE0, 0x3B, 0x81, 0x8C, 0x1C, 0x70, 0xC1, 0x8E, 0x0E, 0x60, 0x37,
  0x01, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0xF0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0xF8, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xF0, 0x04, 0x01, 0x80,
  0x38, 0x0D, 0x81, 0xB0, 0x63, 0x0C, 0x63, 0x06, 0x60, 0xD8, 0x0F, 0x01,
  0x80, 0xFF, 0xFF, 0xF0, 0xE3, 0x0C, 0x30, 0x0E, 0x1F, 0xE3, 0x1C, 0x03,
  0x00, 0xC0, 0x73, 0xFD, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0xFF, 0x7E, 0xC0,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x61, 0xBF, 0x3C, 0xF7, 0x07, 0xE0,
  0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0xC1, 0xF8, 0x77, 0xFE, 0xDF, 0x80,
  0x07, 0x0F, 0xF7, 0x99, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18,
  0x07, 0x04, 0xFE, 0x1F, 0x80, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xC6,
  0x7E, 0xDE, 0x7B, 0x87, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC0,
  0xDC, 0x3B, 0xFF, 0x1F, 0x60, 0x06, 0x07, 0xF1, 0xE7, 0x30, 0x7E, 0x07,
  0xC0, 0xFF, 0xFF, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x9F, 0xE1, 0xFC, 0x07,
  0x0F, 0xC7, 0x23, 0x03, 0x81, 0xC3, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x0C, 0x07, 0xED, 0xE7,
  0xB8, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0xC3, 0xBF,
  0xF1, 0xF6, 0x00, 0xC0, 0x18, 0x07, 0x7B, 0xEF, 0xF8, 0x10, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x61, 0xBF, 0xBE, 0x77, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0xDF,
  0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x18, 0x71, 0x80, 0x00, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0xFB, 0xC4, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xB0, 0xE6, 0x38, 0xCE,
  0x1B, 0x83, 0xF0, 0x7F, 0x0E, 0x61, 0x8E, 0x30, 0xE6, 0x0E, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x06, 0x37, 0xE7, 0xEF, 0x3F, 0x3F,
  0x87, 0x87, 0xE0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0,
  0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xC0, 0x07,
  0x1B, 0xFB, 0xE7, 0x70, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0E, 0x06, 0x03, 0xFC, 0x79, 0xE7, 0x06, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x70, 0xE3, 0xFC, 0x1F,
  0x80, 0x06, 0x1B, 0xF3, 0xCF, 0x70, 0x7E, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0xFC, 0x1F, 0x87, 0x7F, 0xED, 0xF9, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x07, 0xED, 0xE7, 0xB8, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0xC3, 0xBF, 0xF1, 0xF6, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x07, 0xBF, 0xFF, 0x8E, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x1C, 0x3F, 0xF8, 0xD8, 0x0E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0x80, 0xE0, 0x7F, 0xFF, 0xE0, 0x18, 0x18,
  0x38, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F,
  0x1F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFC, 0x3F, 0xFF, 0xBF, 0x30, 0xE0, 0x76, 0x06, 0x70, 0x67, 0x0E,
  0x30, 0xC3, 0x9C, 0x19, 0x81, 0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0xE0, 0xE0, 0xD8, 0x78, 0x76, 0x1E, 0x19, 0xC6, 0xC6, 0x31, 0xB1, 0x8C,
  0xCC, 0xE3, 0xB3, 0xB0, 0xEC, 0x6C, 0x1E, 0x1B, 0x07, 0x87, 0xC1, 0xE0,
  0xE0, 0x38, 0x38, 0x70, 0x73, 0x8E, 0x19, 0xC1, 0xD8, 0x0F, 0x80, 0x70,
  0x0F, 0x01, 0xF8, 0x19, 0xC3, 0x8C, 0x70, 0xEE, 0x07, 0xE0, 0x76, 0x06,
  0x70, 0x63, 0x0E, 0x30, 0xC3, 0x9C, 0x19, 0xC1, 0x98, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x0B, 0xC0, 0xF8, 0x02, 0x00,
  0xFF, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x3F,
  0xFF, 0xF0, 0x1E, 0x3C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x71, 0x83, 0xC1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x1C, 0x0C, 0x79,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0xE3, 0xC4, 0x00, 0x38, 0x3F, 0xCE, 0x1F,
  0xC0, 0x40,
};

const GFXglyph NotoSans_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 16, 6, 2, -16 },
  { 7, 7, 6, 10, 1, -16 },
  { 13, 13, 16, 15, 1, -16 },
  { 39, 11, 18, 13, 1, -17 },
  { 64, 18, 17, 20, 1, -17 },
  { 103, 16, 17, 17, 1, -17 },
  { 137, 3, 6, 5, 1, -16 },
  { 140, 5, 20, 7, 1, -16 },
  { 153, 5, 20, 7, 1, -16 },
  { 166, 11, 10, 13, 1, -17 },
  { 180, 11, 11, 13, 1, -14 },
  { 196, 4, 6, 6, 1, -3 },
  { 199, 6, 2, 7, 1, -7 },
  { 201, 3, 3, 6, 2, -3 },
  { 203, 9, 16, 9, 0, -16 },
  { 221, 11, 17, 13, 1, -17 },
  { 245, 7, 16, 13, 2, -16 },
  { 259, 11, 17, 13, 1, -17 },
  { 283, 11, 17, 13, 1, -17 },
  { 307, 13, 16, 13, 0, -16 },
  { 333, 11, 16, 13, 1, -16 },
  { 355, 11, 17, 13, 1, -17 },
  { 379, 11, 16, 13, 1, -16 },
  { 401, 11, 17, 13, 1, -17 },
  { 425, 11, 17, 13, 1, -17 },
  { 449, 3, 13, 6, 2, -13 },
  { 454, 4, 16, 6, 1, -13 },
  { 462, 11, 11, 13, 1, -14 },
  { 478, 11, 6, 13, 1, -11 },
  { 487, 11, 11, 13, 1, -14 },
  { 503, 10, 17, 10, 0, -17 },
  { 525, 18, 18, 21, 1, -16 },
  { 566, 15, 16, 15, 0, -16 },
  { 596, 12, 16, 15, 2, -16 },
  { 620, 13, 17, 15, 1, -17 },
  { 648, 13, 16, 17, 2, -16 },
  { 674, 9, 16, 13, 2, -16 },
  { 692, 9, 16, 12, 2, -16 },
  { 710, 14, 17, 17, 1, -17 },
  { 740, 13, 16, 17, 2, -16 },
  { 766, 6, 16, 8, 1, -16 },
  { 778, 7, 21, 7, -2, -16 },
  { 797, 13, 16, 15, 2, -16 },
  { 823, 10, 16, 12, 2, -16 },
  { 843, 17, 16, 21, 2, -16 },
  { 877, 14, 16, 18, 2, -16 },
  { 905, 16, 17, 18, 1, -17 },
  { 939, 11, 16, 14, 2, -16 },
  { 961, 16, 21, 18, 1, -17 },
  { 1003, 12, 16, 15, 2, -16 },
  { 1027, 11, 17, 13, 1, -17 },
  { 1051, 13, 16, 13, 0, -16 },
  { 1077, 13, 16, 17, 2, -16 },
  { 1103, 14, 16, 14, 0, -16 },
  { 1131, 21, 16, 22, 0, -16 },
  { 1173, 14, 16, 14, 0, -16 },
  { 1201, 13, 16, 13, 0, -16 },
  { 1227, 11, 16, 13, 1, -16 },
  { 1249, 5, 20, 8, 2, -16 },
  { 1262, 9, 16, 9, 0, -16 },
  { 1280, 5, 20, 8, 1, -16 },
  { 1293, 11, 11, 13, 1, -17 },
  { 1309, 10, 2, 10, 0, 2 },
  { 1312, 5, 4, 7, 1, -18 },
  { 1315, 10, 13, 13, 1, -13 },
  { 1332, 11, 17, 14, 2, -17 },
  { 1356, 10, 13, 11, 1, -13 },
  { 1373, 11, 17, 14, 1, -17 },
  { 1397, 11, 13, 13, 1, -13 },
  { 1415, 9, 18, 8, 0, -18 },
  { 1436, 11, 19, 14, 1, -13 },
  { 1463, 11, 17, 14, 2, -17 },
  { 1487, 3, 17, 6, 2, -17 },
  { 1494, 6, 23, 6, -1, -17 },
  { 1512, 11, 17, 13, 2, -17 },
  { 1536, 2, 17, 6, 2, -17 },
  { 1541, 18, 13, 22, 2, -13 },
  { 1571, 11, 13, 14, 2, -13 },
  { 1589, 12, 13, 14, 1, -13 },
  { 1609, 11, 19, 14, 2, -13 },
  { 1636, 11, 19, 14, 1, -13 },
  { 1663, 7, 13, 10, 2, -13 },
  { 1675, 9, 13, 11, 1, -13 },
  { 1690, 8, 15, 9, 0, -15 },
  { 1705, 11, 12, 14, 2, -12 },
  { 1722, 12, 12, 12, 0, -12 },
  { 1740, 18, 12, 19, 0, -12 },
  { 1767, 12, 12, 12, 0, -12 },
  { 1785, 12, 18, 12, 0, -12 },
  { 1812, 9, 12, 11, 1, -12 },
  { 1826, 7, 20, 9, 1, -16 },
  { 1844, 2, 22, 13, 5, -17 },
  { 1850, 7, 20, 9, 1, -16 },
  { 1868, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_Medium23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium23pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_MEDIUM23PT7B_H_
