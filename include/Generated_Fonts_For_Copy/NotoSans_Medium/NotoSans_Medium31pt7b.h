#ifndef _NOTOSANS_MEDIUM31PT7B_H_
#define _NOTOSANS_MEDIUM31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x60, 0x00, 0x7F, 0xFF,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xC3, 0x03, 0x87, 0x00,
  0xE1, 0x80, 0x38, 0x60, 0x0C, 0x38, 0x03, 0x0E, 0x00, 0xC3, 0x87, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0x87, 0x00, 0x61, 0xC0, 0x38, 0x60,
  0x0E, 0x18, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1C, 0x30, 0x07,
  0x0C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x03, 0xF8, 0x3F, 0xFD, 0xFF, 0xEF, 0x31, 0xB8,
  0xC0, 0xE3, 0x03, 0x8C, 0x0F, 0xB0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0xCF, 0x03, 0x1C, 0x0C, 0x78, 0x31, 0xFC, 0xDF, 0xFF, 0xFB,
  0xFF, 0x80, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x70,
  0x7F, 0x80, 0xE0, 0x73, 0x81, 0xC0, 0x61, 0xC1, 0xC0, 0xE1, 0xC3, 0x80,
  0xE1, 0xC3, 0x80, 0xE1, 0xC7, 0x00, 0xE1, 0xC6, 0x00, 0xE1, 0xCE, 0x10,
  0x61, 0xCC, 0xFC, 0x73, 0x9D, 0xFE, 0x7F, 0xB9, 0xC6, 0x3F, 0x39, 0x87,
  0x00, 0x71, 0x87, 0x00, 0x73, 0x87, 0x00, 0xE3, 0x87, 0x00, 0xC3, 0x87,
  0x01, 0xC1, 0x87, 0x01, 0x81, 0xC7, 0x03, 0x81, 0xCE, 0x07, 0x00, 0xFE,
  0x07, 0x00, 0x7C, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x1E, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x9E, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x04, 0x7F, 0x81, 0xC7, 0x9E,
  0x0E, 0x78, 0x78, 0xF3, 0x81, 0xE7, 0x1C, 0x07, 0xF8, 0xE0, 0x1F, 0x87,
  0x00, 0x78, 0x3C, 0x07, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0x9E, 0x0F, 0xF0,
  0x7C, 0xFF, 0xFF, 0xFB, 0x0F, 0x0E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x70,
  0x70, 0x38, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0xE0, 0xE0, 0xE1, 0xC1, 0xC3,
  0x87, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0xF1, 0xC3, 0x8F, 0x1C, 0x78, 0xE3, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x1E, 0x73, 0xBF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0x0F, 0x80, 0x3B, 0x80, 0xE7, 0x83, 0xC7, 0x83, 0x8E, 0x01, 0x10, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x3F,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x39, 0xDE, 0xE7, 0x39, 0x9C, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xE1, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0xDC,
  0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1E, 0xF0, 0x38, 0xE0, 0xF1,
  0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xC1, 0xF1, 0xFC, 0xFF, 0xFB,
  0xDC, 0xF2, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xF1, 0xF1, 0x81, 0xE2, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0xF1, 0xF1, 0xF1, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x1F, 0xE0, 0x3F,
  0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3E, 0x00, 0xFF, 0xEF, 0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0xB8, 0x07, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38,
  0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xBE, 0xFE, 0xFF, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0xE3, 0xF0, 0x8F, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE7,
  0xE3, 0xBF, 0xCF, 0xFF, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x77, 0x03, 0xDF, 0xBE, 0x3F, 0xF0, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0xF0, 0xF3,
  0xC0, 0xE7, 0x01, 0xEE, 0x03, 0xDE, 0x07, 0x1C, 0x1E, 0x3E, 0x78, 0x1F,
  0xE0, 0x1F, 0x80, 0xFF, 0xC3, 0xC7, 0xCF, 0x03, 0xDC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0xE1, 0xE3, 0xFF, 0xC1, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0E, 0xE0, 0x3D, 0xE0, 0xF9, 0xFF, 0xF3, 0xFE,
  0xE1, 0xF1, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE1,
  0x1F, 0x83, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x3B, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D,
  0xEF, 0x73, 0x99, 0xCE, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x1F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x3F, 0xE7, 0xFF, 0x9E, 0x3E,
  0x80, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xC0, 0xF8, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x70, 0x7F, 0xC6, 0x60, 0xFF, 0x87, 0xE1, 0xE1, 0x87, 0xE3, 0xC1,
  0x83, 0xC3, 0x81, 0x83, 0xC3, 0x81, 0x83, 0xC3, 0x83, 0x83, 0xC3, 0x83,
  0x87, 0xC3, 0x83, 0x87, 0xC3, 0x83, 0x8E, 0xE1, 0xFE, 0xFE, 0xE0, 0xFC,
  0xFC, 0x70, 0x30, 0x20, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x40, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00, 0x39,
  0xC0, 0x03, 0x9C, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xF0, 0x0F,
  0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3C, 0x01, 0xC3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0,
  0x3E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3C, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFF, 0xFC, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xF7, 0xC7, 0xC0, 0x27, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x43, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x0F, 0x38,
  0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E,
  0xE0, 0x07, 0xB8, 0x03, 0xCE, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xFF, 0x83, 0xFF,
  0xF1, 0xFE, 0xF8, 0xF8, 0x02, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0x78, 0x01, 0xDE, 0x00,
  0x73, 0xE0, 0x1C, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1C, 0xFF, 0xFF, 0xCF,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xCF, 0xFF, 0xFC, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFE,
  0xFE, 0xF8, 0xE0, 0x0F, 0x70, 0x0F, 0x38, 0x0F, 0x1C, 0x0F, 0x0E, 0x0F,
  0x07, 0x07, 0x03, 0x87, 0x81, 0xC7, 0x80, 0xE7, 0x80, 0x77, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xBC, 0x07, 0x0F, 0x03, 0x87, 0x81, 0xC1, 0xE0,
  0xE0, 0x78, 0x70, 0x1C, 0x38, 0x0F, 0x1C, 0x03, 0xCE, 0x00, 0xF7, 0x00,
  0x7C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFD, 0xC0, 0x1F, 0xFB, 0x80, 0x77, 0xF7, 0x00, 0xEF,
  0xE7, 0x01, 0x9F, 0xCE, 0x07, 0x3F, 0x8E, 0x0E, 0x7F, 0x1C, 0x38, 0xFE,
  0x38, 0x71, 0xFC, 0x38, 0xE3, 0xF8, 0x73, 0x87, 0xF0, 0xE7, 0x0F, 0xE0,
  0xEC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x03, 0xC0, 0xFE, 0x07,
  0x81, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFB, 0xC0, 0x7E, 0xF0, 0x1F, 0x9E, 0x07, 0xE3,
  0x81, 0xF8, 0xF0, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE0, 0xF1, 0xF8, 0x1E,
  0x7E, 0x07, 0x9F, 0x80, 0xF7, 0xE0, 0x1D, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0x9F, 0xC3, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x1F, 0xBF, 0xFC, 0xFF,
  0xE3, 0xF8, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0x9F,
  0xC3, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xE7,
  0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0xE0,
  0x38, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0F, 0x1F, 0xF1, 0xFF,
  0xE7, 0xFF, 0xBC, 0x02, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8,
  0x03, 0xDE, 0x03, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0xF0, 0x01,
  0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07,
  0x0F, 0x01, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0xC1, 0xE0, 0x38, 0x38,
  0x07, 0x07, 0x00, 0xF1, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x1D, 0xE0,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x7B, 0x80, 0x7C, 0x03, 0x9C, 0x03,
  0xE0, 0x1C, 0xF0, 0x1F, 0x00, 0xE7, 0x80, 0xDC, 0x0F, 0x1C, 0x0E, 0xE0,
  0x70, 0xE0, 0x77, 0x03, 0x87, 0x83, 0xB8, 0x1C, 0x1C, 0x38, 0xE1, 0xE0,
  0xE1, 0xC7, 0x0E, 0x07, 0x0E, 0x38, 0x70, 0x3C, 0x71, 0xE3, 0x80, 0xE7,
  0x07, 0x3C, 0x07, 0x38, 0x39, 0xC0, 0x39, 0xC1, 0xCE, 0x01, 0xDC, 0x07,
  0x70, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC7, 0x00, 0x70, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xE0, 0xE0, 0x1E,
  0x3C, 0x01, 0xC7, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x01, 0xCF, 0x00, 0x78,
  0xF0, 0x0E, 0x0E, 0x03, 0xC1, 0xE0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80,
  0x3D, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x78, 0xF0,
  0x1C, 0x3C, 0x0F, 0x07, 0x83, 0x80, 0xE1, 0xE0, 0x3C, 0xF0, 0x07, 0x38,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF,
  0xFF, 0xF8, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xF8, 0x03,
  0x80, 0x03, 0x80, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xE0, 0x0E, 0x60, 0x1C,
  0x70, 0x1C, 0x30, 0x18, 0x38, 0x38, 0x18, 0x30, 0x1C, 0x70, 0x0C, 0x60,
  0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0,
  0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xC4, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC3, 0xFF, 0x3F, 0xFD, 0xF0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xF7, 0x8F, 0xDF, 0xF3, 0x3F, 0x8C, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x73, 0xE0, 0xEF, 0xF1, 0xFF,
  0xF3, 0xC0, 0xF7, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xEF, 0x03, 0xDF, 0xDF, 0x37,
  0xFC, 0x63, 0xF0, 0x0F, 0xE1, 0xFF, 0x7F, 0xF7, 0x81, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x81,
  0x7E, 0xF3, 0xFF, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xCF, 0x3F, 0xFE, 0xFF, 0xFD,
  0xE0, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x03, 0xEF, 0xDF, 0xCF, 0xFB,
  0x8F, 0xE7, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0xF0, 0x3F, 0x80,
  0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x17, 0xE7, 0x8F, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x7F, 0x0F,
  0xF0, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x8E, 0x7F, 0xDD,
  0xFF, 0xFB, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xDF, 0x3F,
  0x9F, 0xFF, 0x1F, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE8, 0x03, 0xCE,
  0x0F, 0x9F, 0xFE, 0x3F, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x39, 0xF8, 0xEF, 0xF3, 0xFF, 0xEF, 0x83,
  0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x7F,
  0xF2, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x07,
  0x0F, 0x0F, 0x02, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x0F, 0x9F, 0xFE, 0xFC, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0F, 0xE0, 0x7B, 0x83, 0xCE, 0x1E,
  0x38, 0xF0, 0xE7, 0x83, 0xBC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xDE,
  0x0E, 0x3C, 0x38, 0x78, 0xE0, 0xF3, 0x83, 0xCE, 0x07, 0xB8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0xF8, 0xCF,
  0xF3, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x7E, 0x0F, 0xF0, 0x3C, 0x0F, 0xE0,
  0x3C, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xC7,
  0xE3, 0x3F, 0xEF, 0xFF, 0xBC, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1C, 0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0xE3, 0xC1,
  0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x01, 0xEE, 0x07, 0x9F, 0x1F, 0x1F, 0xFC, 0x0F,
  0xE0, 0xC7, 0xE1, 0x9F, 0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEE,
  0x03, 0xDE, 0x07, 0xBF, 0x3E, 0x7F, 0xF8, 0xE7, 0xE1, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0x8E,
  0x7F, 0xDD, 0xFF, 0xBB, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07,
  0xDF, 0x1F, 0x9F, 0xFF, 0x1F, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xC3, 0xF3, 0xFD, 0xFB, 0xF0,
  0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x00, 0x1F, 0xC7, 0xFE, 0xFF, 0xEE, 0x02, 0xE0,
  0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x0F, 0xE1, 0xEF, 0xFE, 0xFF, 0x80, 0x18, 0x0E, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0x91, 0xFC, 0x3F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xEE, 0x07, 0xDF, 0x3F,
  0x9F, 0xF7, 0x1F, 0xCE, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0E,
  0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0xB8, 0x1F, 0x03, 0x9C, 0x0F, 0x81, 0xCF,
  0x06, 0xC1, 0xE3, 0x87, 0x70, 0xF1, 0xC3, 0xB8, 0x70, 0xE1, 0xDC, 0x38,
  0x78, 0xC6, 0x3C, 0x1C, 0xE3, 0x9C, 0x0E, 0x71, 0xCE, 0x07, 0x38, 0xE7,
  0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x03,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x38, 0x0E,
  0x3C, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x07, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x0E, 0x38, 0x1E, 0x3C,
  0x3C, 0x1E, 0x78, 0x0E, 0xF8, 0x0F, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F,
  0x78, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x38,
  0x0E, 0x38, 0x0E, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC1,
  0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0xF0, 0xF8, 0x3C, 0x0F, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xC1, 0xF0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3E, 0x0F, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0xC0, 0x70, 0xFC, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0xFC, 0x3E, 0x0E, 0x00, 0x3E, 0x02, 0xFF, 0x8F, 0x9F, 0xFC,
  0x07, 0xE0,
};

const GFXglyph NotoSans_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 9, 8, 13, 2, -22 },
  { 21, 18, 22, 20, 1, -22 },
  { 71, 14, 26, 18, 2, -24 },
  { 117, 24, 22, 26, 1, -22 },
  { 183, 21, 22, 23, 2, -22 },
  { 241, 3, 8, 7, 2, -22 },
  { 244, 8, 27, 10, 1, -22 },
  { 271, 7, 27, 10, 1, -22 },
  { 295, 15, 15, 17, 1, -24 },
  { 324, 15, 15, 18, 1, -18 },
  { 353, 5, 8, 8, 1, -4 },
  { 358, 8, 3, 10, 1, -10 },
  { 361, 4, 4, 8, 2, -4 },
  { 363, 12, 22, 12, 0, -22 },
  { 396, 15, 22, 18, 1, -22 },
  { 438, 10, 22, 18, 2, -22 },
  { 466, 15, 22, 18, 1, -22 },
  { 508, 15, 22, 18, 1, -22 },
  { 550, 16, 22, 18, 1, -22 },
  { 594, 14, 22, 18, 2, -22 },
  { 633, 14, 22, 18, 2, -22 },
  { 672, 15, 22, 18, 1, -22 },
  { 714, 15, 22, 18, 1, -22 },
  { 756, 15, 22, 18, 1, -22 },
  { 798, 4, 17, 8, 2, -17 },
  { 807, 5, 21, 8, 1, -17 },
  { 821, 15, 16, 18, 1, -19 },
  { 851, 14, 8, 18, 2, -15 },
  { 865, 15, 16, 18, 1, -19 },
  { 895, 13, 22, 14, 0, -22 },
  { 931, 24, 25, 28, 2, -22 },
  { 1006, 20, 22, 20, 0, -22 },
  { 1061, 16, 22, 20, 3, -22 },
  { 1105, 17, 22, 20, 2, -22 },
  { 1152, 18, 22, 23, 3, -22 },
  { 1202, 12, 22, 17, 3, -22 },
  { 1235, 12, 22, 16, 3, -22 },
  { 1268, 18, 22, 23, 2, -22 },
  { 1318, 17, 22, 23, 3, -22 },
  { 1365, 9, 22, 11, 1, -22 },
  { 1390, 8, 28, 9, -2, -22 },
  { 1418, 17, 22, 20, 3, -22 },
  { 1465, 13, 22, 17, 3, -22 },
  { 1501, 23, 22, 28, 3, -22 },
  { 1565, 18, 22, 24, 3, -22 },
  { 1615, 20, 22, 24, 2, -22 },
  { 1670, 14, 22, 19, 3, -22 },
  { 1709, 20, 27, 24, 2, -22 },
  { 1777, 16, 22, 20, 3, -22 },
  { 1821, 14, 22, 17, 2, -22 },
  { 1860, 17, 22, 17, 0, -22 },
  { 1907, 17, 22, 23, 3, -22 },
  { 1954, 19, 22, 19, 0, -22 },
  { 2007, 29, 22, 29, 0, -22 },
  { 2087, 19, 22, 19, 0, -22 },
  { 2140, 18, 22, 18, 0, -22 },
  { 2190, 16, 22, 18, 1, -22 },
  { 2234, 7, 27, 10, 2, -22 },
  { 2258, 12, 22, 12, 0, -22 },
  { 2291, 7, 27, 10, 1, -22 },
  { 2315, 16, 14, 18, 1, -22 },
  { 2343, 14, 2, 13, 0, 3 },
  { 2347, 7, 5, 9, 1, -24 },
  { 2352, 14, 17, 18, 1, -17 },
  { 2382, 15, 24, 19, 3, -24 },
  { 2427, 12, 17, 15, 2, -17 },
  { 2453, 15, 24, 19, 2, -24 },
  { 2498, 14, 17, 18, 2, -17 },
  { 2528, 12, 24, 11, 0, -24 },
  { 2564, 15, 24, 19, 2, -17 },
  { 2609, 14, 24, 19, 3, -24 },
  { 2651, 4, 23, 8, 2, -23 },
  { 2663, 8, 30, 8, -2, -23 },
  { 2693, 14, 24, 17, 3, -24 },
  { 2735, 3, 24, 8, 3, -24 },
  { 2744, 24, 17, 29, 3, -17 },
  { 2795, 14, 17, 19, 3, -17 },
  { 2825, 15, 17, 19, 2, -17 },
  { 2857, 15, 24, 19, 3, -17 },
  { 2902, 15, 24, 19, 2, -17 },
  { 2947, 10, 17, 13, 3, -17 },
  { 2969, 12, 17, 15, 2, -17 },
  { 2995, 10, 20, 12, 1, -20 },
  { 3020, 15, 17, 19, 2, -17 },
  { 3052, 16, 17, 16, 0, -17 },
  { 3086, 25, 17, 25, 0, -17 },
  { 3140, 16, 17, 17, 0, -17 },
  { 3174, 16, 24, 16, 0, -17 },
  { 3222, 13, 17, 15, 1, -17 },
  { 3250, 10, 27, 12, 1, -22 },
  { 3284, 3, 31, 17, 7, -24 },
  { 3296, 10, 27, 12, 1, -22 },
  { 3330, 15, 4, 18, 1, -13 },
};

const GFXfont NotoSans_Medium31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium31pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_MEDIUM31PT7B_H_
