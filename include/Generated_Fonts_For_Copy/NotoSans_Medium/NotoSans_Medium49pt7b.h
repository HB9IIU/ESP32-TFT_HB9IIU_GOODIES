#ifndef _NOTOSANS_MEDIUM49PT7B_H_
#define _NOTOSANS_MEDIUM49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF1, 0xC0, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x0F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0x79, 0xF9, 0xF8, 0xF0, 0x23, 0xE1, 0xE0,
  0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3F, 0x1E, 0x00,
  0x7F, 0xBC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3C, 0x7E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xF8, 0x03,
  0xC3, 0xE8, 0x07, 0x87, 0xDE, 0x0F, 0x3F, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x1E, 0x00, 0x3E, 0x07, 0x80,
  0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x1E, 0x1F,
  0x00, 0x03, 0xE0, 0x78, 0x78, 0x00, 0x0F, 0x81, 0xE3, 0xE3, 0xFC, 0x1E,
  0x0F, 0x8F, 0x1F, 0xF8, 0x78, 0x3C, 0x7C, 0xFF, 0xF1, 0xF1, 0xF1, 0xE3,
  0xE7, 0xC3, 0xFF, 0x8F, 0x1F, 0x0F, 0x87, 0xFE, 0x3C, 0x78, 0x1E, 0x0F,
  0xE1, 0xE1, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0x81, 0xE0, 0x00, 0x3C, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x7C, 0x00,
  0x3E, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0x78,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x7F, 0xFE, 0x00, 0xFC,
  0x1F, 0xDF, 0xC0, 0x3E, 0x0F, 0xC3, 0xF8, 0x0F, 0x87, 0xE0, 0x7F, 0x07,
  0xE1, 0xF8, 0x0F, 0xE1, 0xF0, 0x7C, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0x1F,
  0xBE, 0x0F, 0xC0, 0x03, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xC0, 0x7C, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xFF, 0x1F, 0xC0,
  0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xFC, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x20, 0x1E, 0x00, 0xFC,
  0x1C, 0x1E, 0xFF, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF7,
  0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0xFC, 0x1F,
  0x80, 0x70, 0x1C, 0x00, 0x20, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF3, 0xF7, 0xFF, 0x9F, 0xFC, 0x7D, 0xE1, 0xF2, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x03, 0xF8, 0x3C, 0x00, 0xFC, 0x10,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC7, 0xE0, 0x1F, 0xC7, 0x00, 0x1F, 0x88, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xEF,
  0x00, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0xC0, 0x7C, 0xFF, 0xF0, 0x7D,
  0xFF, 0xF8, 0x7B, 0xFF, 0xFC, 0xFF, 0xC0, 0xFE, 0xFF, 0x00, 0x7E, 0xFE,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0xC1, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0xC3, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC7, 0xF8, 0x3F, 0x01, 0xFC, 0x7E,
  0x00, 0xFE, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x7C,
  0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x7E, 0x00, 0xFC, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x01, 0xFF, 0x3F,
  0xFF, 0xDF, 0x1F, 0xFF, 0x9E, 0x0F, 0xFF, 0x3E, 0x03, 0xFC, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF,
  0xFD, 0xF1, 0xC0, 0x1E, 0x3F, 0x7F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xC0, 0x7F, 0x18, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x03, 0xE3, 0xE0, 0x1F, 0xFF, 0x07,
  0x8F, 0x01, 0xFF, 0xFC, 0x1F, 0x78, 0x0F, 0xFF, 0xF0, 0x3D, 0xE0, 0x7E,
  0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x1F, 0x03, 0xFC, 0x0F, 0x80, 0x7C, 0x0F,
  0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0xC0, 0xF0, 0x07, 0x80, 0xFF, 0x03, 0xC0,
  0x1E, 0x03, 0xFC, 0x1F, 0x00, 0x78, 0x0F, 0xF0, 0x7C, 0x01, 0xE0, 0x3F,
  0xC1, 0xF0, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x1E, 0x03, 0xFC, 0x0F, 0x00,
  0xF8, 0x1E, 0xF0, 0x3E, 0x03, 0xF0, 0x7B, 0xC0, 0xFC, 0x1F, 0xC3, 0xCF,
  0x01, 0xFF, 0xF7, 0xFF, 0x3E, 0x03, 0xFF, 0x9F, 0xF8, 0x78, 0x07, 0xFC,
  0x3F, 0xC1, 0xF0, 0x03, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x10, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80,
  0xFF, 0xC7, 0xC0, 0x07, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0x00, 0x3F,
  0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00,
  0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x07, 0xFB, 0xE0, 0x3F, 0xF9, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0xF8, 0x3F, 0xC0, 0x03, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x83, 0xFE, 0x01, 0xE0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x0F, 0xF0, 0xF8, 0x00, 0x3F, 0x8F,
  0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x7F, 0x8F, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x3E, 0x07, 0xF8, 0x00, 0x30,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F,
  0xF0, 0x00, 0x7C, 0x3F, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0x18, 0x00,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x03,
  0xF8, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80,
  0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFD, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xE0, 0x0F,
  0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x3E, 0x01, 0xF8,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFD, 0xF0, 0x00, 0x1F, 0xFF, 0xBE, 0x00, 0x03, 0xFF, 0xF7, 0xC0, 0x00,
  0x7B, 0xFE, 0x7C, 0x00, 0x1F, 0x7F, 0xCF, 0x80, 0x03, 0xCF, 0xF8, 0xF0,
  0x00, 0x79, 0xFF, 0x1F, 0x00, 0x1F, 0x3F, 0xE3, 0xE0, 0x03, 0xC7, 0xFC,
  0x3C, 0x00, 0xF8, 0xFF, 0x87, 0xC0, 0x1F, 0x1F, 0xF0, 0xF8, 0x03, 0xC3,
  0xFE, 0x0F, 0x00, 0xF8, 0x7F, 0xC1, 0xF0, 0x1F, 0x0F, 0xF8, 0x3E, 0x03,
  0xC1, 0xFF, 0x03, 0xE0, 0xF8, 0x3F, 0xE0, 0x7C, 0x1E, 0x07, 0xFC, 0x0F,
  0x87, 0xC0, 0xFF, 0x80, 0xF8, 0xF8, 0x1F, 0xF0, 0x1F, 0x1E, 0x03, 0xFE,
  0x01, 0xE7, 0xC0, 0x7F, 0xC0, 0x3E, 0xF8, 0x0F, 0xF8, 0x07, 0xDE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x03, 0xF0, 0x03, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x7E, 0x00, 0x1F,
  0xF7, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x1F, 0xF1, 0xF8, 0x01, 0xFF, 0x1F,
  0x80, 0x1F, 0xF0, 0xFC, 0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xF0, 0x7E, 0x01,
  0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x1F, 0xF0,
  0x0F, 0xC1, 0xFF, 0x00, 0xFC, 0x1F, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0x7E,
  0x0F, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0x8F, 0xF0, 0x01, 0xF8, 0xFF,
  0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x7E, 0xFF, 0x00, 0x07, 0xEF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF8, 0x7F,
  0xFB, 0xE0, 0x0F, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7E, 0xF8, 0x07, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x81, 0xFF, 0x87,
  0xC0, 0x0F, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7E,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x07, 0xF0, 0xF8, 0x3F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F,
  0x8F, 0xC0, 0x03, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xDC, 0x00, 0x1F,
  0xBF, 0x00, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xF8, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x1F, 0x00,
  0x3D, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF3, 0xC0, 0x0F, 0x81, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF0, 0x03, 0xCF, 0xC0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x7C,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xE7, 0x80, 0x03, 0xC7, 0x80,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0x83, 0xF8, 0x30, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x07, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0x87, 0xDF, 0xC0, 0x1F, 0x7E, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xF7, 0xE0, 0x3F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0x3C, 0xFF, 0xF8,
  0xF0, 0xFF, 0xC3, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0xFF, 0xC0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xE7,
  0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0xFF, 0xF8, 0xFB, 0xFF,
  0xF0, 0xF1, 0xFF, 0xE0, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7E, 0x00, 0x9F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x4F,
  0xE0, 0x39, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0xF8, 0x3F, 0xF9, 0xF0, 0xFF,
  0xFB, 0xE3, 0xFF, 0xFF, 0xCF, 0xF3, 0xFF, 0xBF, 0x80, 0x7F, 0x7E, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7F, 0x7F, 0x01, 0xFE, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFE, 0x78, 0x7F, 0xF8, 0xF0, 0x3F, 0xE1, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8,
  0x3F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x8F, 0xE0, 0x0E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xFE, 0x3C, 0x3F, 0xFE, 0x78, 0xFF, 0xFE, 0xF3, 0xFC, 0x7F, 0xEF,
  0xE0, 0x1F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBE, 0x1F, 0xFE, 0x7C,
  0x0F, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x40, 0x00, 0x7E, 0xE0, 0x03, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0xBF,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC7, 0xFF,
  0x0F, 0x9F, 0xFF, 0x9F, 0x7F, 0xFF, 0x3F, 0xF9, 0xFF, 0x7F, 0x80, 0x7E,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xE0, 0xFB, 0xEF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x0F, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFE, 0x0F, 0xC0, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x9F,
  0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0,
  0x7E, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x7E,
  0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xF9, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3,
  0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xEF, 0x80, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x1F, 0x81, 0xE1, 0xFF, 0xC1, 0xFF, 0xC3, 0xEF, 0xFF, 0xC7, 0xFF, 0xC7,
  0xDF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFE, 0x7F, 0xFE, 0x7F, 0xDF, 0xE0, 0x3F,
  0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0x00, 0x3E,
  0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00,
  0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0x00,
  0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xF0,
  0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x81,
  0xE1, 0xFF, 0xC3, 0xE7, 0xFF, 0xE7, 0xDF, 0xFF, 0xCF, 0xFE, 0x7F, 0xDF,
  0xE0, 0x1F, 0xBF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x01, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0xF0, 0xFF, 0xE0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8,
  0xFF, 0xE7, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFB, 0xFF, 0xF0, 0xF9, 0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xFE, 0x3C, 0x3F, 0xFE, 0x78, 0xFF, 0xFE, 0xF3, 0xFC, 0x7F, 0xEF,
  0xE0, 0x1F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBE, 0x1F, 0xFE, 0x7C,
  0x0F, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xFB, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E, 0x07, 0xC7, 0xC0, 0x04, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x3E, 0xF0, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xDF, 0x1F, 0xFF, 0x3E,
  0x1F, 0xF8, 0x7C, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0xEF, 0xC0, 0x1F, 0xC0, 0x0F, 0x9F, 0x00, 0x7F, 0x80, 0x3E, 0x7C,
  0x03, 0xFE, 0x01, 0xF9, 0xF0, 0x0F, 0x78, 0x07, 0xC7, 0xE0, 0x3D, 0xF0,
  0x1F, 0x0F, 0x80, 0xF3, 0xC0, 0x7C, 0x3E, 0x07, 0xCF, 0x03, 0xF0, 0xF8,
  0x1E, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0xF8, 0x3E, 0x07, 0xC3, 0xE1, 0xE0,
  0xF8, 0x1F, 0x0F, 0x87, 0x87, 0xC0, 0x7C, 0x3C, 0x1F, 0x1F, 0x00, 0xF9,
  0xF0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x0F, 0x9E, 0x03, 0xCF,
  0x80, 0x3E, 0x78, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x1E, 0xF8, 0x01, 0xFF,
  0x80, 0x7B, 0xC0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7,
  0xC0, 0x01, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF3,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1B, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x01, 0x3F, 0xF0, 0x03, 0x7F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_Medium49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 36, 13, 3, -35 },
  { 33, 15, 13, 21, 3, -35 },
  { 58, 29, 35, 32, 1, -35 },
  { 185, 23, 40, 28, 3, -37 },
  { 300, 38, 35, 42, 2, -35 },
  { 467, 34, 36, 36, 2, -36 },
  { 620, 5, 13, 12, 3, -35 },
  { 629, 12, 43, 15, 2, -35 },
  { 694, 12, 43, 15, 1, -35 },
  { 759, 23, 22, 27, 2, -37 },
  { 823, 24, 24, 28, 2, -29 },
  { 895, 8, 12, 13, 2, -6 },
  { 907, 12, 4, 16, 2, -15 },
  { 913, 7, 7, 13, 3, -6 },
  { 920, 18, 35, 19, 0, -35 },
  { 999, 24, 36, 28, 2, -36 },
  { 1107, 14, 35, 28, 4, -35 },
  { 1169, 24, 35, 28, 2, -35 },
  { 1274, 23, 35, 28, 2, -35 },
  { 1375, 26, 35, 28, 1, -35 },
  { 1489, 22, 35, 28, 3, -35 },
  { 1586, 24, 35, 28, 2, -35 },
  { 1691, 24, 35, 28, 2, -35 },
  { 1796, 24, 35, 28, 2, -35 },
  { 1901, 24, 35, 28, 2, -35 },
  { 2006, 7, 28, 13, 3, -27 },
  { 2031, 8, 33, 13, 2, -27 },
  { 2064, 24, 25, 28, 2, -30 },
  { 2139, 22, 14, 28, 3, -24 },
  { 2178, 24, 25, 28, 2, -30 },
  { 2253, 21, 36, 22, 0, -35 },
  { 2348, 38, 39, 44, 3, -35 },
  { 2534, 32, 35, 32, 0, -35 },
  { 2674, 25, 35, 32, 5, -35 },
  { 2784, 27, 35, 31, 3, -35 },
  { 2903, 28, 35, 36, 5, -35 },
  { 3026, 19, 35, 27, 5, -35 },
  { 3110, 19, 35, 26, 5, -35 },
  { 3194, 29, 35, 36, 3, -35 },
  { 3321, 27, 35, 37, 5, -35 },
  { 3440, 13, 35, 17, 2, -35 },
  { 3497, 14, 45, 14, -4, -35 },
  { 3576, 26, 35, 31, 5, -35 },
  { 3690, 20, 35, 26, 5, -35 },
  { 3778, 35, 35, 45, 5, -35 },
  { 3932, 28, 35, 38, 5, -35 },
  { 4055, 32, 36, 38, 3, -36 },
  { 4199, 22, 35, 30, 5, -35 },
  { 4296, 32, 44, 38, 3, -36 },
  { 4472, 25, 35, 31, 5, -35 },
  { 4582, 23, 35, 27, 2, -35 },
  { 4683, 26, 35, 28, 1, -35 },
  { 4797, 28, 35, 36, 4, -35 },
  { 4920, 30, 35, 30, 0, -35 },
  { 5052, 46, 35, 46, 0, -35 },
  { 5254, 30, 35, 30, 0, -35 },
  { 5386, 29, 35, 29, 0, -35 },
  { 5513, 24, 35, 28, 2, -35 },
  { 5618, 11, 43, 16, 4, -35 },
  { 5678, 18, 35, 19, 0, -35 },
  { 5757, 11, 43, 16, 1, -35 },
  { 5817, 24, 22, 28, 2, -35 },
  { 5883, 21, 4, 21, 0, 4 },
  { 5894, 11, 8, 15, 2, -38 },
  { 5905, 22, 27, 28, 2, -27 },
  { 5980, 24, 37, 30, 4, -37 },
  { 6091, 19, 27, 24, 3, -27 },
  { 6156, 23, 37, 30, 3, -37 },
  { 6263, 23, 27, 28, 3, -27 },
  { 6341, 19, 37, 18, 1, -37 },
  { 6429, 23, 39, 30, 3, -27 },
  { 6542, 23, 37, 31, 4, -37 },
  { 6649, 6, 36, 13, 4, -36 },
  { 6676, 13, 48, 13, -3, -36 },
  { 6754, 23, 37, 27, 4, -37 },
  { 6861, 5, 37, 13, 4, -37 },
  { 6885, 39, 27, 46, 4, -27 },
  { 7017, 23, 27, 31, 4, -27 },
  { 7095, 24, 27, 30, 3, -27 },
  { 7176, 24, 39, 30, 4, -27 },
  { 7293, 23, 39, 30, 3, -27 },
  { 7406, 16, 27, 21, 4, -27 },
  { 7460, 20, 27, 24, 2, -27 },
  { 7528, 17, 32, 19, 1, -32 },
  { 7596, 23, 26, 31, 4, -26 },
  { 7671, 26, 26, 26, 0, -26 },
  { 7756, 38, 26, 40, 1, -26 },
  { 7880, 25, 26, 27, 1, -26 },
  { 7962, 26, 38, 26, 0, -26 },
  { 8086, 20, 26, 23, 2, -26 },
  { 8151, 16, 43, 19, 1, -35 },
  { 8237, 5, 49, 27, 11, -37 },
  { 8268, 16, 43, 19, 2, -35 },
  { 8354, 24, 7, 28, 2, -21 },
};

const GFXfont NotoSans_Medium49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium49pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_MEDIUM49PT7B_H_
