#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Medium
// Headers: 67

#include "NotoSans_Medium6pt7b.h"
#include "NotoSans_Medium7pt7b.h"
#include "NotoSans_Medium8pt7b.h"
#include "NotoSans_Medium9pt7b.h"
#include "NotoSans_Medium10pt7b.h"
#include "NotoSans_Medium11pt7b.h"
#include "NotoSans_Medium12pt7b.h"
#include "NotoSans_Medium13pt7b.h"
#include "NotoSans_Medium14pt7b.h"
#include "NotoSans_Medium15pt7b.h"
#include "NotoSans_Medium16pt7b.h"
#include "NotoSans_Medium17pt7b.h"
#include "NotoSans_Medium18pt7b.h"
#include "NotoSans_Medium19pt7b.h"
#include "NotoSans_Medium20pt7b.h"
#include "NotoSans_Medium21pt7b.h"
#include "NotoSans_Medium22pt7b.h"
#include "NotoSans_Medium23pt7b.h"
#include "NotoSans_Medium24pt7b.h"
#include "NotoSans_Medium25pt7b.h"
#include "NotoSans_Medium26pt7b.h"
#include "NotoSans_Medium27pt7b.h"
#include "NotoSans_Medium28pt7b.h"
#include "NotoSans_Medium29pt7b.h"
#include "NotoSans_Medium30pt7b.h"
#include "NotoSans_Medium31pt7b.h"
#include "NotoSans_Medium32pt7b.h"
#include "NotoSans_Medium33pt7b.h"
#include "NotoSans_Medium34pt7b.h"
#include "NotoSans_Medium35pt7b.h"
#include "NotoSans_Medium36pt7b.h"
#include "NotoSans_Medium37pt7b.h"
#include "NotoSans_Medium38pt7b.h"
#include "NotoSans_Medium39pt7b.h"
#include "NotoSans_Medium40pt7b.h"
#include "NotoSans_Medium41pt7b.h"
#include "NotoSans_Medium42pt7b.h"
#include "NotoSans_Medium43pt7b.h"
#include "NotoSans_Medium44pt7b.h"
#include "NotoSans_Medium45pt7b.h"
#include "NotoSans_Medium46pt7b.h"
#include "NotoSans_Medium47pt7b.h"
#include "NotoSans_Medium48pt7b.h"
#include "NotoSans_Medium49pt7b.h"
#include "NotoSans_Medium50pt7b.h"
#include "NotoSans_Medium51pt7b.h"
#include "NotoSans_Medium52pt7b.h"
#include "NotoSans_Medium53pt7b.h"
#include "NotoSans_Medium54pt7b.h"
#include "NotoSans_Medium55pt7b.h"
#include "NotoSans_Medium56pt7b.h"
#include "NotoSans_Medium57pt7b.h"
#include "NotoSans_Medium58pt7b.h"
#include "NotoSans_Medium59pt7b.h"
#include "NotoSans_Medium60pt7b.h"
#include "NotoSans_Medium61pt7b.h"
#include "NotoSans_Medium62pt7b.h"
#include "NotoSans_Medium63pt7b.h"
#include "NotoSans_Medium64pt7b.h"
#include "NotoSans_Medium65pt7b.h"
#include "NotoSans_Medium66pt7b.h"
#include "NotoSans_Medium67pt7b.h"
#include "NotoSans_Medium68pt7b.h"
#include "NotoSans_Medium69pt7b.h"
#include "NotoSans_Medium70pt7b.h"
#include "NotoSans_Medium71pt7b.h"
#include "NotoSans_Medium72pt7b.h"
