#ifndef _NOTOSANS_MEDIUM36PT7B_H_
#define _NOTOSANS_MEDIUM36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x71,
  0x80, 0x00, 0x19, 0xFF, 0xFB, 0xC8, 0xF1, 0xFE, 0x3F, 0xC7, 0xB8, 0xF7,
  0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x18, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x70, 0x70, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xE1, 0xC0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x1C, 0x1C,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x01,
  0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFB, 0xE6, 0x19, 0xE3, 0x00, 0xF1, 0x80,
  0x78, 0xC0, 0x3E, 0x60, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x01, 0xBF, 0x00, 0xC7, 0xC0, 0x61, 0xE0, 0x30, 0xF0,
  0x18, 0x7F, 0x0C, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x1C, 0x0F, 0xF0,
  0x07, 0x01, 0xFF, 0x00, 0xE0, 0x70, 0xE0, 0x38, 0x0E, 0x1C, 0x07, 0x01,
  0xC3, 0x81, 0xC0, 0x38, 0x38, 0x78, 0x07, 0x07, 0x0E, 0x00, 0xE0, 0xE3,
  0xC0, 0x1C, 0x3C, 0x70, 0x03, 0x87, 0x1C, 0x38, 0x70, 0xE3, 0x9F, 0xCE,
  0x1C, 0xE7, 0xFC, 0xFF, 0x9C, 0xE3, 0x9F, 0xE7, 0x3C, 0x78, 0xF9, 0xE7,
  0x07, 0x00, 0x38, 0xE0, 0xE0, 0x0F, 0x1C, 0x1C, 0x01, 0xC3, 0x83, 0x80,
  0x70, 0x70, 0x70, 0x0E, 0x0E, 0x0E, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0x1C,
  0x70, 0x1C, 0x03, 0xDE, 0x07, 0x80, 0x3F, 0xC0, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xC3, 0xC0, 0x03,
  0xC0, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xF1, 0xFB, 0xE0, 0x78, 0xF0, 0xF8,
  0x78, 0xF8, 0x3E, 0x3C, 0x78, 0x0F, 0xBC, 0x3C, 0x03, 0xFE, 0x1E, 0x00,
  0xFE, 0x0F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x3F, 0xE0, 0xFF,
  0xFE, 0xF8, 0x3F, 0xFE, 0x3E, 0x07, 0xFC, 0x0F, 0xC0, 0xFF, 0xF7, 0x77,
  0x77, 0x77, 0x03, 0x83, 0x83, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78,
  0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0E,
  0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x1C, 0x07, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F,
  0x07, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xC1,
  0xC1, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x08, 0x1C,
  0x0B, 0x86, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xEF, 0x00, 0xF3, 0xC0, 0xF1, 0xF0, 0x78, 0x78, 0x08, 0x30,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x3C, 0xF3, 0xDE, 0x79, 0xC7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x33, 0xFF, 0xF7, 0x90, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x87, 0xC7, 0x81,
  0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xE7, 0x00, 0xF3, 0xC0,
  0x79, 0xF0, 0x78, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xC0,
  0xF0, 0xFC, 0x7F, 0x3F, 0xDE, 0x7F, 0x1D, 0x87, 0x41, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F,
  0xFF, 0x9F, 0x87, 0xC7, 0x01, 0xF2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0x07, 0xC6,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7B, 0x00, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xDC, 0x00, 0x7B, 0x80, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x3C,
  0x38, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83, 0x80,
  0x70, 0xF0, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xF8,
  0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0x83, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF4, 0x00, 0x7B,
  0x80, 0xF9, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x83, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xFE, 0x1E, 0xFF, 0xCE, 0xFF,
  0xF7, 0xE0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xF7, 0x00, 0x7B, 0xC0, 0x78, 0xF0, 0x7C, 0x7F, 0xFC,
  0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83,
  0xE7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3C, 0xE0, 0x1E, 0x78, 0x0F, 0x3E,
  0x0F, 0x0F, 0xDF, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xF9, 0xF8,
  0xF0, 0x3E, 0xF0, 0x0F, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x3C, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x87, 0xCF, 0x81, 0xE7, 0x80,
  0x7B, 0xC0, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x81, 0xFB, 0xF3, 0xFC, 0xFF, 0xDE, 0x3F, 0xCF, 0x03, 0x87,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0x73, 0xFF, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0xFE, 0xF2, 0x00, 0x38, 0xF7,
  0xDF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF7,
  0x9E, 0x79, 0xC7, 0x38, 0xE0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE1, 0xFF,
  0xF1, 0xFF, 0xF3, 0xC1, 0xF4, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7E,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0xE3, 0x80, 0xFE, 0x0E, 0x78, 0x3F, 0xF8, 0x77, 0x07, 0xFF, 0x87, 0x70,
  0xF0, 0x78, 0x7F, 0x0E, 0x07, 0x07, 0xE1, 0xE0, 0x70, 0x7E, 0x1E, 0x07,
  0x07, 0xE1, 0xC0, 0x70, 0x7E, 0x1C, 0x07, 0x07, 0xE1, 0xC0, 0x70, 0x7E,
  0x1E, 0x07, 0x07, 0xE0, 0xE0, 0xF8, 0xEE, 0x0F, 0xBF, 0xFE, 0x70, 0x7F,
  0x9F, 0xC7, 0x03, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEF, 0x00,
  0x01, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xC3, 0x80,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x81, 0xE0,
  0x0F, 0x01, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x00, 0x7D,
  0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF3,
  0xC0, 0x3E, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x3C, 0x07, 0xE7,
  0x80, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x03, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x3E,
  0x1F, 0x00, 0x23, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x60,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x7E, 0x78, 0x01, 0xF3, 0xC0,
  0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF,
  0x00, 0x3E, 0x78, 0x03, 0xF3, 0xC0, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xC3, 0xE1, 0xF0, 0x01, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xF8, 0x00, 0x73, 0xC0,
  0x03, 0x9F, 0x80, 0x1C, 0x7E, 0x00, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE1, 0xFE, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE3, 0xEF, 0xFB, 0xFC, 0xFC, 0x00, 0xF0,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x1F, 0x0F,
  0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00,
  0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0,
  0x0F, 0x8F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x01,
  0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0xF0,
  0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x3B, 0xFD, 0xC0, 0x07, 0x7F, 0xBC, 0x01, 0xEF, 0xF7, 0x80, 0x39, 0xFE,
  0x70, 0x07, 0x3F, 0xCF, 0x01, 0xE7, 0xF9, 0xE0, 0x38, 0xFF, 0x1C, 0x07,
  0x1F, 0xE3, 0xC1, 0xE3, 0xFC, 0x38, 0x38, 0x7F, 0x87, 0x0F, 0x0F, 0xF0,
  0xF1, 0xC1, 0xFE, 0x0E, 0x38, 0x3F, 0xC1, 0xCF, 0x07, 0xF8, 0x3D, 0xC0,
  0xFF, 0x03, 0xB8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x80,
  0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xC0, 0x3C, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0x78, 0x03, 0xFD, 0xF0, 0x0F, 0xF3, 0xC0, 0x3F, 0xCF, 0x80,
  0xFF, 0x1E, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF8, 0x3F, 0xC1, 0xE0, 0xFF,
  0x03, 0xC3, 0xFC, 0x0F, 0x8F, 0xF0, 0x1E, 0x3F, 0xC0, 0x7C, 0xFF, 0x00,
  0xFB, 0xFC, 0x01, 0xEF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x7C,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF,
  0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x00, 0xF9, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x07, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x0F, 0x00,
  0xF1, 0xE0, 0x1F, 0x3C, 0x01, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xDE, 0x00,
  0x3C, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x7E, 0x3E, 0xF8, 0x02, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x3E, 0xFF,
  0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0xF7, 0xC0, 0x1E, 0x3E, 0x07, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x07, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x00,
  0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x03,
  0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xDE, 0x00, 0x78, 0x01, 0xE7,
  0x80, 0x3E, 0x00, 0x79, 0xE0, 0x0F, 0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07,
  0x0F, 0x01, 0xFC, 0x03, 0xC3, 0xC0, 0x7F, 0x80, 0xF0, 0xF0, 0x1D, 0xE0,
  0x3C, 0x3C, 0x07, 0x38, 0x0E, 0x07, 0x83, 0xCE, 0x07, 0x81, 0xE0, 0xF3,
  0xC1, 0xE0, 0x78, 0x38, 0xF0, 0x78, 0x1E, 0x1E, 0x1C, 0x1C, 0x03, 0xC7,
  0x87, 0x8F, 0x00, 0xF1, 0xC1, 0xE3, 0xC0, 0x3C, 0x70, 0x38, 0xF0, 0x07,
  0x3C, 0x0E, 0x38, 0x01, 0xCF, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0xF7, 0x80,
  0x1E, 0xE0, 0x1D, 0xE0, 0x03, 0xF8, 0x07, 0x70, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x03, 0xCF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0x78, 0x03, 0xC1,
  0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x07, 0x83, 0xE0, 0x1F, 0x0F, 0x00, 0x3C,
  0x78, 0x00, 0xFB, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0x70, 0x0E, 0x1C,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x01, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x3E, 0x3E, 0x10, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x03, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x7F, 0xE7, 0x3F, 0xC7,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE1, 0xE0, 0xF7, 0xFC, 0x7F, 0xFF, 0x3F, 0xDF, 0xDF,
  0x01, 0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0xF8, 0x3E, 0xFF, 0xFF, 0x73, 0xFF, 0x38, 0xFE, 0x00, 0x01, 0xF0,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x04, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x07, 0x87, 0x1F, 0xF3, 0x9F, 0xFD, 0xCF, 0xDF, 0xEF,
  0x81, 0xF7, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3D, 0xE0,
  0x1E, 0xF8, 0x1F, 0x3F, 0xFB, 0x8F, 0xFD, 0xC3, 0xF8, 0xE0, 0x01, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x87, 0xC7, 0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0x1F, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xE0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x07, 0xFF, 0x3F, 0xF9, 0xFF,
  0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0xF9, 0xCF, 0xFE, 0xE7, 0xE7, 0xF7,
  0xC0, 0xFB, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1E, 0xF0,
  0x0F, 0x7C, 0x0F, 0x9F, 0xFF, 0xC7, 0xFE, 0xE1, 0xFC, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x40, 0x0F, 0xBF, 0xBF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x80, 0x7C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0xF7, 0xFC,
  0x7F, 0xFF, 0x3F, 0xCF, 0xDF, 0x81, 0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xE0, 0x6F, 0xFF, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x30, 0x00,
  0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0x7F, 0xBF, 0x8E, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x1F, 0x1E, 0x1F, 0x0F,
  0x1F, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0x3C, 0x0F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xF1, 0xE0,
  0x78, 0xF0, 0x1E, 0x78, 0x0F, 0xBC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x0F, 0x0E, 0x7F, 0xC7, 0xFC, 0xEF, 0xFE, 0xFF, 0xEF, 0xF7, 0xFF, 0x7F,
  0xF8, 0x1F, 0xC0, 0xFF, 0x80, 0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x73, 0xFF,
  0x3B, 0xFF, 0xDF, 0xE7, 0xEF, 0x80, 0xF7, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC,
  0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80,
  0x7D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0,
  0x01, 0xF0, 0x73, 0xFE, 0x3B, 0xFF, 0x9F, 0xEF, 0xEF, 0x80, 0xF7, 0xC0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F,
  0x7F, 0xFF, 0xBD, 0xFF, 0x9E, 0x7F, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF9, 0xCF, 0xFE, 0xE7, 0xEF, 0xF7, 0xC0,
  0xFB, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1E, 0xF0, 0x0F,
  0x7C, 0x0F, 0x9F, 0xFD, 0xC7, 0xFE, 0xE1, 0xFC, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xFE, 0x3F, 0xE7, 0xEE, 0xFE, 0xFE, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC0,
  0xFF, 0xF7, 0xFF, 0xBE, 0x1E, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0x7F, 0xFF, 0xBF, 0xFB, 0xC7,
  0xF9, 0xE0, 0xF0, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x01,
  0xC3, 0xC0, 0x3C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00,
  0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x7B, 0xC0, 0x7C, 0x07, 0x9E, 0x03, 0xE0, 0x3C, 0xF0,
  0x3B, 0x81, 0xE3, 0xC1, 0xDC, 0x1E, 0x1E, 0x0E, 0xE0, 0xF0, 0xF0, 0xF7,
  0x87, 0x83, 0x87, 0x1C, 0x38, 0x1E, 0x38, 0xE3, 0xC0, 0xF1, 0xC7, 0x1E,
  0x07, 0x9E, 0x3C, 0xF0, 0x1C, 0xE0, 0xE7, 0x00, 0xF7, 0x07, 0x78, 0x07,
  0xB8, 0x3F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE7,
  0x80, 0xF0, 0x78, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x0F, 0x7C, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x7B, 0xE0, 0x1F, 0x3C, 0x03, 0xC3, 0xC0, 0xF0, 0x7C, 0x3E,
  0x07, 0x87, 0x80, 0x7B, 0xE0, 0x0F, 0x80, 0xF0, 0x01, 0xEF, 0x00, 0x79,
  0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xC0,
  0xF0, 0x78, 0x0E, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0x8F, 0x00,
  0x7B, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x5F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x70, 0x3F, 0x07, 0xF0, 0x7C, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xFE,
  0x0F, 0x80, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x7F, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x7E, 0x0F,
  0xE0, 0xF8, 0x0E, 0x00, 0x7F, 0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE8, 0x03, 0xE0,
};

const GFXglyph NotoSans_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 27, 10, 2, -26 },
  { 18, 11, 10, 15, 2, -26 },
  { 32, 21, 26, 23, 1, -26 },
  { 101, 17, 29, 21, 2, -27 },
  { 163, 27, 26, 31, 2, -26 },
  { 251, 25, 26, 27, 2, -26 },
  { 333, 4, 10, 9, 2, -26 },
  { 338, 9, 32, 11, 1, -26 },
  { 374, 9, 32, 11, 1, -26 },
  { 410, 17, 16, 20, 1, -27 },
  { 444, 17, 17, 21, 2, -21 },
  { 481, 6, 9, 10, 1, -4 },
  { 488, 9, 3, 12, 1, -11 },
  { 492, 5, 6, 10, 2, -5 },
  { 496, 14, 26, 14, 0, -26 },
  { 542, 17, 26, 21, 2, -26 },
  { 598, 10, 26, 21, 3, -26 },
  { 631, 17, 26, 21, 2, -26 },
  { 687, 17, 26, 21, 2, -26 },
  { 743, 19, 26, 21, 1, -26 },
  { 805, 17, 26, 21, 2, -26 },
  { 861, 17, 26, 21, 2, -26 },
  { 917, 18, 26, 21, 1, -26 },
  { 976, 17, 26, 21, 2, -26 },
  { 1032, 17, 26, 21, 2, -26 },
  { 1088, 5, 21, 10, 2, -20 },
  { 1102, 6, 25, 10, 1, -20 },
  { 1121, 17, 18, 21, 2, -22 },
  { 1160, 17, 10, 21, 2, -18 },
  { 1182, 17, 18, 21, 2, -22 },
  { 1221, 15, 27, 16, 0, -26 },
  { 1272, 28, 29, 32, 2, -26 },
  { 1374, 24, 26, 24, 0, -26 },
  { 1452, 19, 26, 24, 3, -26 },
  { 1514, 20, 26, 23, 2, -26 },
  { 1579, 21, 26, 26, 3, -26 },
  { 1648, 15, 26, 20, 3, -26 },
  { 1697, 15, 26, 19, 3, -26 },
  { 1746, 21, 26, 26, 2, -26 },
  { 1815, 20, 26, 27, 3, -26 },
  { 1880, 10, 26, 13, 1, -26 },
  { 1913, 10, 33, 10, -3, -26 },
  { 1955, 20, 26, 23, 3, -26 },
  { 2020, 15, 26, 19, 3, -26 },
  { 2069, 27, 26, 33, 3, -26 },
  { 2157, 22, 26, 28, 3, -26 },
  { 2229, 24, 26, 28, 2, -26 },
  { 2307, 17, 26, 22, 3, -26 },
  { 2363, 24, 32, 28, 2, -26 },
  { 2459, 19, 26, 23, 3, -26 },
  { 2521, 16, 26, 20, 2, -26 },
  { 2573, 20, 26, 20, 0, -26 },
  { 2638, 20, 26, 27, 3, -26 },
  { 2703, 22, 26, 22, 0, -26 },
  { 2775, 34, 26, 34, 0, -26 },
  { 2886, 22, 26, 22, 0, -26 },
  { 2958, 21, 26, 21, 0, -26 },
  { 3027, 18, 26, 21, 1, -26 },
  { 3086, 8, 32, 12, 3, -26 },
  { 3118, 14, 26, 14, 0, -26 },
  { 3164, 8, 32, 12, 1, -26 },
  { 3196, 18, 17, 21, 1, -26 },
  { 3235, 16, 3, 16, 0, 3 },
  { 3241, 9, 6, 11, 1, -28 },
  { 3248, 16, 20, 21, 2, -20 },
  { 3288, 17, 27, 22, 3, -27 },
  { 3346, 15, 20, 18, 2, -20 },
  { 3384, 17, 27, 22, 2, -27 },
  { 3442, 17, 20, 21, 2, -20 },
  { 3485, 13, 28, 13, 1, -28 },
  { 3531, 17, 29, 22, 2, -20 },
  { 3593, 17, 27, 23, 3, -27 },
  { 3651, 4, 27, 10, 3, -27 },
  { 3665, 9, 36, 10, -2, -27 },
  { 3706, 17, 27, 20, 3, -27 },
  { 3764, 4, 27, 10, 3, -27 },
  { 3778, 28, 20, 34, 3, -20 },
  { 3848, 17, 20, 23, 3, -20 },
  { 3891, 18, 20, 22, 2, -20 },
  { 3936, 17, 29, 22, 3, -20 },
  { 3998, 17, 29, 22, 2, -20 },
  { 4060, 12, 20, 15, 3, -20 },
  { 4090, 14, 20, 18, 2, -20 },
  { 4125, 12, 24, 14, 1, -24 },
  { 4161, 17, 19, 23, 3, -19 },
  { 4202, 19, 19, 19, 0, -19 },
  { 4248, 29, 19, 29, 0, -19 },
  { 4317, 19, 19, 20, 0, -19 },
  { 4363, 19, 28, 19, 0, -19 },
  { 4430, 15, 19, 17, 1, -19 },
  { 4466, 12, 32, 14, 1, -26 },
  { 4514, 3, 36, 20, 8, -27 },
  { 4528, 12, 32, 14, 1, -26 },
  { 4576, 17, 5, 21, 2, -15 },
};

const GFXfont NotoSans_Medium36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium36pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_MEDIUM36PT7B_H_
