#ifndef _NOTOSANS_MEDIUM52PT7B_H_
#define _NOTOSANS_MEDIUM52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF, 0x7F,
  0x7E, 0x7E, 0x18, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x01,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFE, 0x3C, 0x1C, 0xFC,
  0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xFC,
  0x3C, 0x00, 0xFE, 0x3C, 0x00, 0x7F, 0xBC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0xFF, 0x00, 0x3C, 0x3F, 0x00,
  0x3C, 0x3F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x3F, 0xC0,
  0x3C, 0x7F, 0xFC, 0x3D, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x00,
  0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x1F,
  0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x07,
  0x80, 0x00, 0xF8, 0x0F, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0x1F, 0x0F, 0xF0,
  0x78, 0x1F, 0x1F, 0x3F, 0xF8, 0x7C, 0x1E, 0x3E, 0x3F, 0xFC, 0x3E, 0x7E,
  0x3C, 0x7C, 0x7E, 0x3F, 0xFC, 0x7C, 0x7C, 0x3E, 0x1F, 0xFC, 0x78, 0x78,
  0x1E, 0x0F, 0xF0, 0xF8, 0xF8, 0x1F, 0x01, 0xC0, 0xF0, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0xF8, 0x01, 0xF8, 0x7F, 0x3F,
  0x80, 0x3E, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x81, 0xF8, 0xFC,
  0x03, 0xF8, 0x3E, 0x1F, 0x80, 0x3F, 0x8F, 0xC3, 0xE0, 0x03, 0xF9, 0xF0,
  0x7C, 0x00, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xFF, 0x81, 0xF0, 0x00, 0x3F,
  0xF0, 0x3F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x1F,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79,
  0xE7, 0x9E, 0x78, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x3C,
  0x01, 0x70, 0x3C, 0x0F, 0xFF, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xC3,
  0xF0, 0x0F, 0xC1, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0x80, 0xE0, 0x01, 0x80,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0x7E, 0xFF, 0x7F, 0x7E, 0x7E, 0x18,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xC0,
  0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0xEF,
  0xBF, 0x9F, 0xFE, 0x3E, 0xF8, 0x7C, 0xE0, 0xF8, 0x81, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC3, 0xFC, 0x0F, 0xF0, 0xF8, 0x01, 0xF8, 0x30, 0x00, 0x7E, 0x10, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xF8, 0x0F, 0xF0, 0xF0, 0x01, 0xF8, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0xE0, 0x00, 0x7F, 0x7E, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x80, 0x00, 0x7E, 0xC0, 0x01, 0xFC, 0xFC, 0x07, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x10,
  0x01, 0xF0, 0xFF, 0xC0, 0xF9, 0xFF, 0xF0, 0x7D, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xF0, 0x1F, 0xCF, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0xE0, 0xFF,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F,
  0xE7, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xF8,
  0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0,
  0x1F, 0xE7, 0xF0, 0x3F, 0xF3, 0xFF, 0xFE, 0xF8, 0xFF, 0xFE, 0x7C, 0x3F,
  0xFE, 0x3E, 0x07, 0xFE, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x08, 0x07, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF, 0x7F, 0x7E, 0x7E, 0x18, 0x0C, 0x1F,
  0x8F, 0xCF, 0xF7, 0xF9, 0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C,
  0x3C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3E, 0x03, 0xF9,
  0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0xFC, 0x07, 0x87,
  0xC0, 0x3F, 0xFF, 0x83, 0xE3, 0xC0, 0x3F, 0xFF, 0xC0, 0xF3, 0xE0, 0x3F,
  0xDF, 0xE0, 0x79, 0xE0, 0x3F, 0x01, 0xF0, 0x3E, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0xF8, 0x1F, 0x00, 0x78, 0x07, 0xFC, 0x0F, 0x80, 0x3C, 0x03, 0xFC,
  0x0F, 0x80, 0x1E, 0x01, 0xFE, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0x03, 0xE0,
  0x07, 0x80, 0x7F, 0x81, 0xF0, 0x03, 0xC0, 0x7F, 0xC0, 0xF8, 0x03, 0xE0,
  0x3D, 0xE0, 0x7C, 0x01, 0xF0, 0x1E, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x78,
  0x0F, 0x80, 0xFC, 0x0F, 0x3E, 0x07, 0xC0, 0x7F, 0x0F, 0x9F, 0x01, 0xFC,
  0xFF, 0xCF, 0x87, 0x80, 0xFF, 0xF9, 0xFF, 0xC3, 0xC0, 0x3F, 0xF8, 0x7F,
  0xC1, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x00, 0xE0,
  0x00, 0x1F, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x1F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x07,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x7E, 0x0F, 0xF0,
  0x00, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x20, 0xFF, 0xF0, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x83, 0xF0, 0x01, 0xFF, 0x0F, 0xC0, 0x01, 0xFE, 0x3F, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xFC, 0x3F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0x03, 0xFE, 0x00, 0x0E, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x3F, 0x0F, 0xF0, 0x00,
  0x7E, 0x0F, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x34, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3D,
  0xFF, 0xFC, 0x00, 0x01, 0xF7, 0xFE, 0xF8, 0x00, 0x07, 0xDF, 0xFB, 0xE0,
  0x00, 0x1E, 0x7F, 0xEF, 0x80, 0x00, 0xFB, 0xFF, 0x9F, 0x00, 0x03, 0xEF,
  0xFE, 0x7C, 0x00, 0x1F, 0x3F, 0xF9, 0xF0, 0x00, 0x7C, 0xFF, 0xE3, 0xE0,
  0x01, 0xF3, 0xFF, 0x8F, 0x80, 0x0F, 0x8F, 0xFE, 0x3F, 0x00, 0x3E, 0x3F,
  0xF8, 0x7C, 0x00, 0xF0, 0xFF, 0xE1, 0xF0, 0x07, 0xC3, 0xFF, 0x83, 0xE0,
  0x1F, 0x0F, 0xFE, 0x0F, 0x80, 0x78, 0x3F, 0xF8, 0x3E, 0x03, 0xE0, 0xFF,
  0xE0, 0x7C, 0x0F, 0x83, 0xFF, 0x81, 0xF0, 0x7C, 0x0F, 0xFE, 0x07, 0xC1,
  0xF0, 0x3F, 0xF8, 0x0F, 0x87, 0xC0, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xFF,
  0x80, 0xF8, 0xF8, 0x0F, 0xFE, 0x01, 0xF3, 0xC0, 0x3F, 0xF8, 0x07, 0xDF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xF0,
  0x00, 0x7F, 0xEF, 0xE0, 0x01, 0xFF, 0x9F, 0x80, 0x07, 0xFE, 0x3F, 0x00,
  0x1F, 0xF8, 0xFE, 0x00, 0x7F, 0xE1, 0xF8, 0x01, 0xFF, 0x83, 0xF0, 0x07,
  0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0x7F, 0x01, 0xFF,
  0x80, 0xFC, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x7F, 0xE0,
  0x0F, 0xC1, 0xFF, 0x80, 0x1F, 0x87, 0xFE, 0x00, 0x7F, 0x1F, 0xF8, 0x00,
  0xFC, 0x7F, 0xE0, 0x03, 0xF9, 0xFF, 0x80, 0x07, 0xE7, 0xFE, 0x00, 0x0F,
  0xDF, 0xF8, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x7E, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x17, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03,
  0xF0, 0xFC, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0x1F, 0x80, 0x06, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFD, 0xFC,
  0x0F, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x78, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x7C, 0x00,
  0xFC, 0x1F, 0x80, 0x1E, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x7E, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x7C, 0x1F, 0x03,
  0xF0, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x03, 0xF1, 0xF8, 0x0F, 0x87,
  0xE0, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0xC0, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xC0, 0x01, 0xEF,
  0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0x80, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xF0,
  0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0x80, 0xFE, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x03, 0xFF, 0x7F,
  0xFF, 0xDF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x1F, 0x0F, 0xFE, 0x0F, 0x00,
  0x40, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x40, 0x0F, 0xC7, 0xFE, 0x07, 0xE7, 0xFF, 0xC3, 0xF7, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFE, 0x7F, 0x80, 0x3F, 0xBF, 0x80,
  0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xBF, 0xC0, 0x1F, 0xDF, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0xE7, 0xCF, 0xFF,
  0xE3, 0xE3, 0xFF, 0xE1, 0xE0, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xE0, 0x78, 0xFC, 0x00, 0x4F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x02, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x02, 0x03, 0xF0, 0x3F, 0xF0, 0xF8, 0x3F,
  0xFE, 0x7C, 0x7F, 0xFF, 0xBE, 0x3F, 0xFF, 0xDF, 0x3F, 0xC1, 0xFF, 0xBF,
  0x80, 0x3F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xE7, 0xF8, 0x3F, 0xF1, 0xFF,
  0xFE, 0xF8, 0xFF, 0xFE, 0x7C, 0x3F, 0xFE, 0x3E, 0x07, 0xFE, 0x1F, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x02, 0x3F, 0xC0, 0x1E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x87, 0xC1, 0xFF, 0xF3, 0xE3, 0xFF,
  0xFD, 0xF1, 0xFF, 0xFE, 0xF9, 0xFE, 0x0F, 0xFD, 0xFC, 0x01, 0xFE, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0x8F, 0xFF, 0xF7, 0xC7, 0xFF,
  0xFB, 0xE0, 0xFF, 0xF9, 0xF0, 0x3F, 0xF0, 0xF8, 0x00, 0x80, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC4, 0x00, 0x0F, 0xE3, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x40, 0x0F,
  0xC3, 0xFF, 0x07, 0xE7, 0xFF, 0xC3, 0xF7, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0xFF, 0x7F, 0x80, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x03,
  0xEF, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x33, 0xFF, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE,
  0x1F, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07,
  0xF7, 0xE0, 0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xF3, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x7C, 0x3F, 0xF0, 0x0F, 0xFC, 0x3E, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xBF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFE, 0x0F, 0xFF,
  0x83, 0xFB, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x06, 0x00, 0x7C, 0x3F, 0xF8, 0x3E, 0x3F, 0xFF, 0x1F, 0x3F, 0xFF,
  0xCF, 0xBF, 0xFF, 0xE7, 0xFE, 0x07, 0xFB, 0xFC, 0x00, 0xFD, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x7C, 0x3F, 0xF0, 0x3E, 0x3F, 0xFE, 0x1F, 0x3F, 0xFF, 0x8F, 0xBF, 0xFF,
  0xE7, 0xFE, 0x0F, 0xF3, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFD, 0xFE, 0x00, 0xFE,
  0xFF, 0xC1, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0x7F, 0xFF, 0x1F, 0x9F, 0xFF,
  0x0F, 0xC7, 0xFE, 0x07, 0xE0, 0x10, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x87,
  0xC1, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF1, 0xFF, 0xFE, 0xF9, 0xFE, 0x0F,
  0xFD, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0xFF,
  0x8F, 0xFF, 0xF7, 0xC7, 0xFF, 0xF3, 0xE0, 0xFF, 0xF3, 0xF0, 0x3F, 0xF1,
  0xF8, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x02, 0x7C, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x1C, 0xF8, 0x00, 0x4F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x08, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x10, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x80, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0x7F, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x8F,
  0x07, 0xFE, 0x0F, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7C,
  0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFF, 0x00,
  0x3E, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x7E,
  0x01, 0xFF, 0x80, 0x7E, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x3F, 0x03, 0xE7, 0xC0, 0xF8,
  0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x1F, 0x87,
  0xC3, 0xE1, 0xF8, 0x0F, 0x87, 0x83, 0xE1, 0xF0, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x07,
  0xCF, 0x00, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x03, 0xDE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x07, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x01, 0xFF,
  0x81, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xFC,
  0x00, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFA, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_Medium52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 38, 14, 3, -37 },
  { 39, 16, 13, 22, 3, -37 },
  { 65, 31, 37, 34, 1, -37 },
  { 209, 24, 42, 30, 3, -39 },
  { 335, 40, 39, 44, 2, -38 },
  { 530, 35, 39, 38, 3, -38 },
  { 701, 6, 13, 12, 3, -37 },
  { 711, 13, 45, 16, 2, -37 },
  { 785, 12, 45, 16, 2, -37 },
  { 853, 24, 24, 29, 2, -40 },
  { 925, 25, 25, 30, 2, -31 },
  { 1004, 8, 13, 14, 2, -6 },
  { 1017, 13, 4, 17, 2, -16 },
  { 1024, 8, 8, 14, 3, -7 },
  { 1032, 20, 37, 20, 0, -37 },
  { 1125, 25, 39, 30, 2, -38 },
  { 1247, 15, 37, 30, 4, -37 },
  { 1317, 25, 38, 30, 2, -38 },
  { 1436, 25, 39, 30, 2, -38 },
  { 1558, 28, 37, 30, 1, -37 },
  { 1688, 24, 38, 30, 3, -37 },
  { 1802, 25, 39, 30, 3, -38 },
  { 1924, 25, 37, 30, 2, -37 },
  { 2040, 25, 39, 30, 2, -38 },
  { 2162, 25, 39, 30, 2, -38 },
  { 2284, 8, 30, 14, 3, -29 },
  { 2314, 9, 36, 14, 2, -29 },
  { 2355, 25, 26, 30, 2, -32 },
  { 2437, 24, 15, 30, 3, -26 },
  { 2482, 25, 26, 30, 2, -32 },
  { 2564, 21, 39, 23, 1, -38 },
  { 2667, 41, 41, 47, 3, -37 },
  { 2878, 34, 37, 34, 0, -37 },
  { 3036, 26, 37, 34, 5, -37 },
  { 3157, 28, 39, 33, 3, -38 },
  { 3294, 30, 37, 38, 5, -37 },
  { 3433, 21, 37, 29, 5, -37 },
  { 3531, 21, 37, 27, 5, -37 },
  { 3629, 31, 39, 38, 3, -38 },
  { 3781, 29, 37, 39, 5, -37 },
  { 3916, 14, 37, 18, 2, -37 },
  { 3981, 14, 47, 15, -4, -37 },
  { 4064, 28, 37, 33, 5, -37 },
  { 4194, 21, 37, 28, 5, -37 },
  { 4292, 38, 37, 48, 5, -37 },
  { 4468, 30, 37, 40, 5, -37 },
  { 4607, 35, 39, 41, 3, -38 },
  { 4778, 24, 37, 32, 5, -37 },
  { 4889, 35, 47, 41, 3, -38 },
  { 5095, 27, 37, 33, 5, -37 },
  { 5220, 23, 39, 29, 3, -38 },
  { 5333, 28, 37, 29, 1, -37 },
  { 5463, 29, 38, 38, 5, -37 },
  { 5601, 32, 37, 32, 0, -37 },
  { 5749, 48, 37, 49, 0, -37 },
  { 5971, 32, 37, 32, 0, -37 },
  { 6119, 30, 37, 30, 0, -37 },
  { 6258, 26, 37, 30, 2, -37 },
  { 6379, 12, 45, 17, 4, -37 },
  { 6447, 20, 37, 20, 0, -37 },
  { 6540, 12, 45, 17, 1, -37 },
  { 6608, 26, 23, 30, 2, -37 },
  { 6683, 23, 3, 23, 0, 5 },
  { 6692, 12, 8, 16, 2, -40 },
  { 6704, 24, 30, 30, 2, -29 },
  { 6794, 25, 41, 32, 4, -40 },
  { 6923, 21, 30, 26, 3, -29 },
  { 7002, 25, 41, 32, 3, -40 },
  { 7131, 24, 30, 30, 3, -29 },
  { 7221, 20, 40, 19, 1, -40 },
  { 7321, 25, 41, 32, 3, -29 },
  { 7450, 25, 40, 33, 4, -40 },
  { 7575, 6, 39, 14, 4, -39 },
  { 7605, 13, 51, 14, -3, -39 },
  { 7688, 25, 40, 29, 4, -40 },
  { 7813, 6, 40, 14, 4, -40 },
  { 7843, 41, 29, 49, 4, -29 },
  { 7992, 25, 29, 33, 4, -29 },
  { 8083, 26, 30, 32, 3, -29 },
  { 8181, 25, 41, 32, 4, -29 },
  { 8310, 25, 41, 32, 3, -29 },
  { 8439, 17, 29, 22, 4, -29 },
  { 8501, 20, 30, 25, 3, -29 },
  { 8576, 18, 35, 20, 1, -34 },
  { 8655, 24, 29, 33, 4, -28 },
  { 8742, 27, 28, 27, 0, -28 },
  { 8837, 40, 28, 42, 1, -28 },
  { 8977, 27, 28, 28, 1, -28 },
  { 9072, 27, 40, 27, 0, -28 },
  { 9207, 21, 28, 25, 2, -28 },
  { 9281, 17, 45, 20, 1, -37 },
  { 9377, 4, 51, 29, 12, -39 },
  { 9403, 17, 45, 20, 2, -37 },
  { 9499, 25, 7, 30, 2, -22 },
};

const GFXfont NotoSans_Medium52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium52pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_MEDIUM52PT7B_H_
