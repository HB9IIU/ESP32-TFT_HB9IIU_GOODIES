#ifndef _NOTOSANS_MEDIUM38PT7B_H_
#define _NOTOSANS_MEDIUM38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x79, 0xCE, 0x73,
  0x9C, 0x00, 0x01, 0xDF, 0xFF, 0xFC, 0x40, 0xF8, 0xF7, 0x0F, 0x70, 0xF7,
  0x0F, 0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0x80, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x38, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x38,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xE3, 0x0C, 0xF0, 0xC0,
  0x3C, 0x30, 0x0F, 0x0C, 0x03, 0xE3, 0x00, 0x7E, 0xC0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0C, 0xF8, 0x03,
  0x1F, 0x00, 0xC3, 0xC0, 0x30, 0xF8, 0x0C, 0x7F, 0xE3, 0x7E, 0xFF, 0xFF,
  0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x1F, 0xF0, 0x07,
  0x80, 0xF7, 0x80, 0x38, 0x0F, 0x1E, 0x03, 0x80, 0x70, 0x70, 0x3C, 0x03,
  0x83, 0x81, 0xC0, 0x1C, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0xE0, 0x07, 0x07,
  0x0F, 0x00, 0x38, 0x38, 0x70, 0x01, 0xC1, 0xC7, 0x8E, 0x0E, 0x0E, 0x39,
  0xFC, 0x78, 0xF3, 0x9F, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0xF9, 0xCF, 0x0E,
  0x3F, 0x9E, 0x78, 0x70, 0x20, 0xE3, 0x83, 0xC0, 0x0F, 0x1C, 0x1E, 0x00,
  0x70, 0xE0, 0xF0, 0x07, 0x87, 0x07, 0x80, 0x38, 0x38, 0x3C, 0x03, 0x81,
  0xC1, 0xE0, 0x3C, 0x0F, 0x0E, 0x01, 0xC0, 0x38, 0x70, 0x1E, 0x01, 0xEF,
  0x80, 0xE0, 0x07, 0xF8, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xF0, 0xFF, 0xE0, 0x3C,
  0x7C, 0x7C, 0x0F, 0x1E, 0x0F, 0x87, 0x8F, 0x81, 0xF1, 0xE3, 0xC0, 0x3E,
  0xF8, 0xF0, 0x07, 0xFC, 0x3C, 0x00, 0xFE, 0x0F, 0x00, 0x1F, 0x83, 0xE0,
  0x0F, 0xE0, 0x7E, 0x0F, 0xFC, 0x1F, 0xFF, 0xEF, 0x83, 0xFF, 0xF1, 0xF0,
  0x3F, 0xF0, 0x3F, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x07, 0x87,
  0x87, 0x83, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x10, 0x38, 0x17, 0x8E, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x78, 0x7C, 0x06, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x3E, 0x78, 0xF1, 0xE7, 0x8F, 0x1C, 0x38, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x77, 0xFF, 0xFF, 0x10, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3C, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3E, 0x3E,
  0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xE0, 0x7C, 0x3F,
  0x8F, 0xF3, 0xFE, 0xFB, 0xFE, 0x7B, 0x0F, 0x21, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x80,
  0x03, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0x1C, 0x03, 0xE2,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x78, 0x1F,
  0x18, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7A, 0x00, 0x3E, 0xE0, 0x1F, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE8, 0x00, 0xFB, 0xC0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x1F, 0xC3, 0xDF, 0xF8, 0xFF, 0xFF, 0x3F, 0x83, 0xEF, 0x80, 0x7B, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03,
  0xDE, 0x00, 0xF7, 0xC0, 0x78, 0xF8, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xC0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0xFC, 0xF8, 0x1F, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xEF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF8, 0x0F, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0xF8, 0x0F, 0xBC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xDF, 0x07, 0xF7, 0xFF, 0xBC, 0xFF, 0xCF, 0x0F, 0xE3,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x77,
  0xFF, 0xFF, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xFF,
  0x10, 0x3C, 0x7C, 0xF9, 0xF3, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x38, 0xF1, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x70,
  0x1F, 0x40, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x01,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0x8F, 0x01, 0xFC, 0x0E, 0x38, 0x1F, 0xFC, 0x39, 0xE0,
  0xFF, 0xF0, 0xF7, 0x07, 0x83, 0xC1, 0xDC, 0x1C, 0x0F, 0x07, 0xF0, 0xF0,
  0x3C, 0x1F, 0x83, 0x80, 0xF0, 0x7E, 0x0E, 0x03, 0xC1, 0xF8, 0x38, 0x0F,
  0x07, 0xE0, 0xE0, 0x38, 0x1F, 0x83, 0x80, 0xE0, 0xEE, 0x0F, 0x07, 0xC3,
  0xBC, 0x3C, 0x3F, 0x1E, 0x70, 0x7F, 0xEF, 0xF1, 0xC0, 0xFF, 0x3F, 0x87,
  0x80, 0xF0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xDE, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x78, 0x1F, 0xCF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xDE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xF7, 0x81, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC,
  0x07, 0x0F, 0x80, 0x08, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x70, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3C, 0x0F,
  0xF0, 0xF0, 0x07, 0xE3, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x3E,
  0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3,
  0xC0, 0x0F, 0x8F, 0x00, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE,
  0x03, 0x83, 0xF0, 0x01, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x80, 0x07, 0x8F, 0x80, 0x0F, 0x1F, 0xE0, 0x3E, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xFF, 0xFF, 0xFD, 0xFF, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x81, 0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xF0, 0x03, 0xFF, 0x00,
  0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF0,
  0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F,
  0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x00,
  0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E,
  0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xDC, 0x00, 0x3F, 0xFB, 0xC0, 0x07, 0x7F, 0x78, 0x00, 0xEF, 0xE7, 0x80,
  0x3D, 0xFC, 0xF0, 0x07, 0x3F, 0x8E, 0x01, 0xE7, 0xF1, 0xE0, 0x3C, 0xFE,
  0x3C, 0x07, 0x1F, 0xC3, 0x81, 0xE3, 0xF8, 0x78, 0x3C, 0x7F, 0x0F, 0x07,
  0x0F, 0xE0, 0xE1, 0xE1, 0xFC, 0x1E, 0x38, 0x3F, 0x83, 0xC7, 0x07, 0xF0,
  0x39, 0xE0, 0xFE, 0x07, 0xB8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0xF8, 0x03, 0xF9, 0xE0,
  0x0F, 0xE7, 0xC0, 0x3F, 0x8F, 0x80, 0xFE, 0x1E, 0x03, 0xF8, 0x7C, 0x0F,
  0xE0, 0xF0, 0x3F, 0x83, 0xE0, 0xFE, 0x07, 0xC3, 0xF8, 0x0F, 0x0F, 0xE0,
  0x3E, 0x3F, 0x80, 0x7C, 0xFE, 0x00, 0xF3, 0xF8, 0x03, 0xEF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0,
  0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x9E,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x07, 0xBE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x1F, 0xEF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF0, 0xFF,
  0x80, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0x3C, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x07, 0xF0,
  0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x7F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xF0, 0x00, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xE7, 0xC0, 0xF7, 0xC0, 0x0B, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x1F, 0xF0, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x8F, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x7C, 0x1E,
  0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xC7,
  0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xEF, 0x00,
  0x3E, 0x00, 0x3D, 0xE0, 0x07, 0xE0, 0x07, 0xBC, 0x00, 0xFC, 0x01, 0xE3,
  0xC0, 0x3F, 0x80, 0x3C, 0x78, 0x07, 0xF0, 0x07, 0x8F, 0x00, 0xEF, 0x00,
  0xF1, 0xE0, 0x1D, 0xE0, 0x3C, 0x1E, 0x07, 0x9C, 0x07, 0x83, 0xC0, 0xF3,
  0xC0, 0xF0, 0x78, 0x1C, 0x78, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0x80, 0xF0,
  0xF0, 0xF0, 0xF0, 0x1E, 0x1E, 0x1E, 0x1E, 0x03, 0xC3, 0x83, 0xC3, 0xC0,
  0x78, 0xF0, 0x38, 0xF0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0xF3,
  0xC0, 0x1E, 0x70, 0x1E, 0x78, 0x03, 0xDE, 0x01, 0xDE, 0x00, 0x3B, 0xC0,
  0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xF0, 0x7C, 0x01, 0xE0,
  0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x1F, 0x00,
  0x3C, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0x3C, 0x1F,
  0x00, 0x7C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3E, 0x01,
  0xF0, 0x78, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x01, 0xC7, 0x00, 0x38, 0xF0, 0x0E, 0x0E, 0x01, 0xC1, 0xE0, 0x78,
  0x1C, 0x0E, 0x03, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x9E, 0x00, 0x73, 0x80,
  0x0F, 0xF0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x83,
  0xE7, 0xE1, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xEF, 0xFE, 0xF3,
  0xFC, 0x38, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x1E,
  0x7F, 0xC3, 0xDF, 0xFC, 0x7F, 0xFF, 0xCF, 0xC0, 0xF9, 0xF0, 0x0F, 0xBE,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xFC,
  0x07, 0xDF, 0xC1, 0xF3, 0xFF, 0xFC, 0x7B, 0xFF, 0x8E, 0x3F, 0xC0, 0x01,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xC0, 0x2F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x0C, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xE3, 0xC3,
  0xFE, 0x71, 0xFF, 0xDC, 0xFF, 0xFF, 0x7C, 0x07, 0xDE, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F, 0x7C, 0x07, 0xDF,
  0x83, 0xF3, 0xFF, 0xDC, 0x7F, 0xE7, 0x0F, 0xF1, 0xC0, 0x01, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xF0, 0xFC, 0x7C, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x61, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC3, 0xE2, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x03, 0xE0, 0x03, 0xFE, 0x71, 0xFF, 0xDC, 0xFE, 0xFF, 0x7C, 0x07, 0xDE,
  0x01, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F,
  0x7C, 0x07, 0xDF, 0x83, 0xF3, 0xFF, 0xDC, 0x7F, 0xEF, 0x0F, 0xF3, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xD0, 0x01, 0xF7, 0xC1,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFE, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF, 0xFE, 0xFC,
  0x07, 0xBE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC7, 0xFF, 0xDF, 0xEF, 0xC0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xEF, 0x01, 0xF3, 0xC0,
  0xF8, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x1F, 0x03, 0xCF, 0x80, 0xF7, 0xC0,
  0x3D, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x3E, 0x3C, 0x0F,
  0x0F, 0x83, 0xC1, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0,
  0x3E, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xC3, 0xCF,
  0xF8, 0xFF, 0xCF, 0x7F, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F,
  0xE0, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFC, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03,
  0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF,
  0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0,
  0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xFB, 0xFF, 0xFE, 0xFC,
  0x07, 0xBE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF, 0xC7,
  0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7B, 0xC0, 0x1E, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xF8, 0x1E, 0x7F, 0xC3, 0xDF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xC0, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0,
  0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x3E, 0xFC, 0x07, 0xDF, 0xC1, 0xF3, 0xFF,
  0xFC, 0x7B, 0xFF, 0x8F, 0x3F, 0xC1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x71, 0xFF, 0xDC, 0xFC,
  0xFF, 0x7C, 0x07, 0xDE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3D, 0xE0, 0x0F, 0x7C, 0x07, 0xDF, 0x83, 0xF3, 0xFF, 0xDC, 0x7F,
  0xEF, 0x0F, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0xFF, 0x1F, 0xBD, 0xFD, 0xFF, 0xEF, 0xE0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0xF9, 0xFF, 0xF7, 0xE3, 0xEF, 0x00, 0x5E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x7B, 0xFF, 0xF7, 0xFF,
  0xC7, 0xFE, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xDF, 0xFF,
  0xF3, 0xFF, 0xBC, 0x7F, 0x8F, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x03, 0x9C, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3D, 0xE0,
  0x1F, 0x00, 0xF7, 0x80, 0x7C, 0x03, 0xDE, 0x03, 0xF0, 0x1E, 0x3C, 0x0F,
  0xE0, 0x78, 0xF0, 0x3B, 0x81, 0xE3, 0xC1, 0xEE, 0x07, 0x8F, 0x07, 0x3C,
  0x3C, 0x1E, 0x1C, 0xF0, 0xF0, 0x78, 0xF1, 0xC3, 0xC1, 0xE3, 0xC7, 0x0E,
  0x07, 0x8E, 0x1E, 0x78, 0x0F, 0x38, 0x79, 0xE0, 0x3D, 0xE0, 0xE7, 0x80,
  0xF7, 0x83, 0xDC, 0x01, 0xDC, 0x0F, 0xF0, 0x07, 0x70, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x03, 0xEF, 0x80, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0x81,
  0xF1, 0xE0, 0x1E, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x1E, 0x7C, 0x07,
  0xC7, 0x80, 0xF0, 0x78, 0x3C, 0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x0F, 0x78,
  0x01, 0xF0, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x39,
  0xE0, 0x03, 0xDC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0x07, 0xF0,
  0x7C, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x3F, 0x0F, 0xC0, 0xF0, 0x0F, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1F,
  0x83, 0xF8, 0x1F, 0x80, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x00,
};

const GFXglyph NotoSans_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 28, 10, 3, -27 },
  { 19, 12, 10, 16, 2, -27 },
  { 34, 23, 27, 25, 1, -27 },
  { 112, 18, 31, 22, 2, -29 },
  { 182, 29, 28, 32, 2, -28 },
  { 284, 26, 28, 28, 2, -28 },
  { 375, 5, 10, 9, 2, -27 },
  { 382, 9, 33, 12, 2, -27 },
  { 420, 9, 33, 12, 1, -27 },
  { 458, 18, 17, 21, 1, -29 },
  { 497, 18, 19, 22, 2, -23 },
  { 540, 7, 9, 10, 1, -4 },
  { 548, 10, 4, 12, 1, -12 },
  { 553, 5, 6, 10, 3, -5 },
  { 557, 14, 27, 15, 0, -27 },
  { 605, 18, 28, 22, 2, -28 },
  { 668, 11, 27, 22, 3, -27 },
  { 706, 18, 28, 22, 2, -28 },
  { 769, 18, 28, 22, 2, -28 },
  { 832, 20, 27, 22, 1, -27 },
  { 900, 18, 27, 22, 2, -27 },
  { 961, 18, 27, 22, 2, -27 },
  { 1022, 19, 27, 22, 1, -27 },
  { 1087, 18, 28, 22, 2, -28 },
  { 1150, 18, 27, 22, 2, -27 },
  { 1211, 5, 22, 10, 3, -21 },
  { 1225, 7, 26, 10, 1, -21 },
  { 1248, 18, 19, 22, 2, -23 },
  { 1291, 18, 11, 22, 2, -19 },
  { 1316, 18, 19, 22, 2, -23 },
  { 1359, 16, 29, 17, 0, -28 },
  { 1417, 30, 30, 34, 2, -27 },
  { 1530, 25, 27, 25, 0, -27 },
  { 1615, 19, 27, 25, 4, -27 },
  { 1680, 21, 28, 24, 2, -28 },
  { 1754, 22, 27, 28, 4, -27 },
  { 1829, 15, 27, 21, 4, -27 },
  { 1880, 15, 27, 20, 4, -27 },
  { 1931, 23, 28, 28, 2, -28 },
  { 2012, 21, 27, 28, 4, -27 },
  { 2083, 11, 27, 13, 1, -27 },
  { 2121, 11, 34, 11, -3, -27 },
  { 2168, 20, 27, 24, 4, -27 },
  { 2236, 15, 27, 20, 4, -27 },
  { 2287, 27, 27, 35, 4, -27 },
  { 2379, 22, 27, 29, 4, -27 },
  { 2454, 26, 28, 30, 2, -28 },
  { 2545, 17, 27, 23, 4, -27 },
  { 2603, 26, 34, 30, 2, -28 },
  { 2714, 20, 27, 24, 4, -27 },
  { 2782, 17, 28, 21, 2, -28 },
  { 2842, 21, 27, 21, 0, -27 },
  { 2913, 22, 27, 28, 3, -27 },
  { 2988, 23, 27, 23, 0, -27 },
  { 3066, 35, 27, 36, 0, -27 },
  { 3185, 23, 27, 23, 0, -27 },
  { 3263, 22, 27, 22, 0, -27 },
  { 3338, 19, 27, 22, 1, -27 },
  { 3403, 9, 33, 13, 3, -27 },
  { 3441, 14, 27, 15, 0, -27 },
  { 3489, 9, 33, 13, 1, -27 },
  { 3527, 19, 17, 22, 1, -27 },
  { 3568, 17, 3, 16, 0, 3 },
  { 3575, 8, 6, 12, 2, -29 },
  { 3581, 17, 21, 22, 2, -21 },
  { 3626, 19, 29, 24, 3, -29 },
  { 3695, 15, 21, 19, 2, -21 },
  { 3735, 18, 29, 24, 2, -29 },
  { 3801, 18, 21, 22, 2, -21 },
  { 3849, 14, 29, 14, 1, -29 },
  { 3900, 18, 30, 24, 2, -21 },
  { 3968, 18, 29, 24, 3, -29 },
  { 4034, 4, 28, 10, 3, -28 },
  { 4048, 9, 37, 10, -2, -28 },
  { 4090, 18, 29, 21, 3, -29 },
  { 4156, 4, 29, 10, 3, -29 },
  { 4171, 30, 21, 36, 3, -21 },
  { 4250, 18, 21, 24, 3, -21 },
  { 4298, 19, 21, 23, 2, -21 },
  { 4348, 19, 30, 24, 3, -21 },
  { 4420, 18, 30, 24, 2, -21 },
  { 4488, 13, 21, 16, 3, -21 },
  { 4523, 15, 21, 18, 2, -21 },
  { 4563, 13, 25, 15, 1, -25 },
  { 4604, 18, 20, 24, 3, -20 },
  { 4649, 20, 20, 20, 0, -20 },
  { 4699, 30, 21, 31, 0, -21 },
  { 4778, 19, 20, 21, 1, -20 },
  { 4826, 20, 29, 20, 0, -20 },
  { 4899, 16, 20, 18, 1, -20 },
  { 4939, 12, 33, 15, 1, -27 },
  { 4989, 3, 38, 21, 9, -29 },
  { 5004, 13, 33, 15, 1, -27 },
  { 5058, 18, 5, 22, 2, -16 },
};

const GFXfont NotoSans_Medium38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium38pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_MEDIUM38PT7B_H_
