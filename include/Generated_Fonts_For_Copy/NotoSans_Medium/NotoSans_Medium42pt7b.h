#ifndef _NOTOSANS_MEDIUM42PT7B_H_
#define _NOTOSANS_MEDIUM42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x1C, 0x70, 0x00, 0x00, 0x23, 0xEF, 0xFF, 0xFF, 0xE2,
  0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01,
  0xC0, 0xE0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF6, 0xFC,
  0x7C, 0x60, 0x4F, 0x86, 0x00, 0xF8, 0x60, 0x0F, 0x86, 0x00, 0x78, 0x60,
  0x07, 0xE6, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0x06, 0xFE, 0x00, 0x63, 0xF0, 0x06, 0x1F, 0x00,
  0x61, 0xF0, 0x06, 0x1F, 0x80, 0x61, 0xFE, 0x06, 0x3E, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x3F, 0xE0, 0x07,
  0x80, 0x7F, 0xE0, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x70, 0x0F,
  0x00, 0xF0, 0x70, 0x1E, 0x00, 0xF0, 0x78, 0x1C, 0x00, 0xE0, 0x78, 0x3C,
  0x00, 0xE0, 0x78, 0x38, 0x00, 0xE0, 0x78, 0x78, 0x00, 0xE0, 0x78, 0xF0,
  0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x71, 0xE3, 0xF8, 0xF0, 0x71, 0xE7,
  0xFC, 0x78, 0xF3, 0xCF, 0xFE, 0x7F, 0xE3, 0x8F, 0x1E, 0x3F, 0xE7, 0x9E,
  0x0E, 0x1F, 0xC7, 0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x1E, 0x1E,
  0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x0F, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x70, 0x1E, 0x0F, 0x00, 0xF0, 0x1E,
  0x0E, 0x00, 0xE0, 0x0F, 0x1E, 0x01, 0xE0, 0x0F, 0xFE, 0x01, 0xC0, 0x07,
  0xFC, 0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x7C, 0x3F, 0x7E, 0x03, 0xE3, 0xF1, 0xF8, 0x1E, 0x1F, 0x07,
  0xE1, 0xF1, 0xF0, 0x1F, 0x8F, 0x8F, 0x80, 0x7E, 0xF8, 0x7C, 0x01, 0xFF,
  0xC3, 0xE0, 0x07, 0xFC, 0x1F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x03,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0x81, 0xFF,
  0xF8, 0x3E, 0x03, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x7C,
  0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83,
  0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x38, 0x38, 0x3F, 0xE7, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x78, 0x03, 0xC7, 0x80, 0xF8, 0xF8,
  0x3E, 0x0F, 0x83, 0xC1, 0xE0, 0x18, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3D, 0xF7,
  0xDF, 0x79, 0xE7, 0xBC, 0xF3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x23,
  0xEF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xF9, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80,
  0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F,
  0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3F, 0x9F,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0,
  0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF, 0xF3, 0xEF, 0x1F, 0x30, 0xF9, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xFE, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xF3, 0xFC, 0x78, 0x07, 0xC3, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x70, 0x07,
  0xE2, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xEC, 0x00, 0x7E, 0xF8, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x07, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C,
  0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xEC, 0x00, 0x7E, 0xFC, 0x3F, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFE, 0x04, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x8F, 0xE0, 0xFB,
  0xFF, 0x8F, 0x7F, 0xFC, 0xF7, 0xFF, 0xEF, 0xE0, 0x3E, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x3E, 0x1F, 0x8F,
  0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7C, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E,
  0x3E, 0x07, 0xC3, 0xF0, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xBF, 0x83, 0xE0, 0xFC, 0x7C, 0x03, 0xEF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF1, 0xFC,
  0x7C, 0x07, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0x7C, 0x07, 0xF7, 0xFB, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF, 0x07,
  0xF1, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x20, 0x7F, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7B, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8F, 0xBF, 0xFF, 0xFF, 0x88, 0x1E,
  0x3E, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78,
  0x78, 0x70, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF1, 0xF8, 0xFE, 0x30, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1E, 0x1C, 0x01, 0xFE, 0x07, 0x1E, 0x07, 0xFF, 0x83, 0xCE, 0x07,
  0xFF, 0xC1, 0xEF, 0x07, 0xC0, 0xE0, 0x77, 0x83, 0xC0, 0x70, 0x3B, 0x83,
  0xC0, 0x38, 0x1D, 0xC1, 0xE0, 0x1C, 0x0F, 0xE0, 0xF0, 0x1E, 0x07, 0xF0,
  0x70, 0x0F, 0x03, 0xF8, 0x38, 0x07, 0x81, 0xFC, 0x1C, 0x03, 0xC0, 0xFE,
  0x0F, 0x01, 0xE0, 0xFF, 0x07, 0x81, 0xF0, 0x73, 0x83, 0xE0, 0xF8, 0x79,
  0xC0, 0xFF, 0xEF, 0xF8, 0xF0, 0x3F, 0xE7, 0xFC, 0x78, 0x0F, 0xE1, 0xF8,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x7F, 0x78, 0x00, 0xFB,
  0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xBC, 0x00,
  0x7D, 0xE0, 0x07, 0xCF, 0x03, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0xF0, 0x07, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFC, 0x00, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x08, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xF8, 0xF0, 0x01, 0xFC,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x7E, 0xF0, 0x00, 0xFC, 0xF0, 0x01, 0xF8, 0xF0, 0x07, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBC, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x06, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0x3F, 0x00, 0x0F, 0x1F,
  0x80, 0x0F, 0x1F, 0xFC, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0xFF, 0xFF, 0x7F,
  0xEF, 0xF9, 0xFC, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1,
  0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFD, 0xE0,
  0x00, 0xFF, 0xFB, 0xC0, 0x03, 0xDF, 0xF7, 0x80, 0x07, 0xBF, 0xE7, 0x80,
  0x0E, 0x7F, 0xCF, 0x00, 0x3C, 0xFF, 0x9F, 0x00, 0x79, 0xFF, 0x1E, 0x01,
  0xE3, 0xFE, 0x3C, 0x03, 0xC7, 0xFC, 0x3C, 0x07, 0x8F, 0xF8, 0x78, 0x1E,
  0x1F, 0xF0, 0xF0, 0x3C, 0x3F, 0xE0, 0xF0, 0x78, 0x7F, 0xC1, 0xE1, 0xE0,
  0xFF, 0x83, 0xC3, 0xC1, 0xFF, 0x03, 0xC7, 0x03, 0xFE, 0x07, 0x9E, 0x07,
  0xFC, 0x0F, 0x3C, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x01, 0xFF,
  0x00, 0x7C, 0x03, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xEF, 0x80, 0x1F, 0xF3, 0xE0, 0x0F,
  0xF9, 0xF0, 0x07, 0xFC, 0x7C, 0x03, 0xFE, 0x1F, 0x01, 0xFF, 0x0F, 0x80,
  0xFF, 0x83, 0xE0, 0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0x7C, 0x1F, 0xF0, 0x1F,
  0x0F, 0xF8, 0x0F, 0x87, 0xFC, 0x03, 0xE3, 0xFE, 0x00, 0xF8, 0xFF, 0x00,
  0x7C, 0x7F, 0x80, 0x1F, 0x3F, 0xC0, 0x0F, 0xDF, 0xE0, 0x03, 0xEF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x1F, 0xC0, 0x1F, 0x81,
  0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xFC, 0x01,
  0xF8, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xF0, 0x0F, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF,
  0x00, 0x7E, 0xF0, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x1F, 0xC0, 0x1F, 0x81,
  0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xFC, 0x01,
  0xFC, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xF0, 0x0F, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0,
  0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7E, 0xF0, 0x00, 0xFB,
  0xC0, 0x01, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xC0, 0x18, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0xFB, 0xFC, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0xF0, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0xE0, 0x0F,
  0x8F, 0x80, 0x3B, 0xC0, 0x1E, 0x1F, 0x00, 0xF7, 0x80, 0x3C, 0x1E, 0x01,
  0xEF, 0x00, 0xF8, 0x3C, 0x03, 0xCF, 0x01, 0xF0, 0x7C, 0x0F, 0x9E, 0x03,
  0xC0, 0xF8, 0x1E, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x7C, 0x1F, 0x01, 0xE0,
  0x78, 0x78, 0x3E, 0x03, 0xE1, 0xE0, 0xF0, 0x78, 0x07, 0xC3, 0xC1, 0xE0,
  0xF0, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0x1F,
  0x3C, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x0F, 0x9E, 0x00, 0x3C, 0xF0, 0x0F,
  0x7C, 0x00, 0x7B, 0xC0, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x01,
  0xFF, 0x00, 0x3B, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x07, 0xC0,
  0x03, 0xE1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xE0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x78, 0x00,
  0x3C, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1E, 0x00, 0xF0,
  0x38, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x78, 0x07, 0x83, 0xC0, 0x0E,
  0x0F, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xCF,
  0xE1, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xF8, 0x3E, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x0F, 0xF7, 0xFF, 0xDE, 0x7F, 0xF3, 0xC7, 0xFC, 0x78, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC7, 0xF0,
  0x3E, 0x7F, 0xE1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x01, 0xF3, 0xF0,
  0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xFC, 0x07, 0xEF,
  0xF8, 0xFE, 0x7B, 0xFF, 0xE3, 0xCF, 0xFE, 0x1E, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xF0, 0x13, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x27, 0xF9, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0xC7, 0xC3, 0xFF, 0x3E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0x01, 0xFD,
  0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xFC, 0x07,
  0xF3, 0xF8, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xF9, 0xE0, 0xFF, 0x0F, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFD, 0xFC, 0x3E, 0x03, 0xE7,
  0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x23, 0xFC,
  0x1E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x78, 0x7F, 0xE3, 0xC7, 0xFF, 0xDE, 0x7F, 0xFF, 0xF3,
  0xE0, 0x3F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F,
  0xDF, 0x80, 0xFE, 0x7F, 0x1F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0x7C, 0x1F,
  0xE3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE3, 0x00, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x87, 0xE0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0x7F, 0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x3F, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8,
  0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0xF8, 0x0F, 0xC7, 0xC0,
  0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F,
  0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xF8, 0x3C, 0x7F, 0xE1, 0xFF,
  0x8F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFE, 0xFE, 0x07, 0xF8,
  0x0F, 0xBF, 0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0x00, 0x7B, 0xE0, 0x07,
  0xC0, 0x1E, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x80,
  0x1E, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x1F, 0xF8, 0x01, 0xE0, 0x07, 0xFE,
  0x00, 0x78, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x1F,
  0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x1E, 0x00,
  0x7F, 0xE0, 0x07, 0x80, 0x1F, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0x78,
  0x01, 0xFF, 0x80, 0x1E, 0x00, 0x7C, 0xF0, 0x7F, 0x0F, 0x1F, 0xFC, 0xF3,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xE0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x07, 0x8F, 0x80, 0x7C, 0x7F, 0x0F, 0xC1, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF0, 0xFE, 0x07, 0x8F, 0xFC, 0x3E, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xE0, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF,
  0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1E, 0xFC,
  0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x80, 0xFD, 0xFF, 0x1F, 0xCF, 0xFF, 0xFC,
  0x7D, 0xFF, 0xC3, 0xE3, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x7F,
  0xE3, 0xC7, 0xFF, 0xDE, 0x7F, 0xFF, 0xF3, 0xE0, 0x3F, 0xBE, 0x00, 0xFD,
  0xF0, 0x07, 0xEF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF,
  0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0xFE, 0x7F, 0x0F,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0x7C, 0x1F, 0xE3, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xF0,
  0x7F, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xCF,
  0xCF, 0x80, 0x27, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xDE, 0x07, 0xEF, 0xFF,
  0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x84, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0x7C, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFE, 0xF3, 0xFF,
  0xCF, 0x0F, 0xF8, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x07,
  0x80, 0x78, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xE1,
  0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xBC, 0x01, 0xF8, 0x03, 0xDF, 0x00, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x01,
  0xF3, 0xC0, 0x7F, 0x80, 0xF1, 0xE0, 0x3F, 0xC0, 0x78, 0xF8, 0x1D, 0xE0,
  0x7C, 0x7C, 0x1E, 0x70, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x07, 0x9E,
  0x1F, 0x07, 0xC3, 0x8F, 0x0F, 0x81, 0xE3, 0xC3, 0xC7, 0x80, 0xF1, 0xE1,
  0xE3, 0xC0, 0x78, 0xF0, 0xF3, 0xE0, 0x3E, 0xF0, 0x39, 0xE0, 0x0F, 0x78,
  0x1E, 0xF0, 0x07, 0xBC, 0x0F, 0x78, 0x03, 0xDC, 0x07, 0xBC, 0x01, 0xEE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xFB, 0xE0, 0x0F,
  0x9F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3E,
  0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB,
  0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x3C, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0xC7,
  0xC0, 0x1E, 0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x03,
  0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x80,
  0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x1F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_Medium42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 31, 11, 3, -30 },
  { 25, 12, 11, 18, 3, -30 },
  { 42, 25, 30, 27, 1, -30 },
  { 136, 20, 34, 24, 2, -32 },
  { 221, 32, 30, 36, 2, -30 },
  { 341, 29, 30, 31, 2, -30 },
  { 450, 4, 11, 10, 3, -30 },
  { 456, 10, 37, 13, 2, -30 },
  { 503, 10, 37, 13, 1, -30 },
  { 550, 19, 19, 23, 2, -32 },
  { 596, 20, 20, 24, 2, -25 },
  { 646, 6, 10, 11, 2, -5 },
  { 654, 10, 4, 13, 2, -13 },
  { 659, 6, 7, 11, 3, -6 },
  { 665, 16, 30, 16, 0, -30 },
  { 725, 20, 30, 24, 2, -30 },
  { 800, 13, 30, 24, 3, -30 },
  { 849, 20, 30, 24, 2, -30 },
  { 924, 20, 30, 24, 2, -30 },
  { 999, 22, 30, 24, 1, -30 },
  { 1082, 20, 30, 24, 2, -30 },
  { 1157, 20, 30, 24, 2, -30 },
  { 1232, 20, 30, 24, 2, -30 },
  { 1307, 20, 30, 24, 2, -30 },
  { 1382, 20, 30, 24, 2, -30 },
  { 1457, 6, 24, 11, 3, -23 },
  { 1475, 8, 28, 11, 1, -23 },
  { 1503, 20, 21, 24, 2, -26 },
  { 1556, 20, 12, 24, 2, -21 },
  { 1586, 20, 21, 24, 2, -26 },
  { 1639, 18, 31, 19, 0, -30 },
  { 1709, 33, 34, 38, 2, -30 },
  { 1850, 27, 30, 28, 0, -30 },
  { 1952, 21, 30, 27, 4, -30 },
  { 2031, 23, 30, 27, 2, -30 },
  { 2118, 24, 30, 31, 4, -30 },
  { 2208, 17, 30, 23, 4, -30 },
  { 2272, 17, 30, 22, 4, -30 },
  { 2336, 24, 30, 31, 3, -30 },
  { 2426, 23, 30, 31, 4, -30 },
  { 2513, 11, 30, 15, 2, -30 },
  { 2555, 11, 38, 12, -3, -30 },
  { 2608, 23, 30, 27, 4, -30 },
  { 2695, 17, 30, 22, 4, -30 },
  { 2759, 31, 30, 39, 4, -30 },
  { 2876, 25, 30, 33, 4, -30 },
  { 2970, 28, 30, 33, 2, -30 },
  { 3075, 20, 30, 26, 4, -30 },
  { 3150, 28, 37, 33, 2, -30 },
  { 3280, 22, 30, 27, 4, -30 },
  { 3363, 19, 30, 23, 2, -30 },
  { 3435, 22, 30, 24, 1, -30 },
  { 3518, 23, 30, 31, 4, -30 },
  { 3605, 26, 30, 26, 0, -30 },
  { 3703, 39, 30, 40, 0, -30 },
  { 3850, 26, 30, 26, 0, -30 },
  { 3948, 25, 30, 25, 0, -30 },
  { 4042, 22, 30, 24, 1, -30 },
  { 4125, 10, 37, 14, 3, -30 },
  { 4172, 16, 30, 16, 0, -30 },
  { 4232, 10, 37, 14, 1, -30 },
  { 4279, 22, 19, 24, 1, -30 },
  { 4332, 18, 3, 18, 0, 4 },
  { 4339, 9, 7, 13, 2, -32 },
  { 4347, 19, 23, 24, 2, -23 },
  { 4402, 21, 32, 26, 3, -32 },
  { 4486, 17, 23, 21, 2, -23 },
  { 4535, 21, 32, 26, 2, -32 },
  { 4619, 20, 23, 24, 2, -23 },
  { 4677, 16, 32, 15, 1, -32 },
  { 4741, 21, 33, 26, 2, -23 },
  { 4828, 20, 32, 26, 3, -32 },
  { 4908, 5, 31, 11, 3, -31 },
  { 4928, 10, 41, 11, -2, -31 },
  { 4980, 20, 32, 23, 3, -32 },
  { 5060, 5, 32, 11, 3, -32 },
  { 5080, 34, 23, 40, 3, -23 },
  { 5178, 20, 23, 26, 3, -23 },
  { 5236, 21, 23, 26, 2, -23 },
  { 5297, 21, 33, 26, 3, -23 },
  { 5384, 21, 33, 26, 2, -23 },
  { 5471, 14, 23, 18, 3, -23 },
  { 5512, 17, 23, 20, 2, -23 },
  { 5561, 14, 28, 16, 1, -28 },
  { 5610, 20, 23, 26, 3, -23 },
  { 5668, 22, 23, 22, 0, -23 },
  { 5732, 33, 23, 34, 0, -23 },
  { 5827, 21, 23, 23, 1, -23 },
  { 5888, 22, 33, 22, 0, -23 },
  { 5979, 16, 23, 20, 2, -23 },
  { 6025, 14, 37, 16, 1, -30 },
  { 6090, 3, 42, 23, 10, -32 },
  { 6106, 14, 37, 16, 1, -30 },
  { 6171, 20, 6, 24, 2, -18 },
};

const GFXfont NotoSans_Medium42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium42pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_MEDIUM42PT7B_H_
