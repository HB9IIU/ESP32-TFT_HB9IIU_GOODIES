#ifndef _NOTOSANS_MEDIUM51PT7B_H_
#define _NOTOSANS_MEDIUM51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0x1F, 0xBF, 0xFF, 0xFD, 0xFB, 0xF3, 0x80, 0xFC, 0x3F,
  0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0x38, 0xF8, 0xFC, 0x38, 0x08, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8,
  0x38, 0x00, 0xF8, 0x38, 0x00, 0xFC, 0x38, 0x00, 0x7F, 0x38, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x39, 0xFE, 0x00,
  0x38, 0x7E, 0x00, 0x38, 0x3E, 0x00, 0x38, 0x3F, 0x00, 0x38, 0x3F, 0x00,
  0x38, 0x3E, 0xC0, 0x38, 0x7E, 0xF8, 0x39, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00,
  0xFF, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x3E, 0x00,
  0x0F, 0x80, 0xF0, 0x78, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07,
  0xC3, 0xC0, 0x00, 0x3C, 0x0F, 0x8F, 0x87, 0xF0, 0x78, 0x1E, 0x1E, 0x3F,
  0xF0, 0xF8, 0x3C, 0x7C, 0xFF, 0xF1, 0xF0, 0xF8, 0xF1, 0xFB, 0xF1, 0xFF,
  0xE3, 0xE7, 0xC3, 0xE1, 0xFF, 0xCF, 0x8F, 0x83, 0xC1, 0xFF, 0x1E, 0x1E,
  0x07, 0xC1, 0xF8, 0x7C, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x0F, 0x00,
  0x03, 0xE1, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x3C, 0x00, 0x1F, 0x07,
  0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x01, 0xE0,
  0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x00, 0xF9, 0xF8,
  0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0xFF, 0xFC,
  0x00, 0xF8, 0x1F, 0xEF, 0xE0, 0x1F, 0x83, 0xF8, 0x7F, 0x01, 0xF8, 0x3F,
  0x03, 0xF8, 0x1F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x7E, 0x00, 0xFE, 0x3E,
  0x07, 0xC0, 0x07, 0xF7, 0xE0, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x01,
  0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xFF,
  0x81, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x02, 0xFC, 0x3C, 0x3E,
  0xFF, 0xBD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0x80,
  0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x81, 0xF0, 0x03, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0xFD, 0xFF, 0xFF, 0xEF,
  0xDF, 0x9C, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC1,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xEF, 0xFF, 0x1F, 0x7C, 0x3E, 0xF0, 0x7C,
  0xC0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0xF0, 0x01, 0xF8, 0x30,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xF0, 0x07, 0xF0, 0xE0, 0x01, 0xF8, 0x20, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFD, 0x80, 0x01,
  0xFC, 0xFC, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x86, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x40, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xB0, 0x00, 0x7F, 0x7C, 0x03, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0xF8,
  0xFF, 0xE0, 0x7D, 0xFF, 0xFC, 0x3E, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0x8F,
  0xF0, 0x0F, 0xEF, 0xF0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x3F, 0xE1, 0xF8, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0x7F, 0x87, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0xFC, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xCF,
  0xC0, 0x3F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0xF8,
  0x1F, 0xFC, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xBF, 0xFF,
  0xFD, 0xFB, 0xF3, 0x80, 0x1E, 0x3F, 0x7F, 0x7F, 0x7F, 0x3F, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8,
  0xF0, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3C,
  0x03, 0xF9, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xFF,
  0xF8, 0x3E, 0x3C, 0x03, 0xFF, 0xF8, 0x1E, 0x7C, 0x07, 0xFF, 0xF8, 0x1E,
  0x78, 0x0F, 0xC0, 0x78, 0x1F, 0x78, 0x1F, 0x80, 0xF8, 0x0F, 0xF8, 0x1F,
  0x00, 0xF8, 0x0F, 0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0xF8,
  0x0F, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0xF0,
  0x3C, 0x00, 0xF8, 0x0F, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0xF0, 0x3E, 0x00,
  0xF8, 0x1E, 0xF0, 0x3E, 0x01, 0xF8, 0x1E, 0xF0, 0x3E, 0x01, 0xF8, 0x1E,
  0xF0, 0x1F, 0x03, 0xF8, 0x3C, 0xF8, 0x1F, 0x87, 0xBC, 0x7C, 0xF8, 0x0F,
  0xFF, 0x3F, 0xF8, 0x78, 0x07, 0xFF, 0x1F, 0xF0, 0x7C, 0x03, 0xFC, 0x0F,
  0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x02, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xC7, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xF8, 0x01, 0xFF, 0x3E, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x1F,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC3, 0xE0, 0x07, 0xFC, 0xF8, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xEF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0xEF, 0x80, 0x07, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x3C, 0x0F, 0xE0, 0x00, 0x41, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x04, 0x0F, 0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x0F, 0x80, 0x7F, 0xF8, 0x7C, 0x00, 0x3F, 0xE3, 0xE0, 0x00, 0x7F, 0x1F,
  0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xFD,
  0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xFC, 0x7C, 0x00, 0x1F, 0xE3, 0xE0,
  0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x03, 0xC0, 0xFF, 0x00, 0x01, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x07, 0xDF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xFE, 0x00,
  0x01, 0xF1, 0xFC, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x1F, 0x07, 0xFE, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3,
  0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC,
  0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xE1, 0xF0, 0x03, 0xF8, 0x3E, 0x00,
  0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03,
  0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x87, 0xF0, 0x01, 0xF1, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFB, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0,
  0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7B, 0xFF,
  0x7C, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x3E, 0xFF, 0xDF, 0x00, 0x03,
  0xE7, 0xFE, 0x7C, 0x00, 0x1F, 0x3F, 0xF3, 0xE0, 0x00, 0xF1, 0xFF, 0x9F,
  0x00, 0x0F, 0x8F, 0xFC, 0x7C, 0x00, 0x7C, 0x7F, 0xE3, 0xE0, 0x03, 0xC3,
  0xFF, 0x1F, 0x00, 0x3E, 0x1F, 0xF8, 0x7C, 0x01, 0xF0, 0xFF, 0xC3, 0xE0,
  0x0F, 0x07, 0xFE, 0x1F, 0x00, 0xF8, 0x3F, 0xF0, 0x7C, 0x07, 0xC1, 0xFF,
  0x83, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x83, 0xE0, 0x7F, 0xE0, 0x7C, 0x1E,
  0x03, 0xFF, 0x03, 0xE1, 0xF0, 0x1F, 0xF8, 0x0F, 0x8F, 0x80, 0xFF, 0xC0,
  0x7C, 0x78, 0x07, 0xFE, 0x03, 0xE7, 0xC0, 0x3F, 0xF0, 0x0F, 0xBE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xF8, 0x00, 0x1F, 0xFB, 0xF0, 0x00, 0x7F,
  0xEF, 0xE0, 0x01, 0xFF, 0x9F, 0x80, 0x07, 0xFE, 0x3F, 0x00, 0x1F, 0xF8,
  0xFE, 0x00, 0x7F, 0xE1, 0xF8, 0x01, 0xFF, 0x83, 0xF0, 0x07, 0xFE, 0x0F,
  0xC0, 0x1F, 0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0x7F, 0x01, 0xFF, 0x80, 0xFC,
  0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x7F, 0xE0, 0x0F, 0xC1,
  0xFF, 0x80, 0x1F, 0x87, 0xFE, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0xFC, 0x7F,
  0xE0, 0x03, 0xF9, 0xFF, 0x80, 0x07, 0xE7, 0xFE, 0x00, 0x0F, 0xDF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8,
  0x0F, 0xFC, 0xF8, 0x01, 0xFE, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xF8,
  0x01, 0xFC, 0xF8, 0x7F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x5F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80, 0x7F, 0xC1, 0xF0, 0x01, 0xFC, 0x3E,
  0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xF8, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x7F, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0x3F, 0x80,
  0x02, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x60, 0x00,
  0xFE, 0xFC, 0x07, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC3, 0xFE, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x3E,
  0x78, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7C,
  0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7C,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0x03, 0xE1, 0xF8,
  0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x03, 0xF1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xC0,
  0x03, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7C,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x78, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x00,
  0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x87, 0x80,
  0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFC,
  0x3F, 0xC0, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0x7F, 0x00, 0x3E,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xBF, 0x01, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3C, 0x7F, 0xFC, 0x78, 0x7F, 0xE0, 0xF0, 0x08, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x0F, 0xCF, 0xFE, 0x07, 0xCF, 0xFF, 0xC3, 0xEF, 0xFF, 0xF1, 0xFF, 0xEF,
  0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0x80,
  0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7D,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x80, 0x3F, 0x3F, 0xF0, 0x7F,
  0x9F, 0xFF, 0xFF, 0x8F, 0xBF, 0xFF, 0x87, 0xCF, 0xFF, 0x83, 0xC1, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xF8, 0x06, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x13, 0xFC, 0x0F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0xDF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F,
  0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xCF, 0x0F, 0xFF, 0x8F, 0x03,
  0xFE, 0x0F, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x02, 0x3F, 0xC0, 0x1C, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x9C, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x0F, 0x0F,
  0xFF, 0xCF, 0x1F, 0xFF, 0xFF, 0x3F, 0xEF, 0xFF, 0x3F, 0x00, 0xFF, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F,
  0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F,
  0xFF, 0x9F, 0x03, 0xFF, 0x1F, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x30,
  0x00, 0xFE, 0x3F, 0x03, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x43, 0xFB, 0xFF, 0xDF,
  0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xF9,
  0xF8, 0x00, 0xFB, 0xF8, 0x00, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0xF8, 0xFF, 0xF0, 0x7F, 0xF8, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0xFB,
  0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0xFF, 0xF0, 0xF9, 0xFF,
  0xFC, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7E, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xE7, 0xFE, 0x0F, 0xE0, 0x1F, 0x87,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7C, 0x7F, 0xF8, 0x3E, 0x7F, 0xFE,
  0x1F, 0x7F, 0xFF, 0x8F, 0xFF, 0x7F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xFC, 0x01, 0xF9, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xFC, 0x7D, 0xFF, 0xFC,
  0x3E, 0x7F, 0xFC, 0x1F, 0x8F, 0xFC, 0x0F, 0xC0, 0x60, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0x0F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE7, 0xFF, 0x3F,
  0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFF, 0x1F, 0x00, 0x20, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0x3F, 0xEF, 0xBF, 0xF7, 0xFF, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0x7E, 0x3E, 0x00, 0x31,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF9, 0x00, 0x07, 0xCE, 0x00, 0x7E, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x04, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x06, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0x03,
  0xFF, 0x7F, 0xFF, 0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFE,
  0x1F, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0xFC, 0x00,
  0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x7C, 0x01, 0xFF, 0x00,
  0x7C, 0x7C, 0x01, 0xFF, 0x00, 0x7C, 0x7E, 0x01, 0xEF, 0x00, 0x7C, 0x3E,
  0x01, 0xEF, 0x80, 0xFC, 0x3E, 0x03, 0xEF, 0x80, 0xF8, 0x3E, 0x03, 0xE7,
  0x80, 0xF8, 0x3F, 0x03, 0xC7, 0x81, 0xF8, 0x1F, 0x07, 0xC7, 0xC1, 0xF8,
  0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x1F, 0x07, 0xC3, 0xC1, 0xF0, 0x1F, 0x8F,
  0x83, 0xE3, 0xF0, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0xF7, 0xC0, 0x07, 0xDE, 0x00,
  0xF7, 0xC0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xCF,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0,
  0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x9F, 0xF8, 0x00, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0x00, 0x1F, 0xF9, 0x00, 0x01,
  0xE0,
};

const GFXglyph NotoSans_Medium51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 37, 14, 3, -36 },
  { 34, 16, 13, 22, 3, -36 },
  { 60, 31, 36, 33, 1, -36 },
  { 200, 24, 42, 29, 3, -39 },
  { 326, 39, 38, 43, 2, -37 },
  { 512, 36, 38, 38, 2, -37 },
  { 683, 6, 13, 12, 3, -36 },
  { 693, 12, 44, 16, 2, -36 },
  { 759, 12, 44, 16, 2, -36 },
  { 825, 24, 23, 28, 2, -39 },
  { 894, 25, 24, 29, 2, -30 },
  { 969, 8, 13, 14, 2, -6 },
  { 982, 13, 5, 16, 2, -16 },
  { 991, 7, 8, 14, 3, -7 },
  { 998, 19, 37, 20, 0, -37 },
  { 1086, 25, 38, 29, 2, -37 },
  { 1205, 15, 36, 29, 4, -36 },
  { 1273, 25, 37, 29, 2, -37 },
  { 1389, 25, 38, 29, 2, -37 },
  { 1508, 27, 37, 29, 1, -37 },
  { 1633, 23, 37, 29, 3, -36 },
  { 1740, 25, 38, 29, 2, -37 },
  { 1859, 25, 36, 29, 2, -36 },
  { 1972, 25, 38, 29, 2, -37 },
  { 2091, 25, 38, 29, 2, -37 },
  { 2210, 7, 29, 14, 3, -28 },
  { 2236, 8, 35, 14, 2, -28 },
  { 2271, 25, 25, 29, 2, -31 },
  { 2350, 23, 14, 29, 3, -25 },
  { 2391, 25, 25, 29, 2, -31 },
  { 2470, 21, 38, 23, 1, -37 },
  { 2570, 40, 41, 46, 3, -37 },
  { 2775, 33, 37, 33, 0, -37 },
  { 2928, 26, 36, 33, 5, -36 },
  { 3045, 28, 38, 32, 3, -37 },
  { 3178, 29, 36, 37, 5, -36 },
  { 3309, 20, 36, 28, 5, -36 },
  { 3399, 20, 36, 27, 5, -36 },
  { 3489, 30, 38, 37, 3, -37 },
  { 3632, 28, 36, 38, 5, -36 },
  { 3758, 14, 36, 18, 2, -36 },
  { 3821, 14, 46, 15, -4, -36 },
  { 3902, 27, 36, 32, 5, -36 },
  { 4024, 21, 36, 27, 5, -36 },
  { 4119, 37, 36, 47, 5, -36 },
  { 4286, 30, 36, 40, 5, -36 },
  { 4421, 34, 38, 40, 3, -37 },
  { 4583, 24, 36, 31, 5, -36 },
  { 4691, 34, 46, 40, 3, -37 },
  { 4887, 27, 36, 32, 5, -36 },
  { 5009, 23, 38, 28, 3, -37 },
  { 5119, 27, 36, 29, 1, -36 },
  { 5241, 28, 37, 38, 5, -36 },
  { 5371, 31, 36, 31, 0, -36 },
  { 5511, 48, 36, 48, 0, -36 },
  { 5727, 31, 36, 31, 0, -36 },
  { 5867, 30, 36, 30, 0, -36 },
  { 6002, 25, 36, 29, 2, -36 },
  { 6115, 12, 44, 17, 4, -36 },
  { 6181, 19, 37, 20, 0, -37 },
  { 6269, 12, 44, 17, 1, -36 },
  { 6335, 25, 24, 29, 2, -37 },
  { 6410, 22, 3, 22, 0, 5 },
  { 6419, 12, 8, 16, 2, -39 },
  { 6431, 23, 29, 29, 2, -28 },
  { 6515, 25, 40, 32, 4, -39 },
  { 6640, 20, 29, 25, 3, -28 },
  { 6713, 24, 40, 32, 3, -39 },
  { 6833, 24, 29, 29, 3, -28 },
  { 6920, 19, 39, 18, 1, -39 },
  { 7013, 24, 40, 32, 3, -28 },
  { 7133, 24, 39, 32, 4, -39 },
  { 7250, 6, 38, 14, 4, -38 },
  { 7279, 13, 50, 14, -3, -38 },
  { 7361, 24, 39, 29, 4, -39 },
  { 7478, 6, 39, 14, 4, -39 },
  { 7508, 40, 28, 48, 4, -28 },
  { 7648, 24, 28, 32, 4, -28 },
  { 7732, 26, 29, 31, 3, -28 },
  { 7827, 25, 40, 32, 4, -28 },
  { 7952, 24, 40, 32, 3, -28 },
  { 8072, 17, 28, 22, 4, -28 },
  { 8132, 21, 29, 25, 2, -28 },
  { 8209, 17, 35, 20, 1, -34 },
  { 8284, 24, 28, 32, 4, -27 },
  { 8368, 27, 27, 27, 0, -27 },
  { 8460, 40, 28, 41, 1, -28 },
  { 8600, 26, 27, 28, 1, -27 },
  { 8688, 27, 39, 27, 0, -27 },
  { 8820, 20, 27, 24, 2, -27 },
  { 8888, 17, 44, 20, 1, -36 },
  { 8982, 4, 51, 28, 12, -39 },
  { 9008, 16, 44, 20, 2, -36 },
  { 9096, 25, 8, 29, 2, -22 },
};

const GFXfont NotoSans_Medium51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium51pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_MEDIUM51PT7B_H_
