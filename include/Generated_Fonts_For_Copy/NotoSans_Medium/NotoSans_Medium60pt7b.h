#ifndef _NOTOSANS_MEDIUM60PT7B_H_
#define _NOTOSANS_MEDIUM60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x78, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x1E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC7, 0xF8, 0xF0, 0x7C, 0x7F, 0x0F, 0x00, 0x87, 0xE0, 0xF0, 0x00,
  0xFE, 0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0xFE, 0x0F, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0x7F, 0xE0, 0x00, 0xF0, 0xFF, 0x00, 0x0F, 0x07, 0xF0,
  0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F,
  0x03, 0xF8, 0x00, 0xF0, 0x7F, 0xF0, 0x0F, 0x0F, 0xFF, 0xF0, 0xF7, 0xFE,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC1,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x1F, 0x07, 0xF8, 0x3E, 0x03, 0xF0, 0xF8,
  0x7F, 0xE1, 0xF8, 0x1F, 0x0F, 0x87, 0xFF, 0x87, 0xC0, 0xF8, 0xFC, 0x7F,
  0xFE, 0x3F, 0x0F, 0xC7, 0xC7, 0xF1, 0xF8, 0xFF, 0xFC, 0x7E, 0x3F, 0x07,
  0xC7, 0xFF, 0xC3, 0xE1, 0xF0, 0x3F, 0x1F, 0xFC, 0x3F, 0x1F, 0x80, 0xF8,
  0x3F, 0xC1, 0xF0, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x00,
  0xFC, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xFF, 0xE0,
  0x01, 0xF8, 0x1F, 0xF7, 0xF8, 0x00, 0xFC, 0x1F, 0xF1, 0xFE, 0x00, 0xFE,
  0x1F, 0xE0, 0x7F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x07, 0xF0,
  0x07, 0xF8, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0x83, 0xF8, 0x00, 0x7F,
  0x9F, 0xC1, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x79,
  0xE7, 0x9E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x40, 0x0F, 0x80, 0x13, 0xC0, 0x7C, 0x07, 0x9F,
  0xC3, 0xC1, 0xFC, 0xFF, 0xFE, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0x7E, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0x7F, 0xDF, 0xFF, 0x8F, 0xFF, 0x87, 0xEF, 0x83, 0xF3,
  0x81, 0xF8, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x7F, 0xE0, 0x3F, 0xE1, 0xF8, 0x00, 0xFF, 0x07, 0x80, 0x03, 0xF8, 0x10,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87,
  0xF8, 0x07, 0xFC, 0x3C, 0x00, 0x1F, 0xC3, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0xC0, 0x00, 0x1F, 0xEF, 0x80, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x0C, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x04, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x40, 0x00, 0x0F, 0xEC, 0x00, 0x07,
  0xF9, 0xF0, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x0F, 0xF8, 0x07, 0xE1, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xC1, 0xF9, 0xFF,
  0xFF, 0x8F, 0xDF, 0xFF, 0xFC, 0x7F, 0xF0, 0x1F, 0xF3, 0xFF, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x7F,
  0x80, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0x7F, 0xE0, 0x1F, 0xE0, 0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xF8, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x7F, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF,
  0x1F, 0x80, 0x7F, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0x7E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7,
  0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x7E, 0x01, 0xFE, 0x70, 0x00, 0x7F, 0x40, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xFF, 0x80, 0x7C, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x7C, 0x3F,
  0x00, 0x7F, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xE0, 0x3E, 0x3E,
  0x01, 0xFC, 0x07, 0xE0, 0x3E, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x7C,
  0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0x1E, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0xF8,
  0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x7C,
  0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x7C, 0x03, 0xF0, 0x3D, 0xE1, 0xF8, 0x7C,
  0x03, 0xFF, 0xFD, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xF8, 0xFF, 0xF0, 0x3E,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0x3F, 0x00, 0x03, 0xFC, 0xFC,
  0x00, 0x07, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x1F, 0xF8, 0xFC,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xFB,
  0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x0F,
  0xFC, 0x00, 0x1C, 0x1F, 0xF0, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x06, 0x0F, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x01, 0xFF,
  0xC3, 0xF0, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00,
  0x3F, 0xCF, 0xC0, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x01, 0xFE, 0xFC, 0x00,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x3F, 0xE3,
  0xF0, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x7F,
  0xC0, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00,
  0x1F, 0x8F, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0x80, 0x00, 0x7E, 0x0F, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF8,
  0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x07, 0xF8, 0x00,
  0xFC, 0x0F, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF8, 0x00,
  0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xDF,
  0x80, 0x00, 0x0F, 0xFF, 0xFB, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x7E, 0x00,
  0x00, 0x3E, 0xFF, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0xFC, 0xFC, 0x00, 0x01,
  0xFB, 0xFF, 0x8F, 0x80, 0x00, 0x3E, 0x7F, 0xF1, 0xF8, 0x00, 0x0F, 0xCF,
  0xFF, 0x3F, 0x00, 0x01, 0xF1, 0xFF, 0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0xFC,
  0x7E, 0x00, 0x0F, 0xC7, 0xFF, 0x8F, 0xC0, 0x01, 0xF0, 0xFF, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0xFE, 0x1F, 0x80, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0x01,
  0xF0, 0x7F, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xFF, 0x07, 0xE0, 0x0F, 0x81,
  0xFF, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xFF,
  0x81, 0xF8, 0x0F, 0x80, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0xFE, 0x03,
  0xF0, 0x7E, 0x03, 0xFF, 0xC0, 0x7E, 0x0F, 0x80, 0x7F, 0xF8, 0x07, 0xC3,
  0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x7E, 0x01, 0xFF, 0xE0, 0x1F, 0x8F, 0x80,
  0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7C, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xE7, 0xF0, 0x00,
  0x1F, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0xF0, 0xFE,
  0x00, 0x0F, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0xFC,
  0x3F, 0xC0, 0x07, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0x80, 0x1F,
  0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xF8, 0x07, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFC, 0x01,
  0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0xFE,
  0x00, 0x3F, 0xC3, 0xFF, 0xC0, 0x03, 0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0x8F,
  0xFF, 0x00, 0x07, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x0F,
  0xF7, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x7F, 0xCF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x03, 0xFC,
  0xFC, 0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xF8,
  0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xE3,
  0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFD,
  0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC0, 0x7F, 0x1F, 0xE0, 0x00, 0xE3, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFD, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0B, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF7, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xE3, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0x81, 0x80, 0x07, 0xF0, 0x20, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFD, 0xFF, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFF, 0xEF, 0xCF, 0xFF, 0xF9, 0xF8, 0xFF, 0xFE, 0x1F, 0x0F, 0xFF, 0x03,
  0xE0, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0xFF, 0xF0, 0x1F, 0x8F,
  0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x87, 0xEF, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F,
  0xF1, 0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00,
  0x3F, 0xDF, 0xF0, 0x01, 0xFC, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0xFF, 0xFE,
  0x3F, 0x7F, 0xFF, 0xE1, 0xF1, 0xFF, 0xFE, 0x0F, 0x87, 0xFF, 0xE0, 0x7C,
  0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF7, 0xF0, 0x7F, 0x80, 0x18, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x43, 0xFE, 0x01, 0xE1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x07, 0xFF, 0x87,
  0xE0, 0x7F, 0xFF, 0x3F, 0x07, 0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFE, 0x3F, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0,
  0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF,
  0x0F, 0x80, 0x7F, 0xF0, 0x7C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00,
  0xFE, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x21, 0xFF, 0x00, 0x1E, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xC3, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0x07, 0xC0, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xF9, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xFC, 0xFF, 0x00, 0x7F, 0xE7, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F,
  0xC0, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF,
  0xE7, 0xE0, 0x7F, 0xFE, 0x3F, 0x00, 0xFF, 0xE1, 0xF8, 0x00, 0x60, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x30, 0x00,
  0x0F, 0xF1, 0xF8, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x3F, 0xFE, 0x0F, 0xC7, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x8F,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xEF, 0xFC, 0x01, 0xFE, 0xFF, 0x80,
  0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x18, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7E,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x30, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF1, 0xFF, 0xC3, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x03,
  0xFC, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xF0, 0xFC, 0x01, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xC0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0xCF,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x01, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xC3, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x0F, 0x83, 0xFF, 0xE0, 0xF8, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF,
  0xFC, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFE, 0xFF, 0xC0, 0x1F, 0xEF,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xC1,
  0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0xC1, 0xFB, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF,
  0xFC, 0x7F, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFC,
  0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFF, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xF9, 0xFF, 0xC0, 0x7F,
  0xCF, 0xFF, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0xC3, 0xF3, 0xFF, 0xFC, 0x1F,
  0x8F, 0xFF, 0xC0, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x0C, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0x07, 0xC0, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xF9,
  0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xFC, 0xFF, 0x00, 0x3F, 0xE7,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE,
  0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0xFC, 0x1F,
  0xFF, 0xE7, 0xE0, 0x7F, 0xFE, 0x3F, 0x00, 0xFF, 0xE1, 0xF8, 0x00, 0x60,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x81, 0xFE, 0xF8, 0x7F, 0xEF, 0x8F, 0xFE, 0xFD,
  0xFF, 0xEF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0x80, 0xFC, 0xFE, 0x00, 0x18, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x7E, 0xF0, 0x00, 0xFE,
  0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0E,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF,
  0xE3, 0xF0, 0x7F, 0xF8, 0x1F, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x8F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x7C, 0x01, 0xFC, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0xF9, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0xC0, 0xFC, 0x07,
  0xE3, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x03, 0xF8, 0x1F,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC,
  0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x7C, 0x7E, 0x00, 0x3F, 0x1F, 0x00,
  0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x03,
  0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x07,
  0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x17, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_Medium60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 44, 16, 4, -43 },
  { 45, 18, 16, 26, 4, -43 },
  { 81, 36, 43, 39, 1, -43 },
  { 275, 28, 49, 34, 3, -46 },
  { 447, 45, 44, 51, 3, -43 },
  { 695, 41, 45, 44, 3, -44 },
  { 926, 6, 16, 14, 4, -43 },
  { 938, 15, 52, 19, 2, -43 },
  { 1036, 14, 52, 19, 2, -43 },
  { 1127, 29, 28, 33, 2, -46 },
  { 1229, 28, 29, 34, 3, -36 },
  { 1331, 10, 15, 16, 2, -7 },
  { 1350, 15, 6, 19, 2, -19 },
  { 1362, 8, 9, 16, 4, -8 },
  { 1371, 22, 43, 23, 1, -43 },
  { 1490, 29, 45, 34, 3, -44 },
  { 1654, 17, 43, 34, 5, -43 },
  { 1746, 29, 43, 34, 3, -43 },
  { 1902, 28, 44, 34, 3, -43 },
  { 2056, 32, 43, 34, 1, -43 },
  { 2228, 27, 44, 34, 4, -43 },
  { 2377, 29, 44, 34, 3, -43 },
  { 2537, 30, 43, 34, 2, -43 },
  { 2699, 29, 44, 34, 3, -43 },
  { 2859, 29, 44, 34, 3, -43 },
  { 3019, 8, 34, 16, 4, -33 },
  { 3053, 10, 41, 16, 2, -33 },
  { 3105, 28, 30, 34, 3, -37 },
  { 3210, 28, 16, 34, 3, -29 },
  { 3266, 28, 30, 34, 3, -37 },
  { 3371, 24, 44, 27, 1, -43 },
  { 3503, 48, 48, 54, 3, -43 },
  { 3791, 39, 43, 39, 0, -43 },
  { 4001, 30, 43, 39, 6, -43 },
  { 4163, 32, 44, 38, 4, -43 },
  { 4339, 34, 43, 44, 6, -43 },
  { 4522, 24, 43, 33, 6, -43 },
  { 4651, 24, 43, 32, 6, -43 },
  { 4780, 35, 44, 44, 4, -43 },
  { 4973, 33, 43, 45, 6, -43 },
  { 5151, 17, 43, 21, 2, -43 },
  { 5243, 17, 55, 17, -5, -43 },
  { 5360, 32, 43, 38, 6, -43 },
  { 5532, 24, 43, 32, 6, -43 },
  { 5661, 43, 43, 55, 6, -43 },
  { 5893, 35, 43, 47, 6, -43 },
  { 6082, 39, 45, 47, 4, -44 },
  { 6302, 28, 43, 37, 6, -43 },
  { 6453, 39, 54, 47, 4, -44 },
  { 6717, 31, 43, 38, 6, -43 },
  { 6884, 27, 44, 33, 3, -43 },
  { 7033, 32, 43, 34, 1, -43 },
  { 7205, 34, 44, 44, 5, -43 },
  { 7392, 37, 43, 37, 0, -43 },
  { 7591, 56, 43, 56, 0, -43 },
  { 7892, 36, 43, 37, 0, -43 },
  { 8086, 35, 43, 35, 0, -43 },
  { 8275, 30, 43, 34, 2, -43 },
  { 8437, 13, 52, 20, 5, -43 },
  { 8522, 22, 43, 23, 1, -43 },
  { 8641, 14, 52, 20, 1, -43 },
  { 8732, 30, 27, 34, 2, -43 },
  { 8834, 26, 4, 26, 0, 5 },
  { 8847, 14, 10, 18, 2, -46 },
  { 8865, 27, 34, 34, 3, -33 },
  { 8980, 29, 47, 37, 5, -46 },
  { 9151, 25, 34, 29, 3, -33 },
  { 9258, 29, 47, 37, 3, -46 },
  { 9429, 28, 34, 34, 3, -33 },
  { 9548, 23, 46, 21, 1, -46 },
  { 9681, 29, 47, 37, 3, -33 },
  { 9852, 28, 46, 38, 5, -46 },
  { 10013, 8, 45, 16, 4, -45 },
  { 10058, 15, 59, 16, -3, -45 },
  { 10169, 28, 46, 34, 5, -46 },
  { 10330, 6, 46, 16, 5, -46 },
  { 10365, 47, 33, 57, 5, -33 },
  { 10559, 28, 33, 38, 5, -33 },
  { 10675, 31, 34, 37, 3, -33 },
  { 10807, 29, 47, 37, 5, -33 },
  { 10978, 29, 47, 37, 3, -33 },
  { 11149, 20, 33, 25, 5, -33 },
  { 11232, 24, 34, 29, 3, -33 },
  { 11334, 20, 41, 23, 1, -40 },
  { 11437, 28, 33, 38, 5, -32 },
  { 11553, 32, 32, 32, 0, -32 },
  { 11681, 47, 32, 48, 1, -32 },
  { 11869, 31, 32, 33, 1, -32 },
  { 11993, 32, 46, 32, 0, -32 },
  { 12177, 24, 32, 29, 2, -32 },
  { 12273, 20, 52, 23, 1, -43 },
  { 12403, 5, 60, 33, 14, -46 },
  { 12441, 20, 52, 23, 2, -43 },
  { 12571, 28, 8, 34, 3, -25 },
};

const GFXfont NotoSans_Medium60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium60pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_MEDIUM60PT7B_H_
