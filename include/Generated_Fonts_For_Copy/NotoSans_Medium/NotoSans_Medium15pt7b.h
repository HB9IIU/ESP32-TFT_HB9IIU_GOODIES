#ifndef _NOTOSANS_MEDIUM15PT7B_H_
#define _NOTOSANS_MEDIUM15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDD, 0x99, 0x09, 0x0C, 0x84, 0xCF, 0xF7, 0xF8,
  0x90, 0xC9, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x10, 0xFF, 0x54, 0x8D, 0x0F,
  0x07, 0x8B, 0x97, 0xF8, 0x40, 0x80, 0x60, 0x92, 0x22, 0x4C, 0x49, 0x09,
  0x69, 0x2B, 0xDB, 0x48, 0x59, 0x11, 0x22, 0x24, 0x87, 0x00, 0x38, 0x1B,
  0x04, 0x41, 0xB0, 0x78, 0x1C, 0x0D, 0x8A, 0x36, 0x87, 0x31, 0xC7, 0xDC,
  0xFA, 0x2B, 0x69, 0x24, 0x93, 0x26, 0xC6, 0x23, 0x33, 0x11, 0x33, 0x32,
  0xE0, 0x30, 0x63, 0xF9, 0x87, 0x99, 0x80, 0x10, 0x20, 0x47, 0xF1, 0x02,
  0x04, 0x00, 0xFA, 0xFC, 0xF0, 0x0C, 0x21, 0x84, 0x10, 0xC2, 0x18, 0x61,
  0x0C, 0x00, 0x38, 0xDB, 0x14, 0x38, 0x70, 0xE1, 0xC3, 0xC7, 0x99, 0xE0,
  0x19, 0xF6, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x79, 0xFA, 0x10, 0x20, 0x41,
  0x86, 0x18, 0x61, 0x83, 0xF8, 0x79, 0x98, 0x10, 0x20, 0xCF, 0x03, 0x03,
  0x07, 0x1B, 0xE0, 0x06, 0x0E, 0x0E, 0x16, 0x36, 0x26, 0x46, 0xFF, 0xFF,
  0x06, 0x06, 0x7D, 0xFB, 0x06, 0x0F, 0x1F, 0x81, 0x83, 0x07, 0x1B, 0xE0,
  0x1C, 0xE9, 0x06, 0x0B, 0x9D, 0xB1, 0xC3, 0xC7, 0x89, 0xF0, 0xFF, 0xFC,
  0x10, 0x60, 0xC3, 0x06, 0x08, 0x30, 0x41, 0x80, 0x79, 0xDB, 0x1E, 0x26,
  0xC7, 0x33, 0x43, 0x87, 0x8D, 0xF0, 0x39, 0xDA, 0x14, 0x38, 0x79, 0xDF,
  0x83, 0x04, 0x1B, 0xE0, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x58, 0x06, 0x39,
  0xC6, 0x0E, 0x03, 0x81, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0xC0, 0x60,
  0x31, 0xCE, 0x30, 0x00, 0x7B, 0xF0, 0x41, 0x0C, 0x63, 0x08, 0x00, 0xC3,
  0x00, 0x0F, 0x03, 0x9C, 0x60, 0x64, 0xF2, 0x99, 0x39, 0x13, 0x91, 0x39,
  0x12, 0x9E, 0xEC, 0x00, 0x60, 0x03, 0xF8, 0x0C, 0x03, 0x01, 0xE0, 0x58,
  0x32, 0x0C, 0xC2, 0x31, 0xFC, 0x61, 0x90, 0x2C, 0x0C, 0xFC, 0xFE, 0xC3,
  0xC3, 0xC6, 0xFC, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x1E, 0x7F, 0x60, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x71, 0x3F, 0xFC, 0x7F, 0xB0, 0xD8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x63, 0xBF, 0x00, 0xFF, 0xFC, 0x30, 0xC3,
  0xFC, 0x30, 0xC3, 0x0F, 0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3,
  0x0C, 0x00, 0x1F, 0x9F, 0x98, 0x18, 0x0C, 0x06, 0x3F, 0x1F, 0x83, 0xC1,
  0xB8, 0xCF, 0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x60, 0xFE, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0xC6, 0xC4, 0xCC, 0xD8, 0xF8, 0xF8,
  0xCC, 0xC6, 0xC2, 0xC3, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0xF8, 0xE0, 0x7C, 0x0F, 0xC3, 0xF8, 0x5D, 0x1B, 0xB2, 0x76, 0x4E,
  0x59, 0xCE, 0x38, 0xC7, 0x18, 0x80, 0xE0, 0xF0, 0x7C, 0x3A, 0x1D, 0x8E,
  0x67, 0x33, 0x8D, 0xC3, 0xE1, 0xF0, 0x60, 0x1E, 0x1F, 0xE4, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0x98, 0xE3, 0xF0, 0xF9, 0xFF, 0x1E,
  0x1C, 0x39, 0xFF, 0x60, 0xC1, 0x83, 0x00, 0x1E, 0x1F, 0xE4, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0x98, 0xE3, 0xF0, 0x0C, 0x03, 0x00,
  0x60, 0xF8, 0xFE, 0xC2, 0xC2, 0xC2, 0xFE, 0xFC, 0xCC, 0xC6, 0xC2, 0xC3,
  0x7D, 0xFB, 0x06, 0x0E, 0x0F, 0x07, 0x03, 0x07, 0x1B, 0xE0, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1, 0x8F, 0x80, 0xC1, 0xE0,
  0xD0, 0x4C, 0x66, 0x31, 0x10, 0xD8, 0x2C, 0x14, 0x0E, 0x03, 0x00, 0xC3,
  0x0F, 0x0C, 0x34, 0x30, 0x99, 0xE2, 0x64, 0x99, 0x92, 0x62, 0xCD, 0x0F,
  0x34, 0x38, 0x70, 0x61, 0xC1, 0x86, 0x00, 0xC1, 0xB1, 0x88, 0x86, 0xC1,
  0xC0, 0x60, 0x70, 0x6C, 0x22, 0x31, 0xB0, 0x60, 0xC1, 0xA1, 0x98, 0xC4,
  0xC3, 0x40, 0xE0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFF, 0xFC, 0x30,
  0x61, 0x86, 0x0C, 0x30, 0xC1, 0x83, 0xF8, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xF0, 0xC1, 0x04, 0x18, 0x20, 0xC3, 0x04, 0x18, 0x20, 0xC0, 0xFF,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x10, 0x60, 0xE2, 0x44, 0xD8, 0xA1,
  0x80, 0xFE, 0xCC, 0x7D, 0x10, 0x5F, 0xC6, 0x1C, 0xFD, 0xC0, 0xC0, 0xC0,
  0xFC, 0xC6, 0xC2, 0xC3, 0xC2, 0xC2, 0xE6, 0xFC, 0x7F, 0x1C, 0x20, 0x83,
  0x0C, 0x5F, 0x06, 0x0C, 0x1B, 0xDC, 0x78, 0xE0, 0xC1, 0xC7, 0x8D, 0xE8,
  0x7D, 0x8B, 0x1F, 0xF8, 0x18, 0x30, 0xBE, 0x3C, 0x82, 0x3E, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x00, 0x7B, 0x8F, 0x1C, 0x18, 0x38, 0xF1, 0xBD, 0x06,
  0x0F, 0xF1, 0x80, 0xC1, 0x83, 0x07, 0xFE, 0x78, 0x70, 0xE1, 0xC3, 0x87,
  0x08, 0xF3, 0xFF, 0xFC, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xC0,
  0xC1, 0x83, 0x06, 0x3C, 0xDB, 0x3C, 0x7C, 0xC9, 0x9B, 0x18, 0xFF, 0xFF,
  0xFC, 0xFD, 0xEE, 0x73, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C,
  0x63, 0xFF, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x7D, 0x8F, 0x0C, 0x18,
  0x38, 0x71, 0xBE, 0xFC, 0xE6, 0xC2, 0xC3, 0xC2, 0xC2, 0xE6, 0xFC, 0xC0,
  0xC0, 0xC0, 0xC0, 0x7B, 0x8F, 0x1C, 0x18, 0x38, 0xF1, 0xBD, 0x06, 0x0C,
  0x18, 0x30, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xFA, 0x2C, 0x3C, 0x38, 0x38,
  0xFE, 0x21, 0x3E, 0xC6, 0x31, 0x8C, 0x61, 0xC0, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0xF1, 0xBD, 0xC3, 0x42, 0x66, 0x66, 0x24, 0x3C, 0x38, 0x18, 0xC6,
  0x34, 0x62, 0x4F, 0x26, 0xD6, 0x69, 0x62, 0x9C, 0x39, 0xC3, 0x0C, 0xE3,
  0x66, 0x3C, 0x18, 0x18, 0x3C, 0x66, 0xC3, 0xC3, 0x42, 0x66, 0x66, 0x24,
  0x3C, 0x18, 0x18, 0x18, 0x10, 0xF0, 0xC0, 0xF8, 0x61, 0x0C, 0x61, 0x0C,
  0x3F, 0x09, 0xCC, 0x63, 0x1B, 0x8C, 0x31, 0x8C, 0x61, 0x80, 0xFF, 0xFE,
  0x8C, 0x66, 0x66, 0x37, 0x66, 0x66, 0xC0, 0xFF, 0x18,
};

const GFXglyph NotoSans_Medium15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 9, 11, 10, 0, -11 },
  { 19, 7, 12, 9, 1, -11 },
  { 30, 11, 11, 13, 1, -11 },
  { 46, 10, 11, 11, 1, -11 },
  { 60, 2, 4, 4, 1, -11 },
  { 61, 3, 13, 5, 1, -11 },
  { 66, 4, 13, 5, 0, -11 },
  { 73, 7, 6, 8, 1, -11 },
  { 79, 7, 7, 9, 1, -9 },
  { 86, 2, 4, 4, 1, -2 },
  { 87, 3, 2, 5, 1, -5 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 6, 11, 6, 0, -11 },
  { 98, 7, 11, 9, 1, -11 },
  { 108, 5, 11, 9, 1, -11 },
  { 115, 7, 11, 9, 1, -11 },
  { 125, 7, 11, 9, 1, -11 },
  { 135, 8, 11, 9, 0, -11 },
  { 146, 7, 11, 9, 1, -11 },
  { 156, 7, 11, 9, 1, -11 },
  { 166, 7, 11, 9, 1, -11 },
  { 176, 7, 11, 9, 1, -11 },
  { 186, 7, 11, 9, 1, -11 },
  { 196, 2, 8, 4, 1, -8 },
  { 198, 3, 10, 4, 0, -8 },
  { 202, 7, 7, 9, 1, -9 },
  { 209, 7, 4, 9, 1, -7 },
  { 213, 7, 7, 9, 1, -9 },
  { 220, 6, 11, 7, 0, -11 },
  { 229, 12, 12, 13, 1, -11 },
  { 247, 10, 11, 10, 0, -11 },
  { 261, 8, 11, 10, 1, -11 },
  { 272, 8, 11, 10, 1, -11 },
  { 283, 9, 11, 11, 1, -11 },
  { 296, 6, 11, 8, 1, -11 },
  { 305, 6, 11, 8, 1, -11 },
  { 314, 9, 11, 11, 1, -11 },
  { 327, 9, 11, 11, 1, -11 },
  { 340, 4, 11, 5, 1, -11 },
  { 346, 4, 14, 4, -1, -11 },
  { 353, 8, 11, 9, 1, -11 },
  { 364, 7, 11, 8, 1, -11 },
  { 374, 11, 11, 14, 1, -11 },
  { 390, 9, 11, 12, 1, -11 },
  { 403, 10, 11, 12, 1, -11 },
  { 417, 7, 11, 9, 1, -11 },
  { 427, 10, 14, 12, 1, -11 },
  { 445, 8, 11, 9, 1, -11 },
  { 456, 7, 11, 8, 1, -11 },
  { 466, 8, 11, 8, 0, -11 },
  { 477, 9, 11, 11, 1, -11 },
  { 490, 9, 11, 9, 0, -11 },
  { 503, 14, 11, 14, 0, -11 },
  { 523, 9, 11, 9, 0, -11 },
  { 536, 9, 11, 9, 0, -11 },
  { 549, 7, 11, 9, 1, -11 },
  { 559, 4, 13, 5, 1, -11 },
  { 566, 6, 11, 6, 0, -11 },
  { 575, 4, 13, 5, 0, -11 },
  { 582, 7, 7, 9, 1, -11 },
  { 589, 7, 1, 7, 0, 1 },
  { 590, 3, 2, 5, 1, -11 },
  { 591, 6, 8, 9, 1, -8 },
  { 597, 8, 11, 9, 1, -11 },
  { 608, 6, 8, 7, 1, -8 },
  { 614, 7, 11, 9, 1, -11 },
  { 624, 7, 8, 9, 1, -8 },
  { 631, 6, 11, 5, 0, -11 },
  { 640, 7, 12, 9, 1, -8 },
  { 651, 7, 11, 9, 1, -11 },
  { 661, 2, 11, 4, 1, -11 },
  { 664, 4, 15, 4, -1, -11 },
  { 672, 7, 11, 8, 1, -11 },
  { 682, 2, 11, 4, 1, -11 },
  { 685, 12, 8, 14, 1, -8 },
  { 697, 7, 8, 9, 1, -8 },
  { 704, 7, 8, 9, 1, -8 },
  { 711, 8, 12, 9, 1, -8 },
  { 723, 7, 12, 9, 1, -8 },
  { 734, 5, 8, 6, 1, -8 },
  { 739, 6, 8, 7, 1, -8 },
  { 745, 5, 10, 6, 0, -10 },
  { 752, 7, 8, 9, 1, -8 },
  { 759, 8, 8, 8, 0, -8 },
  { 767, 12, 8, 12, 0, -8 },
  { 779, 8, 8, 8, 0, -8 },
  { 787, 8, 12, 8, 0, -8 },
  { 799, 6, 8, 7, 1, -8 },
  { 805, 5, 13, 6, 0, -11 },
  { 814, 1, 15, 8, 4, -11 },
  { 816, 4, 13, 6, 1, -11 },
  { 823, 7, 2, 9, 1, -6 },
};

const GFXfont NotoSans_Medium15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium15pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_MEDIUM15PT7B_H_
