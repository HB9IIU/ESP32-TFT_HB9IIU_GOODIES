#ifndef _NOTOSANS_MEDIUM30PT7B_H_
#define _NOTOSANS_MEDIUM30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x76, 0x66, 0x66, 0x60, 0x06, 0xFF, 0xF0,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1B, 0x8C, 0x03, 0x86, 0x00, 0xC3,
  0x80, 0x30, 0xE0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x07, 0xFF, 0xFD,
  0xFF, 0xFF, 0x06, 0x18, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0C,
  0x38, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0x70, 0xC0, 0x1C, 0x70, 0x06, 0x1C,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x38, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x0F, 0xFC, 0x7F, 0xFB, 0xEF, 0xCE, 0x30, 0x38, 0xC0, 0xE3, 0x03,
  0xCC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x37, 0x80, 0xCF,
  0x03, 0x3C, 0x0C, 0xEC, 0x37, 0xBF, 0xFC, 0xFF, 0xE0, 0x3C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x01, 0xC1, 0xFE, 0x07,
  0x03, 0x1C, 0x0C, 0x0E, 0x18, 0x38, 0x1C, 0x30, 0x60, 0x38, 0x71, 0xC0,
  0x70, 0xE3, 0x00, 0xE1, 0x8E, 0x00, 0xC3, 0x39, 0xF1, 0x8E, 0x77, 0xF3,
  0xFD, 0xCC, 0x73, 0xF3, 0x38, 0xE1, 0x8E, 0x71, 0xC0, 0x18, 0xE1, 0x80,
  0x71, 0xC3, 0x00, 0xC3, 0x86, 0x03, 0x87, 0x0C, 0x0E, 0x0E, 0x38, 0x1C,
  0x0C, 0x70, 0x70, 0x1F, 0xC1, 0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0x80, 0x07, 0xFE, 0x00, 0x38, 0x70, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0x70, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x80, 0xE3, 0xDE, 0x0E, 0x3C, 0x78, 0x71, 0xC1, 0xE7, 0x9E,
  0x07, 0xB8, 0xF0, 0x1F, 0xC3, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0xFD, 0xFF,
  0xC3, 0xFF, 0xDF, 0x07, 0xF8, 0x7C, 0xFF, 0xFF, 0xF8, 0x0E, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF0,
  0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x0E, 0x1C, 0xE0, 0xE0, 0xE1, 0xC1,
  0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x43, 0x07, 0xED, 0xFF, 0xFF, 0xCF, 0xFC, 0x07, 0xC0, 0x3F,
  0x01, 0xCE, 0x07, 0x3C, 0x3C, 0x70, 0x21, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x7B, 0xDC, 0xE6, 0x73, 0x80, 0xFF, 0xFF, 0x6F, 0xFF, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC7, 0x83,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xDC, 0x07, 0xB8, 0x0E, 0x70, 0x1C, 0xE0,
  0x38, 0xE0, 0xF1, 0xF7, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0x87, 0xC7,
  0xE7, 0xFF, 0x3B, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x03, 0x80, 0x3F,
  0xE1, 0xFF, 0xE3, 0xC3, 0xC2, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xE3, 0x83, 0xE2, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x07, 0xE0, 0x3F, 0x00,
  0x7F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3A, 0x00, 0xF7, 0xC7, 0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0xB8, 0x07, 0x38, 0x06,
  0x38, 0x0E, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x38, 0x38, 0x70, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xFF, 0xC3, 0xFF, 0xC6, 0x1F,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x3A, 0x01,
  0xEF, 0x3F, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x80, 0xEF,
  0xE1, 0xFF, 0xE7, 0xE1, 0xEF, 0x81, 0xFE, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x3C, 0xE0, 0x71, 0xF3, 0xE1, 0xFF, 0x80, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x3C, 0x1E, 0x3C, 0x78, 0x3F, 0xE0, 0x3F,
  0x00, 0xFF, 0x83, 0xCF, 0x8F, 0x07, 0x9C, 0x07, 0x78, 0x07, 0xE0, 0x0F,
  0xE0, 0x1D, 0xC0, 0x73, 0xC1, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0x80,
  0x3F, 0xC0, 0xFF, 0xC3, 0xC3, 0xC7, 0x03, 0xCE, 0x03, 0xBC, 0x07, 0x70,
  0x07, 0xF0, 0x1E, 0xE0, 0x3D, 0xC0, 0xFB, 0xE3, 0xF3, 0xFE, 0xE3, 0xFB,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE1, 0x0F, 0x83,
  0xFE, 0x07, 0xF0, 0x00, 0x2F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x06, 0xFF,
  0xF0, 0x33, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEE, 0x73,
  0xB9, 0xCC, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x1C, 0x00, 0x20, 0x00, 0x00, 0x07, 0x03, 0xFF, 0x3F, 0xFC, 0xC1, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3C,
  0x03, 0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x01, 0xCE, 0x07, 0xC1, 0x9C, 0x3F,
  0xE3, 0xF0, 0xFB, 0xC3, 0xE3, 0x83, 0x87, 0x87, 0x07, 0x0F, 0x0C, 0x0E,
  0x1E, 0x18, 0x1C, 0x3C, 0x30, 0x38, 0x78, 0x60, 0x71, 0xF0, 0xE1, 0xE3,
  0x61, 0xEF, 0xEE, 0xE1, 0xFD, 0xF8, 0xC0, 0xE0, 0xC1, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x0C, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x79, 0xC0, 0x07, 0x1E,
  0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x38, 0x03, 0xC3, 0x80, 0x1C, 0x78,
  0x01, 0xC7, 0x00, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xF1, 0xFF,
  0xF3, 0x81, 0xF7, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1E,
  0xE1, 0xF9, 0xFF, 0xC3, 0xFF, 0xE7, 0x03, 0xEE, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE,
  0x00, 0x00, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0x06, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0xFF, 0xF0, 0x7F,
  0xFC, 0x38, 0x3F, 0x9C, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0, 0x1F, 0x70, 0x1F, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0x0C, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03,
  0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0x7F, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x78, 0xFF, 0xFF, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0xFE, 0xFC, 0xF8, 0xE0, 0x1F, 0xE0,
  0x3C, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7,
  0x80, 0xEF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xF3, 0xC0, 0xE1,
  0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0,
  0x1E, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x37, 0xFC, 0x01,
  0xDF, 0xB8, 0x07, 0x7E, 0xE0, 0x39, 0xFB, 0x80, 0xE7, 0xE7, 0x03, 0x9F,
  0x9C, 0x1C, 0x7E, 0x70, 0x71, 0xF8, 0xE1, 0x87, 0xE3, 0x8E, 0x1F, 0x86,
  0x38, 0x7E, 0x1C, 0xC1, 0xF8, 0x77, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7E, 0x0F, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x70, 0x1C, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0x70, 0x1F, 0xBC, 0x0F,
  0xCF, 0x07, 0xE3, 0x83, 0xF1, 0xE1, 0xF8, 0x78, 0xFC, 0x1C, 0x7E, 0x0F,
  0x3F, 0x03, 0x8F, 0x81, 0xE7, 0xC0, 0x7B, 0xE0, 0x1D, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xE0, 0xF8, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0x70, 0x01,
  0xE7, 0x80, 0x1C, 0x3C, 0x03, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0xE3, 0xFF, 0xCE, 0x1F, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x81, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x83,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0xF8,
  0x78, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x3C,
  0x03, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xE1, 0xF8, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x3C,
  0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xE1, 0xC0,
  0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C,
  0xE0, 0x1E, 0xE0, 0x0F, 0x03, 0xC0, 0x7F, 0xF3, 0xFF, 0x9F, 0x06, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xFC, 0x03,
  0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x03, 0xFF, 0x7E, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70,
  0x0F, 0x7F, 0x7E, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x01, 0xDC, 0x00, 0xF7,
  0x00, 0x39, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0xC0, 0x70, 0x70,
  0x3C, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x07, 0x1C,
  0x01, 0xCF, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x00,
  0xF0, 0x0E, 0x70, 0x0F, 0x80, 0xE7, 0x81, 0xF8, 0x0E, 0x38, 0x1F, 0x81,
  0xE3, 0x81, 0xF8, 0x1C, 0x38, 0x39, 0xC1, 0xC3, 0xC3, 0x9C, 0x1C, 0x1C,
  0x39, 0xC3, 0xC1, 0xC3, 0x8E, 0x38, 0x1C, 0x70, 0xE3, 0x81, 0xE7, 0x0E,
  0x38, 0x0E, 0x70, 0xE7, 0x80, 0xEE, 0x07, 0x70, 0x0E, 0xE0, 0x77, 0x00,
  0xEE, 0x07, 0x70, 0x07, 0xE0, 0x37, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x03, 0xCE,
  0x01, 0xC3, 0xC0, 0xF0, 0x78, 0x38, 0x0E, 0x1E, 0x03, 0xCF, 0x00, 0x73,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x01, 0xCE, 0x00, 0xF3, 0xC0, 0x38, 0x78, 0x1C, 0x0E, 0x0F,
  0x03, 0xC3, 0x80, 0x79, 0xE0, 0x0E, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xDE,
  0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x38, 0x1C, 0x1E, 0x07, 0x87, 0x00, 0xE3,
  0xC0, 0x3C, 0xE0, 0x07, 0x78, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC,
  0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0xEC, 0x01, 0xDC, 0x03, 0x18, 0x0E, 0x38, 0x18, 0x30, 0x70, 0x70, 0xC0,
  0x63, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0x1F, 0xF0, 0xFF, 0xE1, 0x83, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x7F, 0xC7, 0xFF, 0x7E, 0x1D, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x3D, 0xE3, 0xF7, 0xFD, 0xCF, 0xE7, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7B, 0xF8, 0xFF,
  0xF9, 0xF8, 0xFB, 0xE0, 0x77, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xEF, 0xE7, 0xDD,
  0xFF, 0x39, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x7C, 0x6F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0xCE, 0x3F, 0xE1, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC7, 0xF7, 0x3F, 0xFD, 0xE1, 0xFF, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x0F, 0x7C, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x1F, 0xE0, 0xFF,
  0xC7, 0x87, 0xBC, 0x0E, 0xE0, 0x3B, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xF0, 0xE3, 0xFF, 0x83,
  0xFC, 0x03, 0xF0, 0xFF, 0x0F, 0xE1, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x07,
  0xFC, 0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0x1F, 0xDC, 0xFF, 0xF7, 0x87, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3D, 0xF3,
  0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x7D,
  0xF9, 0xFF, 0xC7, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3D, 0xFC, 0xFF, 0xFB, 0xF0, 0xFF, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xC0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x9E,
  0xFE, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x1E, 0xF0, 0x79, 0xE1, 0xE3, 0xC7, 0x87, 0x9E,
  0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFB, 0xC1, 0xE3, 0x83,
  0xC3, 0x87, 0x87, 0x8F, 0x07, 0x9E, 0x07, 0x3C, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xF1,
  0xFC, 0xEF, 0xFB, 0xFE, 0xFC, 0x7F, 0x1F, 0xF8, 0x3E, 0x0F, 0xF0, 0x3C,
  0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C,
  0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C,
  0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xE7, 0xF3,
  0xBF, 0xEF, 0xC3, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0x1F, 0xE0, 0x7F, 0xE1, 0xE1, 0xE7, 0x81, 0xEE, 0x01, 0xDC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x80,
  0xE7, 0x03, 0xCF, 0x8F, 0x0F, 0xFC, 0x07, 0xF0, 0xE7, 0xF1, 0xDF, 0xF3,
  0xF1, 0xF7, 0xC0, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xDF, 0xCF, 0xBF, 0xFE,
  0x7B, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xDC, 0xFF, 0xF7, 0x87, 0xFC, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x3D, 0xF3, 0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE7, 0xFB, 0xFE,
  0xF7, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x3F, 0xF7, 0xFF, 0x70, 0x6F, 0x00, 0xF0,
  0x07, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x70, 0x07, 0x80,
  0x7F, 0x0F, 0xFF, 0xE7, 0xFC, 0x18, 0x06, 0x03, 0x80, 0xE0, 0xFF, 0xFF,
  0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x11, 0xFC, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x3D, 0xF3, 0xF7, 0xFE, 0xC7, 0xE3, 0xF0, 0x0F,
  0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x1C, 0x38,
  0x1C, 0x38, 0x1C, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x70, 0x3C, 0x0E,
  0x70, 0x3E, 0x0E, 0x78, 0x7E, 0x0E, 0x38, 0x76, 0x1E, 0x38, 0x67, 0x1C,
  0x38, 0xE7, 0x1C, 0x3C, 0xE7, 0x1C, 0x1C, 0xE3, 0x38, 0x1C, 0xC3, 0xB8,
  0x1D, 0xC3, 0xB8, 0x0D, 0xC3, 0xB8, 0x0F, 0x81, 0xB0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0x00, 0xE0, 0x78, 0x0F, 0x38, 0x1C, 0x1C, 0x3C,
  0x1E, 0x38, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0x70, 0x0E, 0x78, 0x1C, 0x38, 0x3C, 0x1C, 0x78, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x38, 0x1C,
  0x38, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x9F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0x07, 0xC3, 0xF0, 0xF0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC3, 0xE0, 0xE0, 0x3E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0xE0, 0x3F, 0x07, 0xC0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3E, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x3F,
  0x03, 0xC3, 0xF0, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0xC3, 0xF0, 0xF8, 0x38, 0x00, 0x1C, 0x02, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xE8, 0x02, 0x00,
};

const GFXglyph NotoSans_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 9, 7, 13, 2, -21 },
  { 20, 18, 21, 19, 1, -21 },
  { 68, 14, 25, 17, 2, -23 },
  { 112, 23, 22, 26, 1, -22 },
  { 176, 21, 22, 22, 1, -22 },
  { 234, 3, 7, 7, 2, -21 },
  { 237, 7, 26, 9, 1, -21 },
  { 260, 7, 26, 9, 1, -21 },
  { 283, 14, 14, 16, 1, -23 },
  { 308, 15, 15, 17, 1, -18 },
  { 337, 5, 7, 8, 1, -3 },
  { 342, 8, 2, 10, 1, -9 },
  { 344, 4, 4, 8, 2, -4 },
  { 346, 11, 21, 12, 0, -21 },
  { 375, 15, 22, 17, 1, -22 },
  { 417, 9, 21, 17, 2, -21 },
  { 441, 15, 22, 17, 1, -22 },
  { 483, 15, 22, 17, 1, -22 },
  { 525, 16, 22, 17, 1, -22 },
  { 569, 14, 21, 17, 2, -21 },
  { 606, 15, 22, 17, 1, -22 },
  { 648, 15, 21, 17, 1, -21 },
  { 688, 15, 22, 17, 1, -22 },
  { 730, 15, 22, 17, 1, -22 },
  { 772, 4, 17, 8, 2, -17 },
  { 781, 5, 21, 8, 1, -17 },
  { 795, 15, 15, 17, 1, -18 },
  { 824, 14, 9, 17, 2, -15 },
  { 840, 15, 15, 17, 1, -18 },
  { 869, 13, 22, 13, 0, -22 },
  { 905, 23, 24, 27, 2, -21 },
  { 974, 20, 22, 20, 0, -22 },
  { 1029, 15, 21, 20, 3, -21 },
  { 1069, 16, 22, 19, 2, -22 },
  { 1113, 17, 21, 22, 3, -21 },
  { 1158, 12, 21, 17, 3, -21 },
  { 1190, 12, 21, 16, 3, -21 },
  { 1222, 18, 22, 22, 2, -22 },
  { 1272, 17, 21, 22, 3, -21 },
  { 1317, 8, 21, 11, 1, -21 },
  { 1338, 8, 27, 9, -2, -21 },
  { 1365, 16, 21, 19, 3, -21 },
  { 1407, 12, 21, 16, 3, -21 },
  { 1439, 22, 21, 28, 3, -21 },
  { 1497, 17, 21, 23, 3, -21 },
  { 1542, 20, 22, 24, 2, -22 },
  { 1597, 14, 21, 18, 3, -21 },
  { 1634, 20, 27, 24, 2, -22 },
  { 1702, 16, 21, 19, 3, -21 },
  { 1744, 14, 22, 17, 1, -22 },
  { 1783, 16, 21, 17, 0, -21 },
  { 1825, 16, 21, 22, 3, -21 },
  { 1867, 18, 21, 18, 0, -21 },
  { 1915, 28, 21, 28, 0, -21 },
  { 1989, 18, 21, 18, 0, -21 },
  { 2037, 18, 21, 18, 0, -21 },
  { 2085, 15, 21, 17, 1, -21 },
  { 2125, 7, 26, 10, 2, -21 },
  { 2148, 11, 21, 12, 0, -21 },
  { 2177, 7, 26, 10, 1, -21 },
  { 2200, 15, 14, 17, 1, -22 },
  { 2227, 13, 2, 13, 0, 3 },
  { 2231, 7, 5, 9, 1, -23 },
  { 2236, 14, 16, 17, 1, -16 },
  { 2264, 15, 23, 19, 2, -23 },
  { 2308, 12, 16, 15, 2, -16 },
  { 2332, 14, 23, 19, 2, -23 },
  { 2373, 14, 16, 17, 2, -16 },
  { 2401, 12, 23, 11, 0, -23 },
  { 2436, 14, 23, 19, 2, -16 },
  { 2477, 14, 23, 19, 2, -23 },
  { 2518, 4, 22, 8, 2, -22 },
  { 2529, 8, 29, 8, -2, -22 },
  { 2558, 15, 23, 17, 2, -23 },
  { 2602, 4, 23, 8, 2, -23 },
  { 2614, 24, 16, 28, 2, -16 },
  { 2662, 14, 16, 19, 2, -16 },
  { 2690, 15, 16, 18, 2, -16 },
  { 2720, 15, 23, 19, 2, -16 },
  { 2764, 14, 23, 19, 2, -16 },
  { 2805, 10, 16, 13, 2, -16 },
  { 2825, 12, 16, 15, 1, -16 },
  { 2849, 10, 20, 11, 1, -20 },
  { 2874, 14, 16, 19, 2, -16 },
  { 2902, 16, 16, 16, 0, -16 },
  { 2934, 24, 16, 24, 0, -16 },
  { 2982, 16, 16, 16, 0, -16 },
  { 3014, 16, 23, 16, 0, -16 },
  { 3060, 12, 16, 14, 1, -16 },
  { 3084, 10, 26, 12, 1, -21 },
  { 3117, 3, 30, 17, 7, -23 },
  { 3129, 10, 26, 12, 1, -21 },
  { 3162, 15, 5, 17, 1, -13 },
};

const GFXfont NotoSans_Medium30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium30pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_MEDIUM30PT7B_H_
