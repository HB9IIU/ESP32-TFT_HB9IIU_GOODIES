#ifndef _NOTOSANS_MEDIUM71PT7B_H_
#define _NOTOSANS_MEDIUM71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xBF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xE7, 0xF0, 0xF8, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E,
  0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0x1F, 0x03, 0xE3, 0xFE, 0x0F,
  0x80, 0x21, 0xFE, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x0F, 0xF0,
  0x3E, 0x00, 0x07, 0xFC, 0x1F, 0x00, 0x01, 0xFF, 0x8F, 0x80, 0x00, 0xFF,
  0xF7, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00, 0xF8, 0x7F,
  0xC0, 0x00, 0x7C, 0x1F, 0xF0, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x1F, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x03, 0xE0,
  0x7F, 0xC0, 0x01, 0xF0, 0x3F, 0xF8, 0x00, 0xF8, 0x3F, 0xDF, 0xC0, 0x7C,
  0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0xFE, 0x0F, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0xFF, 0xFC, 0x1F,
  0x80, 0x7E, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x1F, 0xFF,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0xFF, 0x1F, 0xC3, 0xFF, 0xFF, 0x0F, 0xC3,
  0xF0, 0x3F, 0x87, 0xFF, 0xF8, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xFF, 0xC3,
  0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0xFE, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x1F,
  0xE0, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xCF, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0xF8, 0x01,
  0xDF, 0xC0, 0x7C, 0x0F, 0xEF, 0xFE, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0x7F, 0x7F, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xF7, 0xE0, 0x7F, 0x3C, 0x07, 0xF1, 0x80,
  0x7F, 0x10, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x01, 0xFF, 0x07, 0x80, 0x00, 0x3F, 0xC0,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0xFC, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x01, 0xFF, 0x02, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE8, 0x00, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x07,
  0xFC, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xA0, 0x00, 0x00, 0xFF, 0x9C,
  0x00, 0x00, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xFE, 0x00, 0xFE, 0x3F, 0xFF,
  0xF0, 0x1F, 0xCF, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xFE, 0x7F,
  0xF0, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFC, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFE, 0x00,
  0x3F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x01,
  0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xF1, 0xFF, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF,
  0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xE1, 0xFC, 0x01, 0xFF, 0xE0, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xC7, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7,
  0xF0, 0xF8, 0x07, 0xC0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xC7, 0x80, 0x01, 0xFE,
  0x30, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x7E, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7E, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x3E,
  0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x3F, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x7E, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x3E, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x7E, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0xFC, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xF8, 0xFC,
  0x00, 0xFF, 0x03, 0xEF, 0xC3, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x00,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x3F,
  0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0xFC, 0xFE, 0x00,
  0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0x0F,
  0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0x8F,
  0xE0, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03,
  0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x03, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0xEF, 0xE0, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x07,
  0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0xC7,
  0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xF9, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xBF,
  0x80, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x1F,
  0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x7F,
  0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x1F, 0xC0, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x00, 0x02,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x00, 0x01, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xC3, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x03, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x03,
  0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xF8,
  0x00, 0x00, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFC,
  0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x3F,
  0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x1F,
  0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFD, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xF0, 0x00, 0x00,
  0x1F, 0xBF, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xFF, 0xCF, 0xE0, 0x00,
  0x00, 0xFE, 0xFF, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0xFF, 0x9F, 0xC0,
  0x00, 0x07, 0xF3, 0xFF, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x3F,
  0x00, 0x00, 0x1F, 0x8F, 0xFF, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFF, 0xF8,
  0xFE, 0x00, 0x00, 0xFC, 0x3F, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xFF,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x1F,
  0xFF, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0x3F,
  0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0xFF, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xC1, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xCF, 0xF8, 0x00, 0x03,
  0xFF, 0xE3, 0xFC, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xF8, 0x00, 0x03,
  0xFE, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x7F, 0xDF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFC, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x07, 0xFE, 0x7F,
  0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x0F,
  0xFC, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFF, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xC1, 0xFC,
  0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x00, 0x3F,
  0xE3, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0xFE, 0x00,
  0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0x18,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x80, 0x00, 0x03, 0xFE, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x1F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xF8,
  0x07, 0xFE, 0x03, 0xC0, 0x01, 0xFE, 0x02, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC,
  0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0x7F, 0xF0,
  0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0xFE, 0x3F, 0x1F, 0xFF,
  0xFC, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x0F,
  0xFF, 0x80, 0x3F, 0x87, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF, 0xFF, 0x83, 0xFB,
  0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0x8F,
  0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xCF, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0xC0,
  0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xCF,
  0xFF, 0xFF, 0x83, 0xF1, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0x83, 0xFF, 0x00,
  0x1C, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x02, 0x1F, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF,
  0xC7, 0xF0, 0x7F, 0xFF, 0xF9, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0x00, 0x3F, 0xFC, 0xFF,
  0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF,
  0xFC, 0x3F, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xFE, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x04, 0x1F, 0xF8, 0x00, 0x1E, 0x07, 0xFF, 0xE3, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x30,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x03, 0xF0,
  0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFF, 0xDF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xC7,
  0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xFE, 0x7F,
  0x03, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0x87, 0xF0, 0x07, 0xFF, 0x81,
  0xFC, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xC0,
  0x00, 0x03, 0xFE, 0x3C, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0x0F, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xFF, 0x1F, 0xDF, 0xFF, 0xFF, 0x8F,
  0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x1C, 0x3F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFB, 0x07, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x01, 0xFF,
  0x3F, 0x80, 0x01, 0xFF, 0x1F, 0xC0, 0x01, 0xFF, 0x0F, 0xE0, 0x01, 0xFF,
  0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x3F, 0x81, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC1,
  0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x03, 0xFE,
  0x3F, 0x80, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F,
  0xF7, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0x07,
  0xFF, 0xFC, 0x1F, 0x8F, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFE, 0xFF,
  0xE0, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0x03, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0xE0,
  0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xF3, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFB, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xF0, 0x3F, 0x87, 0xFF, 0xF8,
  0x0F, 0xE0, 0x7F, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0x07, 0xFF,
  0xFF, 0xDF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF,
  0xC0, 0x07, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF,
  0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0x87, 0xF0, 0x07,
  0xFF, 0x81, 0xFC, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xBF, 0xBF, 0xFF, 0x7F,
  0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x0F, 0xC7, 0xF8, 0x00, 0x1C,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF4, 0x00, 0x00, 0xFF,
  0x78, 0x00, 0x1F, 0xF7, 0xF8, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xF9, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xEF, 0xC0, 0x03,
  0xF8, 0x3F, 0xC0, 0x07, 0xEF, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE7,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xF0, 0x1F, 0xE0,
  0x0F, 0xC7, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x47, 0xFF, 0xE0, 0x00, 0x33, 0xFF, 0xFE, 0x00, 0x1D,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0x3F,
  0xFE, 0x20, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_Medium71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 10, 52, 19, 5, -51 },
  { 66, 21, 19, 30, 5, -51 },
  { 116, 42, 51, 46, 2, -51 },
  { 384, 33, 58, 41, 4, -54 },
  { 624, 54, 52, 60, 3, -51 },
  { 975, 49, 52, 52, 3, -51 },
  { 1294, 7, 19, 17, 5, -51 },
  { 1311, 17, 62, 22, 3, -51 },
  { 1443, 17, 62, 22, 2, -51 },
  { 1575, 33, 32, 39, 3, -54 },
  { 1707, 34, 34, 41, 3, -42 },
  { 1852, 11, 17, 19, 3, -8 },
  { 1876, 17, 6, 23, 3, -22 },
  { 1889, 10, 10, 19, 5, -9 },
  { 1902, 26, 51, 27, 1, -51 },
  { 2068, 34, 52, 41, 3, -51 },
  { 2289, 20, 51, 41, 6, -51 },
  { 2417, 34, 51, 41, 3, -51 },
  { 2634, 34, 52, 41, 3, -51 },
  { 2855, 38, 51, 41, 1, -51 },
  { 3098, 33, 52, 41, 4, -51 },
  { 3313, 35, 52, 41, 3, -51 },
  { 3541, 34, 51, 41, 3, -51 },
  { 3758, 34, 52, 41, 3, -51 },
  { 3979, 34, 52, 41, 3, -51 },
  { 4200, 10, 40, 19, 5, -39 },
  { 4250, 12, 48, 19, 2, -39 },
  { 4322, 34, 36, 41, 3, -44 },
  { 4475, 33, 20, 41, 4, -35 },
  { 4558, 34, 36, 41, 3, -44 },
  { 4711, 29, 52, 32, 1, -51 },
  { 4900, 56, 57, 64, 4, -51 },
  { 5299, 46, 51, 47, 0, -51 },
  { 5593, 36, 51, 46, 7, -51 },
  { 5823, 39, 52, 45, 4, -51 },
  { 6077, 41, 51, 52, 7, -51 },
  { 6339, 28, 51, 40, 7, -51 },
  { 6518, 28, 51, 37, 7, -51 },
  { 6697, 42, 52, 52, 4, -51 },
  { 6970, 39, 51, 53, 7, -51 },
  { 7219, 19, 51, 25, 3, -51 },
  { 7341, 19, 65, 21, -5, -51 },
  { 7496, 38, 51, 45, 7, -51 },
  { 7739, 29, 51, 38, 7, -51 },
  { 7924, 51, 51, 65, 7, -51 },
  { 8250, 41, 51, 55, 7, -51 },
  { 8512, 47, 52, 56, 4, -51 },
  { 8818, 33, 51, 43, 7, -51 },
  { 9029, 47, 63, 56, 4, -51 },
  { 9400, 37, 51, 45, 7, -51 },
  { 9636, 32, 52, 39, 4, -51 },
  { 9844, 38, 51, 40, 1, -51 },
  { 10087, 40, 52, 52, 6, -51 },
  { 10347, 44, 51, 44, 0, -51 },
  { 10628, 65, 51, 67, 1, -51 },
  { 11043, 43, 51, 43, 0, -51 },
  { 11318, 41, 51, 41, 0, -51 },
  { 11580, 36, 51, 41, 2, -51 },
  { 11810, 17, 62, 23, 5, -51 },
  { 11942, 26, 51, 27, 1, -51 },
  { 12108, 16, 62, 23, 2, -51 },
  { 12232, 36, 32, 41, 2, -51 },
  { 12376, 31, 5, 31, 0, 6 },
  { 12396, 16, 11, 22, 3, -54 },
  { 12418, 32, 40, 41, 3, -39 },
  { 12578, 34, 55, 44, 6, -54 },
  { 12812, 29, 40, 35, 4, -39 },
  { 12957, 34, 55, 44, 4, -54 },
  { 13191, 33, 40, 41, 4, -39 },
  { 13356, 27, 54, 25, 1, -54 },
  { 13539, 34, 56, 44, 4, -39 },
  { 13777, 33, 54, 45, 6, -54 },
  { 14000, 9, 53, 19, 5, -53 },
  { 14060, 18, 70, 19, -4, -53 },
  { 14218, 33, 54, 40, 6, -54 },
  { 14441, 7, 54, 19, 6, -54 },
  { 14489, 56, 39, 67, 6, -39 },
  { 14762, 33, 39, 45, 6, -39 },
  { 14923, 36, 40, 43, 4, -39 },
  { 15103, 34, 56, 44, 6, -39 },
  { 15341, 34, 56, 44, 4, -39 },
  { 15579, 23, 39, 30, 6, -39 },
  { 15692, 28, 40, 35, 3, -39 },
  { 15832, 24, 48, 27, 1, -47 },
  { 15976, 34, 39, 45, 5, -38 },
  { 16142, 37, 38, 37, 0, -38 },
  { 16318, 56, 38, 57, 1, -38 },
  { 16584, 37, 38, 39, 1, -38 },
  { 16760, 37, 55, 37, 0, -38 },
  { 17015, 28, 38, 34, 3, -38 },
  { 17148, 23, 62, 27, 2, -51 },
  { 17327, 6, 71, 39, 17, -54 },
  { 17381, 24, 62, 27, 2, -51 },
  { 17567, 34, 10, 41, 3, -30 },
};

const GFXfont NotoSans_Medium71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium71pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_MEDIUM71PT7B_H_
