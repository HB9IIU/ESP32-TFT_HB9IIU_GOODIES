#ifndef _NOTOSANS_MEDIUM63PT7B_H_
#define _NOTOSANS_MEDIUM63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium63pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF7, 0xF0, 0xF0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0x9E, 0x3F, 0x8F, 0xF0, 0xF0, 0x1C, 0x7F,
  0x07, 0x80, 0x03, 0xF0, 0x3C, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0xFC, 0x0F,
  0x00, 0x07, 0xE0, 0x78, 0x00, 0x3F, 0x83, 0xC0, 0x01, 0xFE, 0x1E, 0x00,
  0x0F, 0xFC, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xBF,
  0xF8, 0x00, 0x3C, 0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0x00, 0x0F, 0x03, 0xF8,
  0x00, 0x78, 0x1F, 0xC0, 0x03, 0xC0, 0xFE, 0x00, 0x1E, 0x07, 0xF0, 0x00,
  0xF0, 0x3F, 0xE0, 0x07, 0x83, 0xFB, 0xE0, 0x3C, 0x7F, 0xDF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0xF8, 0x06, 0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x7F, 0xE0, 0xFC, 0x07, 0xE1,
  0xF0, 0xFF, 0xF0, 0x7C, 0x07, 0xC3, 0xF1, 0xFF, 0xF8, 0x7E, 0x0F, 0xC3,
  0xE1, 0xFF, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0x8F,
  0xC3, 0xE0, 0x7E, 0x1F, 0xFF, 0x0F, 0xC7, 0xE0, 0x7E, 0x0F, 0xFE, 0x1F,
  0x87, 0xE0, 0x3E, 0x07, 0xFC, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0xC0, 0x3F,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x9F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFC,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x03, 0xFF, 0x7F, 0x80, 0x0F, 0xE0, 0xFF,
  0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x07, 0xF8,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x7F,
  0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x1F, 0x00, 0xE7,
  0xF0, 0x78, 0x3F, 0x9F, 0xF9, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x38, 0x03, 0x80, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x1E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F,
  0xFF, 0x3F, 0xEF, 0xDF, 0xE3, 0xFF, 0xF0, 0xFD, 0xF8, 0x3F, 0x3C, 0x0F,
  0xC6, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFE, 0x07, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x3E, 0x00, 0x0F, 0xF0, 0x60,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0x80, 0x07, 0xFC,
  0x38, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE8, 0x00, 0x00, 0x7F, 0xB8, 0x00, 0x07, 0xFC,
  0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x02, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x40, 0x00, 0x0F, 0xF3, 0x80, 0x00, 0xFF,
  0x9F, 0xC0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFF,
  0xE0, 0x1F, 0x8F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFB,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x0F,
  0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFE,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFC, 0x7F,
  0x01, 0xFF, 0xC1, 0xF8, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x10, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xDF, 0xC3, 0xC0, 0x07, 0x03, 0xF8, 0x7F, 0x1F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xF9,
  0xE0, 0x01, 0xFE, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xFF, 0xFC,
  0x07, 0xE1, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x01, 0xFF, 0xFF,
  0xE0, 0x3E, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0x7F, 0x80,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7D, 0xF8, 0x0F, 0xC0,
  0x07, 0xC0, 0x1F, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0xF8,
  0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0x7D, 0xF0, 0x1F,
  0x80, 0x07, 0xC0, 0x1F, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x9F,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF9,
  0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7C, 0x7C, 0x03, 0xF8, 0x0F, 0xF8, 0x3F,
  0x1F, 0x00, 0x7F, 0x8F, 0xDF, 0xBF, 0x87, 0xE0, 0x1F, 0xFF, 0xE7, 0xFF,
  0xC0, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0xE0, 0x3E, 0x00, 0x7F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3C,
  0x0F, 0xF8, 0x00, 0x01, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x0C, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0xFE, 0x00,
  0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xCF,
  0xE0, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x7F,
  0xF0, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xFF, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xF3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xF0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xBF, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFF, 0xF7, 0xE0, 0x00, 0x01,
  0xF3, 0xFF, 0xDF, 0x80, 0x00, 0x0F, 0xDF, 0xFF, 0x3F, 0x00, 0x00, 0x3F,
  0x7F, 0xFC, 0xFC, 0x00, 0x00, 0xF9, 0xFF, 0xF3, 0xF8, 0x00, 0x07, 0xE7,
  0xFF, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0xFF, 0x1F, 0x80, 0x00, 0xFC, 0x7F,
  0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xFF,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0xFF, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0xFC,
  0x1F, 0x80, 0x07, 0xC1, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xFF, 0xC0,
  0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0xFC, 0x03, 0xF0,
  0x3E, 0x01, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x87,
  0xE0, 0x1F, 0xFF, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xF3, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xF9, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xFE,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0x87, 0xF8, 0x00,
  0x3F, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x1F,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0xC0, 0x03, 0xFC,
  0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0x87, 0xFF, 0x80,
  0x01, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0xE0, 0x00, 0x3F, 0xCF,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xF8, 0x00, 0x03, 0xFB, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xF8, 0x01, 0xFF,
  0xDF, 0xC0, 0x03, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xEF,
  0xE0, 0x01, 0xFF, 0x7F, 0x00, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xC1,
  0xFC, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x87, 0xF8, 0x00, 0x78, 0x7F, 0x80, 0x00, 0x43, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFB, 0x00, 0x00, 0x3F, 0xDF, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x83, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x3F, 0x8F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x7F, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0x60, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3,
  0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xF1,
  0xF1, 0xFF, 0xFE, 0x1F, 0x07, 0xFF, 0x81, 0xF0, 0x07, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x18, 0x00, 0x3F, 0x83, 0xFF, 0x00, 0x7F, 0x1F, 0xFF,
  0x80, 0xFE, 0x7F, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80,
  0x07, 0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xDF, 0xFF, 0xFE, 0x1F, 0x9F, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF,
  0xC0, 0x7C, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0xF0, 0x7F, 0x80, 0x04, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x87, 0xFE, 0x03, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x17, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xC0, 0x1F,
  0xC0, 0x1F, 0xFC, 0x3F, 0x80, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xFE, 0xFE,
  0x1F, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xF3,
  0xFE, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7,
  0xE0, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0xFE, 0x1F, 0x80, 0x7F, 0xF8, 0x3F,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x10, 0x7F, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0x0E, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0xE1, 0xF8, 0x3F, 0xFF, 0xF3, 0xF0, 0xFF,
  0xFF, 0xF7, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0x9F, 0xF0,
  0x03, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xE3,
  0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x7F, 0x07,
  0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xC3, 0xF8, 0x00,
  0x30, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x40, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0x00, 0x0F, 0xE0, 0xFF, 0xE0, 0x3F, 0x8F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF,
  0xC3, 0xFB, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFC,
  0xFF, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x7E, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x39, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x38, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0xC7, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFC,
  0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x3F, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC3, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xE0,
  0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0xF8,
  0xFC, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xBF,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFB, 0xFE, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xF8, 0x1F, 0xFC, 0x03, 0xF0, 0xFF, 0xFC, 0x07, 0xE3, 0xFF, 0xFE,
  0x0F, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x07, 0xFC,
  0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xFC, 0x00,
  0xFF, 0x9F, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFE, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0xFE, 0x03, 0xF8, 0x7F, 0xF8,
  0x07, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0xE1, 0xF8, 0x3F,
  0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xF7, 0xE1, 0xFF, 0xFF, 0xEF, 0xC7, 0xFC,
  0x07, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xDF, 0x87,
  0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xF1, 0xFC, 0x03,
  0xFF, 0xC3, 0xF8, 0x00, 0x70, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xE7, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xEF,
  0xCF, 0xFF, 0x7E, 0x7F, 0xFB, 0xF7, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF1, 0xFC, 0x00, 0xF9, 0xFC, 0x00, 0x08, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF7, 0xC0, 0x07, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x04, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0xF0,
  0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xCF,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3E, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x7E, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x9F, 0x80, 0x3F,
  0x03, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x7C, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x1F, 0x83,
  0xF8, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xE0, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x08,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xB0, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x7F,
  0xC0,
};

const GFXglyph NotoSans_Medium63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 46, 17, 4, -45 },
  { 53, 19, 16, 27, 4, -45 },
  { 91, 37, 45, 41, 2, -45 },
  { 300, 29, 52, 36, 4, -48 },
  { 489, 48, 47, 54, 3, -46 },
  { 771, 43, 47, 46, 3, -46 },
  { 1024, 7, 16, 15, 4, -45 },
  { 1038, 15, 55, 20, 3, -45 },
  { 1142, 15, 55, 20, 2, -45 },
  { 1246, 30, 29, 35, 2, -48 },
  { 1355, 30, 30, 36, 3, -37 },
  { 1468, 11, 15, 17, 2, -7 },
  { 1489, 16, 6, 20, 2, -20 },
  { 1501, 9, 9, 17, 4, -8 },
  { 1512, 23, 45, 24, 1, -45 },
  { 1642, 30, 47, 36, 3, -46 },
  { 1819, 18, 45, 36, 5, -45 },
  { 1921, 30, 46, 36, 3, -46 },
  { 2094, 30, 47, 36, 3, -46 },
  { 2271, 34, 45, 36, 1, -45 },
  { 2463, 29, 46, 36, 4, -45 },
  { 2630, 30, 47, 36, 3, -46 },
  { 2807, 31, 45, 36, 2, -45 },
  { 2982, 30, 47, 36, 3, -46 },
  { 3159, 30, 47, 36, 3, -46 },
  { 3336, 9, 36, 17, 4, -35 },
  { 3377, 11, 43, 17, 2, -35 },
  { 3437, 30, 32, 36, 3, -39 },
  { 3557, 30, 18, 36, 3, -31 },
  { 3625, 30, 32, 36, 3, -39 },
  { 3745, 26, 47, 28, 1, -46 },
  { 3898, 50, 50, 57, 3, -45 },
  { 4211, 41, 45, 41, 0, -45 },
  { 4442, 32, 45, 41, 6, -45 },
  { 4622, 34, 47, 40, 4, -46 },
  { 4822, 36, 45, 46, 6, -45 },
  { 5025, 25, 45, 35, 6, -45 },
  { 5166, 25, 45, 33, 6, -45 },
  { 5307, 37, 47, 46, 4, -46 },
  { 5525, 35, 45, 47, 6, -45 },
  { 5722, 18, 45, 22, 2, -45 },
  { 5824, 18, 57, 18, -5, -45 },
  { 5953, 34, 45, 40, 6, -45 },
  { 6145, 26, 45, 34, 6, -45 },
  { 6292, 46, 45, 58, 6, -45 },
  { 6551, 37, 45, 49, 6, -45 },
  { 6760, 42, 47, 49, 4, -46 },
  { 7007, 29, 45, 38, 6, -45 },
  { 7171, 42, 57, 49, 4, -46 },
  { 7471, 33, 45, 40, 6, -45 },
  { 7657, 29, 47, 35, 3, -46 },
  { 7828, 34, 45, 35, 1, -45 },
  { 8020, 35, 46, 47, 6, -45 },
  { 8222, 39, 45, 39, 0, -45 },
  { 8442, 59, 45, 59, 0, -45 },
  { 8774, 38, 45, 39, 0, -45 },
  { 8988, 37, 45, 37, 0, -45 },
  { 9197, 32, 45, 36, 2, -45 },
  { 9377, 14, 55, 21, 5, -45 },
  { 9474, 23, 45, 24, 1, -45 },
  { 9604, 14, 55, 21, 2, -45 },
  { 9701, 32, 28, 36, 2, -45 },
  { 9813, 27, 4, 27, 0, 6 },
  { 9827, 14, 10, 19, 3, -48 },
  { 9845, 28, 36, 36, 3, -35 },
  { 9971, 31, 49, 39, 5, -48 },
  { 10161, 26, 36, 31, 3, -35 },
  { 10278, 31, 49, 39, 3, -48 },
  { 10468, 30, 36, 36, 3, -35 },
  { 10603, 24, 48, 22, 1, -48 },
  { 10747, 31, 50, 39, 3, -35 },
  { 10941, 30, 48, 40, 5, -48 },
  { 11121, 7, 47, 17, 5, -47 },
  { 11163, 15, 62, 17, -3, -47 },
  { 11280, 30, 48, 35, 5, -48 },
  { 11460, 7, 48, 17, 5, -48 },
  { 11502, 50, 35, 60, 5, -35 },
  { 11721, 30, 35, 40, 5, -35 },
  { 11853, 32, 36, 39, 3, -35 },
  { 11997, 31, 50, 39, 5, -35 },
  { 12191, 31, 50, 39, 3, -35 },
  { 12385, 21, 35, 27, 5, -35 },
  { 12477, 25, 36, 31, 3, -35 },
  { 12590, 22, 43, 24, 1, -42 },
  { 12709, 29, 35, 40, 5, -34 },
  { 12836, 33, 34, 33, 0, -34 },
  { 12977, 49, 34, 51, 1, -34 },
  { 13186, 32, 34, 34, 1, -34 },
  { 13322, 33, 49, 33, 0, -34 },
  { 13525, 26, 34, 30, 2, -34 },
  { 13636, 20, 55, 24, 2, -45 },
  { 13774, 5, 63, 35, 15, -48 },
  { 13814, 21, 55, 24, 2, -45 },
  { 13959, 30, 9, 36, 3, -27 },
};

const GFXfont NotoSans_Medium63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium63pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_MEDIUM63PT7B_H_
