#ifndef _NOTOSANS_MEDIUM17PT7B_H_
#define _NOTOSANS_MEDIUM17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xD5, 0x0F, 0xDE, 0xF3, 0x90, 0x0C, 0x81, 0x30, 0x26, 0x3F,
  0xF7, 0xFE, 0x22, 0x04, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0xC8, 0x13, 0x00,
  0x10, 0x10, 0x7F, 0xD2, 0xD0, 0xF0, 0x78, 0x1E, 0x13, 0x13, 0xD7, 0xFE,
  0x10, 0x10, 0xF0, 0xC4, 0xC4, 0x26, 0x61, 0x12, 0x09, 0xB0, 0x6D, 0x79,
  0xDA, 0x40, 0x93, 0x0D, 0x98, 0xC4, 0xC4, 0x24, 0x61, 0xE0, 0x3E, 0x06,
  0x60, 0x62, 0x06, 0x60, 0x3C, 0x03, 0x80, 0x6C, 0x6C, 0x6C, 0xC3, 0xCC,
  0x18, 0xE7, 0xC7, 0xE7, 0xFF, 0x36, 0x4C, 0xCC, 0x88, 0x8C, 0xCC, 0x66,
  0x30, 0xC4, 0x66, 0x23, 0x33, 0x32, 0x66, 0x6C, 0x80, 0x18, 0x10, 0x91,
  0xFF, 0x18, 0x28, 0x6E, 0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0xFE, 0xF0, 0xF0, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x61, 0x84,
  0x30, 0x7C, 0x66, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x66,
  0x3C, 0x19, 0xFA, 0x90, 0x84, 0x21, 0x08, 0x42, 0x10, 0x7C, 0xC6, 0x02,
  0x02, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0xFC, 0xC6, 0x02,
  0x02, 0x06, 0x38, 0x1E, 0x03, 0x03, 0x03, 0xCE, 0xFC, 0x07, 0x03, 0x83,
  0xC3, 0x61, 0x31, 0x99, 0x8C, 0x86, 0xFF, 0x81, 0x80, 0xC0, 0x60, 0x7E,
  0x40, 0x40, 0xC0, 0xD0, 0xFE, 0x07, 0x03, 0x03, 0x03, 0xCE, 0xFC, 0x3E,
  0x70, 0x40, 0xC0, 0xDC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0xFF,
  0x03, 0x02, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x7E,
  0xC6, 0xC3, 0xC2, 0x66, 0x38, 0x6E, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x7C,
  0xE6, 0xC3, 0xC3, 0xC3, 0xC7, 0x7F, 0x33, 0x02, 0x06, 0x8C, 0x78, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xF8, 0x03, 0x0E, 0x38, 0xE0, 0xE0, 0x38, 0x0F,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0x3C, 0xE0,
  0x80, 0xFC, 0x8C, 0x18, 0x30, 0x63, 0x86, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x0F, 0xC1, 0xC3, 0x98, 0x04, 0x8F, 0xBC, 0xCC, 0xE4, 0x66, 0x63, 0x33,
  0x19, 0x89, 0xDE, 0x7B, 0x90, 0x00, 0xC0, 0x41, 0xFC, 0x00, 0x0E, 0x01,
  0xC0, 0x2C, 0x0D, 0x81, 0xB0, 0x63, 0x0C, 0x61, 0xFC, 0x7F, 0xCC, 0x19,
  0x01, 0xE0, 0x30, 0xFE, 0x87, 0x83, 0x83, 0x86, 0xFC, 0x86, 0x83, 0x83,
  0x83, 0xFF, 0xFC, 0x1F, 0xB8, 0xD8, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x1E, 0x63, 0xF0, 0xFE, 0x47, 0xA0, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xBF, 0xDF, 0x80, 0xFE, 0x08, 0x20, 0x83, 0xF8,
  0x20, 0x82, 0x0F, 0xFF, 0xFE, 0x08, 0x20, 0x83, 0xFF, 0xE0, 0x82, 0x08,
  0x20, 0x1F, 0xCE, 0x26, 0x03, 0x00, 0xC0, 0x30, 0xFC, 0x3F, 0x03, 0xC0,
  0xD8, 0x33, 0x8C, 0x7F, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFE, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x6F,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x33, 0xE0, 0x83, 0xC3, 0x23, 0x13,
  0x09, 0x85, 0x83, 0xE1, 0x38, 0x8C, 0x43, 0x20, 0xD0, 0x70, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xFF, 0xF0, 0xC0, 0x7E, 0x07,
  0xA0, 0xFB, 0x0F, 0xB0, 0xB9, 0x1B, 0x99, 0x39, 0x93, 0x8B, 0x38, 0xE3,
  0x8E, 0x38, 0x63, 0xC0, 0xF8, 0x3E, 0x0E, 0xC3, 0x98, 0xE6, 0x38, 0xCE,
  0x1B, 0x86, 0xE0, 0xF8, 0x3E, 0x07, 0x3F, 0x8E, 0x39, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x6C, 0x1D, 0xE7, 0x0F, 0xC0, 0xFC,
  0x8E, 0x86, 0x83, 0x82, 0x86, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F,
  0x8E, 0x39, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x6C,
  0x1D, 0xE7, 0x0F, 0xC0, 0x38, 0x03, 0x80, 0x38, 0xFC, 0x47, 0x20, 0xD0,
  0x68, 0x64, 0x73, 0xE1, 0x18, 0x8C, 0x43, 0x20, 0xD0, 0x70, 0x7E, 0xE2,
  0xC0, 0xC0, 0xE0, 0x78, 0x1E, 0x06, 0x03, 0x03, 0xCE, 0xFC, 0xFF, 0x86,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0xF9,
  0xCF, 0xC0, 0xC0, 0xD0, 0x36, 0x0D, 0x86, 0x21, 0x8C, 0x43, 0x30, 0x4C,
  0x1A, 0x07, 0x80, 0xE0, 0x30, 0xC1, 0x83, 0x41, 0x82, 0x63, 0xC6, 0x63,
  0xC6, 0x62, 0x46, 0x26, 0x64, 0x36, 0x6C, 0x36, 0x6C, 0x34, 0x2C, 0x1C,
  0x38, 0x1C, 0x38, 0x18, 0x18, 0xE0, 0xD8, 0x63, 0x30, 0x6C, 0x1E, 0x03,
  0x00, 0xE0, 0x78, 0x33, 0x0C, 0x66, 0x1B, 0x03, 0xC0, 0xD8, 0x66, 0x10,
  0xCC, 0x32, 0x07, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xFF, 0xFF, 0xFC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0x06, 0x08, 0x30, 0xC1,
  0x06, 0x18, 0x20, 0xC3, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0,
  0x18, 0x38, 0x2C, 0x64, 0x46, 0x42, 0xC3, 0x81, 0xFE, 0xC6, 0x30, 0x7E,
  0x8C, 0x08, 0x77, 0xF8, 0x71, 0xE7, 0x7A, 0xC0, 0x60, 0x30, 0x18, 0x0D,
  0xE7, 0x1B, 0x05, 0x83, 0xC1, 0xE0, 0xF8, 0xDE, 0xED, 0xE0, 0x7E, 0xC7,
  0x06, 0x0C, 0x18, 0x30, 0x33, 0x3E, 0x03, 0x03, 0x03, 0x03, 0x7F, 0xE7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7D, 0x7E, 0x66, 0xC3, 0xFF, 0xFF,
  0xC0, 0xC0, 0x62, 0x3E, 0x1E, 0x78, 0xC1, 0x8F, 0xC6, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x00, 0x7D, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67,
  0x7F, 0x03, 0x03, 0x67, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0xDF, 0xE3, 0xC3,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x70, 0xFF, 0xFF, 0xC0, 0x13, 0x00,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3B, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7,
  0xC6, 0xCC, 0xD8, 0xF8, 0xEC, 0xCE, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0,
  0xDE, 0xFB, 0x8E, 0x7C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30,
  0xF0, 0xC3, 0xC3, 0x0C, 0xDF, 0xE3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0x7E, 0x31, 0xB0, 0xD8, 0x2C, 0x1E, 0x0B, 0x0C, 0xCE, 0x3E, 0x00,
  0xDE, 0x71, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x8D, 0xEE, 0xDE, 0x60, 0x30,
  0x18, 0x0C, 0x00, 0x7D, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7F,
  0x03, 0x03, 0x03, 0x03, 0xDF, 0xCE, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x7D,
  0x8B, 0x07, 0x03, 0xC1, 0x81, 0xC6, 0xF8, 0x20, 0x8F, 0xC8, 0x20, 0x82,
  0x08, 0x20, 0xD3, 0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67,
  0x7D, 0xC1, 0xA1, 0x98, 0xCC, 0x63, 0x61, 0xB0, 0x50, 0x38, 0x1C, 0x00,
  0xC3, 0x0D, 0x1C, 0x66, 0x79, 0x99, 0x66, 0x6C, 0xB0, 0xB2, 0xC3, 0x8F,
  0x0E, 0x38, 0x18, 0x60, 0xE3, 0x99, 0x8D, 0x83, 0x81, 0xC0, 0xF0, 0xD8,
  0xC6, 0xE1, 0x80, 0xC1, 0xB1, 0x98, 0xCC, 0x63, 0x61, 0xB0, 0x50, 0x38,
  0x1C, 0x0C, 0x06, 0x06, 0x0F, 0x00, 0xFC, 0x31, 0x86, 0x31, 0x86, 0x30,
  0xFC, 0x1C, 0x63, 0x0C, 0x30, 0xC7, 0x38, 0x30, 0xC3, 0x0C, 0x10, 0x70,
  0xC0, 0xFF, 0xFF, 0x80, 0xC3, 0x18, 0xC6, 0x30, 0xC3, 0x63, 0x18, 0xC6,
  0x72, 0x00, 0xF1, 0x9F,
};

const GFXglyph NotoSans_Medium17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 5, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 11, 12, 11, 0, -12 },
  { 24, 8, 14, 10, 1, -13 },
  { 38, 13, 12, 14, 1, -12 },
  { 58, 12, 12, 13, 1, -12 },
  { 76, 2, 4, 4, 1, -12 },
  { 77, 4, 15, 5, 1, -12 },
  { 85, 4, 15, 5, 1, -12 },
  { 93, 8, 8, 9, 1, -13 },
  { 101, 8, 8, 10, 1, -10 },
  { 109, 2, 4, 5, 1, -2 },
  { 110, 4, 1, 5, 1, -5 },
  { 111, 2, 2, 5, 1, -2 },
  { 112, 6, 12, 7, 0, -12 },
  { 121, 8, 12, 10, 1, -12 },
  { 133, 5, 12, 10, 1, -12 },
  { 141, 8, 12, 10, 1, -12 },
  { 153, 8, 12, 10, 1, -12 },
  { 165, 9, 12, 10, 0, -12 },
  { 179, 8, 12, 10, 1, -12 },
  { 191, 8, 12, 10, 1, -12 },
  { 203, 8, 12, 10, 1, -12 },
  { 215, 8, 12, 10, 1, -12 },
  { 227, 8, 12, 10, 1, -12 },
  { 239, 2, 9, 5, 1, -9 },
  { 242, 2, 11, 5, 1, -9 },
  { 245, 8, 8, 10, 1, -10 },
  { 253, 8, 4, 10, 1, -8 },
  { 257, 8, 8, 10, 1, -10 },
  { 265, 7, 12, 8, 0, -12 },
  { 276, 13, 13, 15, 1, -12 },
  { 298, 11, 12, 11, 0, -12 },
  { 315, 8, 12, 11, 2, -12 },
  { 327, 9, 12, 11, 1, -12 },
  { 341, 9, 12, 12, 2, -12 },
  { 355, 6, 12, 9, 2, -12 },
  { 364, 6, 12, 9, 2, -12 },
  { 373, 10, 12, 12, 1, -12 },
  { 388, 9, 12, 13, 2, -12 },
  { 402, 4, 12, 6, 1, -12 },
  { 408, 4, 15, 5, -1, -12 },
  { 416, 9, 12, 11, 2, -12 },
  { 430, 7, 12, 9, 2, -12 },
  { 441, 12, 12, 16, 2, -12 },
  { 459, 10, 12, 13, 2, -12 },
  { 474, 11, 12, 13, 1, -12 },
  { 491, 8, 12, 10, 2, -12 },
  { 503, 11, 15, 13, 1, -12 },
  { 524, 9, 12, 11, 2, -12 },
  { 538, 8, 12, 9, 1, -12 },
  { 550, 9, 12, 10, 0, -12 },
  { 564, 9, 12, 13, 2, -12 },
  { 578, 10, 12, 10, 0, -12 },
  { 593, 16, 12, 16, 0, -12 },
  { 617, 10, 12, 10, 0, -12 },
  { 632, 10, 12, 10, 0, -12 },
  { 647, 8, 12, 10, 1, -12 },
  { 659, 4, 15, 6, 1, -12 },
  { 667, 6, 12, 7, 0, -12 },
  { 676, 4, 15, 6, 0, -12 },
  { 684, 8, 8, 10, 1, -12 },
  { 692, 7, 1, 7, 0, 2 },
  { 693, 4, 3, 5, 1, -13 },
  { 695, 7, 9, 10, 1, -9 },
  { 703, 9, 13, 11, 1, -13 },
  { 718, 7, 9, 8, 1, -9 },
  { 726, 8, 13, 11, 1, -13 },
  { 739, 8, 9, 10, 1, -9 },
  { 748, 7, 13, 6, 0, -13 },
  { 760, 8, 13, 11, 1, -9 },
  { 773, 8, 13, 11, 1, -13 },
  { 786, 2, 13, 5, 1, -13 },
  { 790, 4, 17, 5, -1, -13 },
  { 799, 8, 13, 10, 1, -13 },
  { 812, 2, 13, 5, 1, -13 },
  { 816, 14, 9, 16, 1, -9 },
  { 832, 8, 9, 11, 1, -9 },
  { 841, 9, 9, 10, 1, -9 },
  { 852, 9, 13, 11, 1, -9 },
  { 867, 8, 13, 11, 1, -9 },
  { 880, 6, 9, 7, 1, -9 },
  { 887, 7, 9, 8, 1, -9 },
  { 895, 6, 11, 7, 0, -11 },
  { 904, 8, 9, 11, 1, -9 },
  { 913, 9, 9, 9, 0, -9 },
  { 924, 14, 9, 14, 0, -9 },
  { 940, 9, 9, 9, 0, -9 },
  { 951, 9, 13, 9, 0, -9 },
  { 966, 6, 9, 8, 1, -9 },
  { 973, 6, 15, 7, 0, -12 },
  { 985, 1, 17, 9, 4, -13 },
  { 988, 5, 15, 7, 1, -12 },
  { 998, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_Medium17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium17pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_MEDIUM17PT7B_H_
