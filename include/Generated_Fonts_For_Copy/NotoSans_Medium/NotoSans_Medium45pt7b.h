#ifndef _NOTOSANS_MEDIUM45PT7B_H_
#define _NOTOSANS_MEDIUM45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x07, 0xBF, 0xFF, 0xFF,
  0xDF, 0x30, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0x3C, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0xE0, 0xCF, 0x8E, 0x00, 0xF0, 0xE0, 0x0F,
  0x0E, 0x00, 0xF8, 0xE0, 0x0F, 0x8E, 0x00, 0xFE, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x0E, 0x3F, 0x00, 0xE1, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x0E,
  0x0F, 0x80, 0xE1, 0xFF, 0x8E, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3C, 0x03, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x78, 0x78,
  0x03, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0x0F, 0x03, 0x80, 0x78, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x07, 0x80, 0x0F,
  0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0xF0, 0x00, 0xF0, 0x3C, 0x3C, 0x00,
  0x3C, 0x0F, 0x1E, 0x0E, 0x0F, 0x03, 0x8F, 0x9F, 0xE1, 0xE1, 0xE3, 0xCF,
  0xFC, 0x78, 0x79, 0xE3, 0xFF, 0x9F, 0xFC, 0x79, 0xE1, 0xE3, 0xFF, 0x3C,
  0x78, 0x3C, 0x7F, 0x8F, 0x1E, 0x0F, 0x03, 0x07, 0x87, 0x83, 0xC0, 0x01,
  0xE3, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0x7C, 0x3C, 0x0F, 0x00,
  0x1E, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x3C,
  0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x00, 0xF1,
  0xE0, 0x0F, 0x00, 0x3F, 0xF8, 0x07, 0x80, 0x07, 0xFC, 0x03, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xF0,
  0xFE, 0xFC, 0x03, 0xE1, 0xF8, 0xFC, 0x07, 0x87, 0xE0, 0xFC, 0x1F, 0x0F,
  0x80, 0xFC, 0x3E, 0x3F, 0x00, 0xFC, 0xF8, 0x7C, 0x00, 0xFF, 0xF0, 0xF8,
  0x00, 0xFF, 0xC1, 0xF0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xE0,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7B, 0xDE, 0x73, 0x9C, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80,
  0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0x81, 0xC0, 0xDF,
  0x8E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x01, 0xF1, 0xE0, 0x0F,
  0x8F, 0x80, 0xF8, 0x3E, 0x0F, 0xC1, 0xE0, 0x0C, 0x04, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3E, 0x7D, 0xF3, 0xE7,
  0xCF, 0x1E, 0x7C, 0xF1, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7B, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xCF, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8,
  0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xEF, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0x03, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x0F,
  0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0x1F, 0x70, 0xF9,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x60, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0xFF, 0xDF, 0xE1, 0xF0, 0x0F, 0xC3, 0x00, 0x1F, 0x08, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF9, 0xFE, 0x3C, 0x01, 0xF8,
  0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7D, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x03,
  0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x30, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xEC, 0x00, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF8, 0x20, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE3, 0xFE, 0x0F, 0x9F, 0xFC,
  0x3E, 0xFF, 0xF8, 0xFF, 0xCF, 0xF3, 0xFC, 0x07, 0xEF, 0xC0, 0x0F, 0xBF,
  0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3F, 0x01, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF1, 0xF8, 0x07, 0xC7, 0xC0,
  0x0F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x0F, 0x80, 0x7C, 0x3F, 0x03, 0xE0, 0x7F, 0x3F, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFD, 0xFE, 0x0F, 0xC1,
  0xFC, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0x7C,
  0x01, 0xF9, 0xFE, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xCF, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x3C, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x7F, 0x7E, 0x03, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xF7, 0x87, 0xFF, 0x9E, 0x07, 0xF8, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xE7, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3B, 0xFF, 0xFF, 0xFD,
  0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0x7C, 0xC0, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFB, 0xFC, 0x60, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x10, 0x03, 0xC1, 0xE0, 0x3F, 0xFC, 0x1E, 0x3C, 0x07, 0xFF,
  0xC1, 0xE3, 0xC0, 0xFF, 0xFC, 0x0F, 0x78, 0x1F, 0x03, 0xC0, 0xF7, 0x81,
  0xE0, 0x3C, 0x0F, 0x78, 0x3C, 0x03, 0xC0, 0xF7, 0x83, 0xC0, 0x3C, 0x0F,
  0x70, 0x3C, 0x03, 0xC0, 0xFF, 0x07, 0x80, 0x3C, 0x0F, 0xF0, 0x78, 0x03,
  0xC0, 0xFF, 0x07, 0x80, 0x3C, 0x0F, 0xF0, 0x3C, 0x03, 0xC0, 0xE7, 0x03,
  0xC0, 0x7C, 0x1E, 0x70, 0x3C, 0x07, 0xC1, 0xE7, 0x83, 0xF1, 0xFE, 0x3C,
  0x78, 0x1F, 0xFC, 0xFF, 0x87, 0x80, 0xFF, 0x8F, 0xF0, 0x3C, 0x03, 0xF0,
  0x3E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0x80, 0x3F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xCF, 0x80, 0x1F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF1, 0xF0, 0x07, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xEF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x0E, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x06, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0xF8, 0x03, 0xFE, 0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x03, 0xF3,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00,
  0x1F, 0xCF, 0x80, 0x0F, 0xE3, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xF8, 0x00, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF3, 0xF0, 0x00,
  0x7C, 0xFE, 0x00, 0x1F, 0x1F, 0xE0, 0x07, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x9F, 0xEF, 0xFC, 0xFF, 0xCF,
  0xF0, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC,
  0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xBC, 0x00, 0x07, 0xBF, 0xDF, 0x00, 0x03, 0xDF,
  0xF7, 0x80, 0x03, 0xDF, 0xFB, 0xC0, 0x01, 0xEF, 0xFD, 0xF0, 0x00, 0xF7,
  0xFE, 0x78, 0x00, 0xF3, 0xFF, 0x3C, 0x00, 0x79, 0xFF, 0x9F, 0x00, 0x7C,
  0xFF, 0xC7, 0x80, 0x3C, 0x7F, 0xE3, 0xC0, 0x1E, 0x3F, 0xF1, 0xF0, 0x1F,
  0x1F, 0xF8, 0x78, 0x0F, 0x0F, 0xFC, 0x3E, 0x07, 0x87, 0xFE, 0x1F, 0x07,
  0x83, 0xFF, 0x07, 0x83, 0xC1, 0xFF, 0x83, 0xE3, 0xE0, 0xFF, 0xC0, 0xF1,
  0xE0, 0x7F, 0xE0, 0x78, 0xF0, 0x3F, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F,
  0x78, 0x0F, 0xFC, 0x07, 0xBC, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xE0,
  0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFD, 0xF0, 0x00, 0xFF, 0xBF, 0x00, 0x1F, 0xF3, 0xF0,
  0x03, 0xFF, 0x3E, 0x00, 0x7F, 0xE7, 0xE0, 0x0F, 0xFC, 0x7C, 0x01, 0xFF,
  0x87, 0xC0, 0x3F, 0xF0, 0xFC, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0xC1, 0xF8,
  0x1F, 0xF8, 0x1F, 0x83, 0xFF, 0x01, 0xF0, 0x7F, 0xE0, 0x3F, 0x0F, 0xFC,
  0x03, 0xE1, 0xFF, 0x80, 0x3E, 0x3F, 0xF0, 0x07, 0xE7, 0xFE, 0x00, 0x7C,
  0xFF, 0xC0, 0x0F, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7F,
  0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xDF, 0x03, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0,
  0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x00,
  0x71, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3D, 0x00, 0x03, 0xEF, 0x00,
  0x3F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0x00, 0xF9,
  0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0x80, 0x0F, 0x8F, 0x80,
  0x1F, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xFF,
  0x00, 0x7C, 0x1F, 0x00, 0xF3, 0xC0, 0x1F, 0x07, 0xC0, 0x3C, 0xF0, 0x07,
  0x81, 0xF0, 0x0F, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0x0F,
  0x81, 0xE1, 0xE0, 0x3E, 0x03, 0xE0, 0x78, 0x78, 0x0F, 0x00, 0xF8, 0x3E,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0xF0,
  0x7C, 0x01, 0xF0, 0xF0, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x0F, 0x8F, 0x80,
  0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x78, 0xF8, 0x00, 0xF9,
  0xE0, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00,
  0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00,
  0x7C, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0x07, 0xF0,
  0x80, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0x1F, 0x7E, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xF7, 0xE3, 0xFF, 0x7F, 0xFE, 0xF3, 0xFF, 0xCF, 0x1F,
  0xF0, 0x70, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0x1F, 0xF0, 0x3C, 0xFF, 0xF0, 0xF7,
  0xFF, 0xE3, 0xFE, 0x3F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0x7E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xF8, 0x0F,
  0xCF, 0xFF, 0xFE, 0x3D, 0xFF, 0xF8, 0xF3, 0xFF, 0xC3, 0x87, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0x7C,
  0x7E, 0x00, 0x9F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x04, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xC1, 0xF0, 0x7F, 0xE7, 0xC3, 0xFF, 0xCF, 0x1F, 0xFF, 0xBC,
  0xFF, 0x1F, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xEF, 0x0F, 0xFF, 0x3C, 0x0F, 0xF0, 0xF0, 0x00, 0x38,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x83, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x79, 0xF0,
  0x01, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x10, 0x7F, 0xDF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFE, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF8, 0xF0, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x3F, 0x87, 0xFC, 0xFC, 0x07,
  0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x80, 0x3F, 0x3F, 0x01, 0xFC, 0xFF, 0x3F, 0xF1, 0xFF, 0xFB, 0xC3,
  0xFF, 0xCF, 0x03, 0xFE, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF2, 0x00, 0x1F, 0x8F, 0x80, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0xE0, 0x3C, 0x7F, 0xE1, 0xE7, 0xFF, 0x8F, 0x7F, 0xFE, 0x7F, 0xC3, 0xFB,
  0xF8, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xC0, 0x7B, 0xFF, 0xDF, 0x78, 0x00, 0x00, 0x01,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x03, 0xC0, 0xFC, 0x1F, 0x81, 0xF0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF4,
  0x7E, 0xFF, 0xDF, 0xF3, 0xFC, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xFD,
  0xE0, 0x0F, 0xCF, 0x00, 0xFC, 0x78, 0x0F, 0xC3, 0xC0, 0xFC, 0x1E, 0x0F,
  0xC0, 0xF0, 0xFC, 0x07, 0x8F, 0xC0, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F,
  0x7E, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFC, 0xFC,
  0x07, 0x83, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7E, 0x0F, 0x01, 0xF8, 0x78,
  0x07, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xFC, 0xF0, 0x03, 0xF7, 0x80, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x78, 0x1E, 0x3F,
  0xF0, 0x7F, 0xE3, 0xCF, 0xFF, 0x1F, 0xFE, 0x7B, 0xFF, 0xF7, 0xFF, 0xEF,
  0xF0, 0xFF, 0xF1, 0xFD, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E,
  0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0xFF,
  0x80, 0x0F, 0x80, 0x1F, 0xF0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x3E, 0x00,
  0x7F, 0xC0, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x0F, 0x80, 0x1F, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x8F,
  0xFC, 0x3C, 0xFF, 0xF9, 0xEF, 0xFF, 0xCF, 0xF8, 0x7F, 0x7F, 0x00, 0xFB,
  0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFC, 0x3F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBC, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xF0, 0x0F, 0x83, 0xFC, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x3C, 0x03, 0xC7, 0xFE, 0x0F, 0x3F, 0xFC, 0x3D, 0xFF,
  0xF8, 0xFF, 0x8F, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBF, 0x00, 0x7C, 0xFE, 0x03, 0xF3,
  0xFF, 0xFF, 0x8F, 0x7F, 0xFE, 0x3C, 0xFF, 0xF0, 0xF1, 0xFF, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0xF0, 0xFF,
  0xF3, 0xC7, 0xFF, 0xEF, 0x3F, 0x87, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x0F,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x3F,
  0x3F, 0x01, 0xFC, 0xFF, 0x3F, 0xF1, 0xFF, 0xFB, 0xC3, 0xFF, 0xDF, 0x03,
  0xFC, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xC3, 0xFF,
  0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7C, 0x07, 0x3E, 0x00, 0x4F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xFC,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0xB8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF7,
  0xC0, 0x1F, 0xDF, 0x80, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFD, 0xF1, 0xFF,
  0xE7, 0xC3, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xC7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x80,
  0x1E, 0x7C, 0x01, 0xFC, 0x03, 0xE3, 0xC0, 0x3F, 0xC0, 0x3E, 0x3E, 0x03,
  0xFC, 0x03, 0xC3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x03, 0xDE, 0x07, 0xC1,
  0xE0, 0x79, 0xE0, 0x7C, 0x1F, 0x07, 0x9E, 0x07, 0x81, 0xF0, 0x79, 0xF0,
  0xF8, 0x1F, 0x0F, 0x8F, 0x0F, 0x80, 0xF0, 0xF0, 0xF0, 0xF8, 0x0F, 0x8F,
  0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x79, 0xF0, 0x07, 0x9E, 0x07, 0x9F, 0x00,
  0x79, 0xE0, 0x79, 0xE0, 0x07, 0xDE, 0x07, 0xDE, 0x00, 0x7D, 0xC0, 0x3D,
  0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xF8, 0x07,
  0xE0, 0xF8, 0x0F, 0x81, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xF8,
  0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81,
  0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0x01, 0xFC,
  0x1F, 0xF0, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFA, 0x00, 0x3F,
  0x80,
};

const GFXglyph NotoSans_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 33, 12, 3, -32 },
  { 26, 13, 11, 19, 3, -32 },
  { 44, 27, 32, 29, 1, -32 },
  { 152, 20, 37, 26, 3, -34 },
  { 245, 34, 33, 38, 2, -33 },
  { 386, 31, 33, 33, 2, -33 },
  { 514, 5, 11, 11, 3, -32 },
  { 521, 11, 39, 14, 2, -32 },
  { 575, 11, 39, 14, 1, -32 },
  { 629, 21, 20, 25, 2, -34 },
  { 682, 21, 22, 26, 2, -27 },
  { 740, 7, 11, 12, 2, -5 },
  { 750, 11, 4, 14, 2, -14 },
  { 756, 6, 7, 12, 3, -6 },
  { 762, 17, 32, 17, 0, -32 },
  { 830, 22, 33, 26, 2, -33 },
  { 921, 13, 32, 26, 4, -32 },
  { 973, 22, 33, 26, 2, -33 },
  { 1064, 21, 33, 26, 2, -33 },
  { 1151, 24, 32, 26, 1, -32 },
  { 1247, 20, 32, 26, 3, -32 },
  { 1327, 22, 33, 26, 2, -33 },
  { 1418, 22, 32, 26, 2, -32 },
  { 1506, 22, 33, 26, 2, -33 },
  { 1597, 22, 33, 26, 2, -33 },
  { 1688, 6, 26, 12, 3, -25 },
  { 1708, 8, 31, 12, 1, -25 },
  { 1739, 22, 23, 26, 2, -28 },
  { 1803, 21, 12, 26, 2, -22 },
  { 1835, 22, 23, 26, 2, -28 },
  { 1899, 19, 34, 20, 0, -33 },
  { 1980, 36, 36, 40, 2, -32 },
  { 2142, 29, 32, 29, 0, -32 },
  { 2258, 23, 32, 29, 4, -32 },
  { 2350, 24, 33, 29, 3, -33 },
  { 2449, 26, 32, 33, 4, -32 },
  { 2553, 18, 32, 25, 4, -32 },
  { 2625, 18, 32, 24, 4, -32 },
  { 2697, 26, 33, 33, 3, -33 },
  { 2805, 25, 32, 34, 4, -32 },
  { 2905, 12, 32, 16, 2, -32 },
  { 2953, 12, 41, 13, -3, -32 },
  { 3015, 24, 32, 28, 4, -32 },
  { 3111, 19, 32, 24, 4, -32 },
  { 3187, 33, 32, 41, 4, -32 },
  { 3319, 27, 32, 35, 4, -32 },
  { 3427, 30, 33, 35, 3, -33 },
  { 3551, 21, 32, 27, 4, -32 },
  { 3635, 30, 41, 35, 3, -33 },
  { 3789, 24, 32, 28, 4, -32 },
  { 3885, 21, 33, 25, 2, -33 },
  { 3972, 24, 32, 25, 1, -32 },
  { 4068, 25, 32, 33, 4, -32 },
  { 4168, 28, 32, 28, 0, -32 },
  { 4280, 42, 32, 42, 0, -32 },
  { 4448, 27, 32, 28, 0, -32 },
  { 4556, 26, 32, 26, 0, -32 },
  { 4660, 22, 32, 26, 2, -32 },
  { 4748, 11, 39, 15, 3, -32 },
  { 4802, 17, 32, 17, 0, -32 },
  { 4870, 10, 39, 15, 1, -32 },
  { 4919, 22, 20, 26, 2, -32 },
  { 4974, 20, 3, 20, 0, 4 },
  { 4982, 10, 7, 14, 2, -34 },
  { 4991, 20, 25, 26, 2, -25 },
  { 5054, 22, 34, 28, 4, -34 },
  { 5148, 19, 25, 22, 2, -25 },
  { 5208, 22, 34, 28, 2, -34 },
  { 5302, 22, 25, 26, 2, -25 },
  { 5371, 17, 34, 16, 1, -34 },
  { 5444, 22, 36, 28, 2, -25 },
  { 5543, 21, 34, 28, 4, -34 },
  { 5633, 6, 33, 12, 3, -33 },
  { 5658, 11, 44, 12, -2, -33 },
  { 5719, 21, 34, 25, 4, -34 },
  { 5809, 4, 34, 12, 4, -34 },
  { 5826, 35, 25, 43, 4, -25 },
  { 5936, 21, 25, 28, 4, -25 },
  { 6002, 23, 25, 28, 2, -25 },
  { 6074, 22, 36, 28, 4, -25 },
  { 6173, 22, 36, 28, 2, -25 },
  { 6272, 14, 25, 19, 4, -25 },
  { 6316, 18, 25, 22, 2, -25 },
  { 6373, 15, 30, 17, 1, -30 },
  { 6430, 22, 24, 28, 3, -24 },
  { 6496, 24, 24, 24, 0, -24 },
  { 6568, 36, 24, 36, 0, -24 },
  { 6676, 23, 24, 24, 1, -24 },
  { 6745, 24, 35, 24, 0, -24 },
  { 6850, 18, 24, 21, 2, -24 },
  { 6904, 15, 39, 17, 1, -32 },
  { 6978, 3, 45, 25, 11, -34 },
  { 6995, 14, 39, 17, 2, -32 },
  { 7064, 22, 6, 26, 2, -19 },
};

const GFXfont NotoSans_Medium45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium45pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_MEDIUM45PT7B_H_
