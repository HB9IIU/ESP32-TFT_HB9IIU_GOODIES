#ifndef _NOTOSANS_MEDIUM37PT7B_H_
#define _NOTOSANS_MEDIUM37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x8E, 0x38, 0xC0, 0x00, 0x00, 0xC7, 0xBF, 0x7D, 0xE1, 0x00, 0xF1, 0xF7,
  0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE0,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF0, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0x81, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0x7D, 0xE3, 0x82, 0xF1, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1F,
  0x38, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xEF, 0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x1C, 0x7C, 0x0E, 0x3F, 0xC7,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x02, 0x03, 0xF8, 0x01, 0xC0, 0x7F,
  0xC0, 0x3C, 0x0F, 0x1C, 0x03, 0x80, 0xE1, 0xE0, 0x78, 0x0E, 0x0E, 0x07,
  0x00, 0xE0, 0xE0, 0xE0, 0x0E, 0x0E, 0x0E, 0x00, 0xE0, 0xE1, 0xC0, 0x0E,
  0x0E, 0x3C, 0x00, 0xE0, 0xE3, 0x80, 0x0E, 0x0E, 0x79, 0xF8, 0xE1, 0xE7,
  0x3F, 0xCF, 0x1C, 0xF3, 0xFE, 0x7F, 0xCE, 0x70, 0xE3, 0xF9, 0xC7, 0x0E,
  0x0E, 0x1C, 0x70, 0x70, 0x03, 0x87, 0x07, 0x00, 0x78, 0xF0, 0x70, 0x07,
  0x0F, 0x07, 0x00, 0xF0, 0x70, 0x70, 0x0E, 0x07, 0x07, 0x01, 0xE0, 0x70,
  0xF0, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0x3D, 0xE0, 0x38, 0x03, 0xFC, 0x07,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xE7, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x78, 0xFF,
  0xC0, 0x7C, 0xF9, 0xF0, 0x3C, 0x78, 0x7C, 0x1E, 0x7C, 0x1F, 0x1E, 0x3C,
  0x07, 0xEF, 0x1E, 0x01, 0xFF, 0x0F, 0x00, 0x7F, 0x87, 0x80, 0x0F, 0x83,
  0xE0, 0x0F, 0xE0, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xBE, 0x1F, 0xFF, 0x0F,
  0x83, 0xFE, 0x03, 0xE0, 0xF7, 0x77, 0x77, 0x77, 0x70, 0x07, 0x87, 0x83,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x07, 0x07, 0x83, 0xC3, 0xC1, 0xC1, 0xE1, 0xE0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x18, 0x30, 0x67, 0xEC,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0x1E, 0xE0,
  0x0F, 0x3C, 0x03, 0xCF, 0x81, 0xE1, 0xF0, 0x38, 0x70, 0x02, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x3C, 0xF3, 0xCE, 0x79, 0xE7, 0x1C, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x31, 0xEF, 0xDF, 0x78, 0x40, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFD, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xBC,
  0x00, 0xFF, 0x00, 0x3B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x9E, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x7C,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x9F,
  0xF7, 0xDF, 0xF3, 0xDC, 0x79, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x0F, 0xFC, 0x1F,
  0xFF, 0x9F, 0xFF, 0xC7, 0x01, 0xF3, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xE7, 0x01, 0xF2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3E, 0xFF, 0xFE, 0x7F, 0xFE,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x03, 0xCF,
  0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0xF0, 0x38, 0x1E,
  0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x1E, 0x01, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x8F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7B, 0x80, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0x8C, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x0F, 0x03, 0xCF, 0xF0, 0xFF, 0xFF, 0x3F, 0xCF, 0xCF,
  0xC0, 0xFB, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x78, 0xF8, 0x7C, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xC7, 0xE7, 0x80, 0xF3, 0xC0, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F,
  0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x8F, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7C, 0x7C, 0x78, 0x1F, 0x78, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0x7F, 0xFF,
  0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xEF, 0xC7, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFB, 0xC0, 0xFD, 0xFF,
  0xEE, 0x7F, 0xEF, 0x1F, 0xE7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF0, 0x00, 0x79, 0xFF, 0xDE, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x7B, 0xF7, 0xDE, 0x10, 0x3C, 0xF9, 0xF9, 0xE1, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x79, 0xF3,
  0xC7, 0x8E, 0x1C, 0x78, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x60, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x02, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC7, 0x01,
  0xFF, 0x0E, 0x78, 0x3F, 0xF8, 0x3B, 0x83, 0xE1, 0xC1, 0xDC, 0x3C, 0x0E,
  0x0F, 0xE1, 0xC0, 0x70, 0x7E, 0x0E, 0x03, 0x83, 0xF0, 0xF0, 0x1C, 0x1F,
  0x87, 0x80, 0xE0, 0xFC, 0x3C, 0x07, 0x07, 0xE1, 0xE0, 0x78, 0x3F, 0x07,
  0x03, 0xC3, 0xB8, 0x3C, 0x3E, 0x1D, 0xE0, 0xFF, 0xBF, 0xC7, 0x07, 0xF8,
  0xFC, 0x38, 0x0F, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x78,
  0x07, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0xFB, 0xC0, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x3C, 0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x80, 0x63, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x06, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x03,
  0xF8, 0xF0, 0x03, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3,
  0xC0, 0x1F, 0x8F, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xC0, 0x18,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xF0,
  0x03, 0xC7, 0xF0, 0x0F, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC3, 0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE3, 0xFF, 0xFB, 0xFC, 0xFE, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x03, 0xE1,
  0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x78, 0x03,
  0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x78, 0x07,
  0x8F, 0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1F, 0x0F,
  0x01, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xDE,
  0x00, 0x7C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1D, 0xFB, 0x80,
  0x07, 0x7E, 0xF0, 0x03, 0xDF, 0xBC, 0x00, 0xE7, 0xE7, 0x00, 0x79, 0xF9,
  0xE0, 0x1E, 0x7E, 0x78, 0x07, 0x1F, 0x8E, 0x03, 0xC7, 0xE3, 0xC0, 0xE1,
  0xF8, 0x70, 0x38, 0x7E, 0x1E, 0x1E, 0x1F, 0x87, 0x87, 0x07, 0xE0, 0xE1,
  0xC1, 0xF8, 0x3C, 0xF0, 0x7E, 0x0F, 0x38, 0x1F, 0x81, 0xDE, 0x07, 0xE0,
  0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xE0, 0x3E, 0x01, 0xF8, 0x07, 0x80, 0x70, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF7, 0x80, 0x3F, 0xBE,
  0x01, 0xFC, 0xF0, 0x0F, 0xE7, 0xC0, 0x7F, 0x1F, 0x03, 0xF8, 0x78, 0x1F,
  0xC3, 0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0x3C, 0x3F, 0x81, 0xF0, 0xFC, 0x07,
  0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xCF, 0xC0, 0x1F, 0x7E,
  0x00, 0x7B, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01,
  0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xC0, 0x7E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x7F, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01,
  0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x01, 0xF8, 0xF0, 0x07,
  0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x7C, 0xF0, 0x07, 0x8F, 0x01, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3C,
  0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF,
  0xFF, 0xE7, 0x80, 0x67, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x3D, 0xE0, 0x7E, 0xFF, 0xFE, 0x7F, 0xFE,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x3E, 0x00, 0xF8, 0xFC, 0x0F, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xDE, 0x00, 0x7C, 0x00, 0xF7, 0x80, 0x3F, 0x00, 0x3D, 0xE0, 0x0F, 0xC0,
  0x1E, 0x3C, 0x03, 0xF8, 0x07, 0x8F, 0x00, 0xEE, 0x01, 0xE3, 0xC0, 0x7B,
  0x80, 0x78, 0xF0, 0x1E, 0xF0, 0x3C, 0x1E, 0x07, 0x3C, 0x0F, 0x07, 0x81,
  0xC7, 0x03, 0xC1, 0xE0, 0xF1, 0xC0, 0xF0, 0x78, 0x3C, 0x78, 0x78, 0x0F,
  0x0E, 0x1E, 0x1E, 0x03, 0xC7, 0x83, 0x87, 0x80, 0xF1, 0xE0, 0xF1, 0xE0,
  0x3C, 0x70, 0x3C, 0xF0, 0x07, 0x9C, 0x07, 0x3C, 0x01, 0xEF, 0x01, 0xCF,
  0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x0E, 0xE0, 0x1E, 0xE0, 0x03, 0xB8, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xEF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x1E,
  0x00, 0x78, 0x7C, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xE0, 0x78, 0x07, 0xC3,
  0xE0, 0x0F, 0x0F, 0x00, 0x3E, 0x78, 0x00, 0x7B, 0xE0, 0x00, 0xF0, 0xF8,
  0x00, 0x7D, 0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80,
  0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x0E, 0x1C,
  0x01, 0xC1, 0xC0, 0x78, 0x38, 0x0E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x07,
  0x0E, 0x00, 0xE3, 0x80, 0x0E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0xF8, 0x3F,
  0xFE, 0x3F, 0xFE, 0x18, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xCF, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xF7, 0x7F, 0xE7, 0x3F,
  0xC7, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF3, 0xF8, 0x3D, 0xFF, 0x8F,
  0xFF, 0xF3, 0xF0, 0x7E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0x1E, 0xFC, 0x1F, 0xBF, 0xFF, 0xCE,
  0x7F, 0xE3, 0x8F, 0xF0, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xF1, 0xF0, 0x67,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x06,
  0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x0F, 0xF3, 0xC7, 0xFE, 0xF3, 0xFF, 0xFD, 0xF8, 0x3F, 0x78, 0x07, 0xDE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x1F,
  0x7C, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xBC, 0x3F, 0xC7, 0x07, 0xF8, 0x0F,
  0xFF, 0x0F, 0xFF, 0xC7, 0x81, 0xE7, 0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0x1F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0xF3, 0xFF, 0xCF, 0xFF, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xF1, 0xC7, 0xFE, 0xF3, 0xFF, 0xFD,
  0xF8, 0x3F, 0x78, 0x07, 0xDE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x1F, 0x7C, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xBC,
  0x3F, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x40,
  0x0F, 0x9F, 0x8F, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF1, 0xFC, 0x7B, 0xFF, 0x3F, 0xFF, 0xDF, 0xC1,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x2F,
  0xFF, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xCF, 0xFF, 0xDF, 0xCF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E, 0x0F, 0x8F, 0x0F, 0x87, 0x8F,
  0x83, 0xCF, 0x81, 0xE7, 0x80, 0xF7, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xBC, 0x0F, 0x9F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x3E,
  0x78, 0x0F, 0xBC, 0x03, 0xDE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F,
  0xC7, 0x3F, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xF8, 0x3F, 0xC1, 0xFF,
  0x80, 0xFC, 0x07, 0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x1E, 0x01, 0xFE, 0x00,
  0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x3C, 0x03, 0xFC, 0x01, 0xE0,
  0x1F, 0xE0, 0x0F, 0x00, 0xFF, 0x00, 0x78, 0x07, 0xF8, 0x03, 0xC0, 0x3F,
  0xC0, 0x1E, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x80,
  0x3C, 0x03, 0xFC, 0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0x00, 0xF0, 0xE3, 0xFC,
  0x73, 0xFF, 0xBF, 0xFF, 0xDF, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x3E, 0x0F, 0x87, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xE3, 0xFC, 0x3D, 0xFF, 0x8F, 0xFF, 0xF3,
  0xF0, 0x7E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xFC, 0x1F, 0xBF, 0xFF, 0xCF, 0x7F, 0xE3,
  0xCF, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xF1, 0xC7, 0xFE, 0xF3, 0xFF, 0xFD, 0xF0, 0x3F, 0x78, 0x07, 0xDE, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x7C,
  0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xBC, 0x3F, 0xCF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0xE1, 0xFE, 0x7F, 0xE7, 0xFF, 0xF9, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xBC, 0x06, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xC0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xBF, 0xFD,
  0xCF, 0xFC, 0xE3, 0xFC, 0x70, 0xF0, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03,
  0xE7, 0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x07,
  0x1E, 0x00, 0x79, 0xC0, 0x07, 0xBC, 0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7B, 0xC0,
  0x7E, 0x03, 0xDE, 0x03, 0xF0, 0x1E, 0xF0, 0x1F, 0x80, 0xE3, 0xC1, 0xFC,
  0x0F, 0x1E, 0x0E, 0xF0, 0x78, 0xF0, 0x73, 0x83, 0xC7, 0x83, 0x9C, 0x1C,
  0x1E, 0x3C, 0xF1, 0xE0, 0xF1, 0xC7, 0x8F, 0x07, 0x8E, 0x1C, 0x78, 0x1C,
  0xF0, 0xE7, 0x80, 0xF7, 0x87, 0xBC, 0x07, 0xB8, 0x1D, 0xE0, 0x3D, 0xC0,
  0xEE, 0x00, 0xEE, 0x07, 0x70, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xCF, 0x00,
  0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x78, 0x03, 0xEF,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF0, 0xF0, 0x3C, 0x0F,
  0x0F, 0x81, 0xF1, 0xE0, 0x1F, 0x78, 0x01, 0xF0, 0xF0, 0x01, 0xF7, 0x80,
  0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0x71, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xC0, 0x03, 0xBC, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x08, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x3F, 0x07, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xFE, 0x0F, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x7F, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xF0,
  0x0F, 0x03, 0xF0, 0x7E, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3E, 0x0F, 0xE0, 0xFC, 0x0E,
  0x00, 0x1C, 0x00, 0xBF, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xF4,
  0x00, 0x40,
};

const GFXglyph NotoSans_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 27, 10, 2, -26 },
  { 22, 12, 9, 16, 2, -26 },
  { 36, 22, 26, 24, 1, -26 },
  { 108, 17, 30, 21, 2, -28 },
  { 172, 28, 27, 32, 2, -27 },
  { 267, 25, 27, 27, 2, -27 },
  { 352, 4, 9, 9, 2, -26 },
  { 357, 9, 32, 12, 1, -26 },
  { 393, 9, 32, 12, 1, -26 },
  { 429, 18, 17, 20, 1, -28 },
  { 468, 17, 18, 21, 2, -22 },
  { 507, 6, 9, 10, 1, -4 },
  { 514, 10, 4, 12, 1, -12 },
  { 519, 6, 6, 10, 2, -5 },
  { 524, 14, 26, 14, 0, -26 },
  { 570, 18, 27, 21, 2, -27 },
  { 631, 11, 26, 21, 3, -26 },
  { 667, 17, 27, 21, 2, -27 },
  { 725, 17, 27, 21, 2, -27 },
  { 783, 19, 27, 21, 1, -27 },
  { 848, 17, 26, 21, 2, -26 },
  { 904, 18, 27, 21, 2, -27 },
  { 965, 19, 26, 21, 1, -26 },
  { 1027, 17, 27, 21, 2, -27 },
  { 1085, 17, 27, 21, 2, -27 },
  { 1143, 6, 21, 10, 2, -20 },
  { 1159, 7, 25, 10, 1, -20 },
  { 1181, 17, 19, 21, 2, -23 },
  { 1222, 17, 10, 21, 2, -18 },
  { 1244, 17, 19, 21, 2, -23 },
  { 1285, 16, 28, 17, 0, -27 },
  { 1341, 29, 29, 33, 2, -26 },
  { 1447, 24, 27, 24, 0, -27 },
  { 1528, 19, 26, 24, 3, -26 },
  { 1590, 20, 27, 24, 2, -27 },
  { 1658, 22, 26, 27, 3, -26 },
  { 1730, 14, 26, 21, 4, -26 },
  { 1776, 14, 26, 20, 4, -26 },
  { 1822, 22, 27, 27, 2, -27 },
  { 1897, 20, 26, 28, 4, -26 },
  { 1962, 11, 26, 13, 1, -26 },
  { 1998, 10, 33, 11, -3, -26 },
  { 2040, 19, 26, 23, 4, -26 },
  { 2102, 16, 26, 20, 3, -26 },
  { 2154, 26, 26, 34, 4, -26 },
  { 2239, 21, 26, 29, 4, -26 },
  { 2308, 25, 27, 29, 2, -27 },
  { 2393, 18, 26, 23, 3, -26 },
  { 2452, 25, 33, 29, 2, -27 },
  { 2556, 20, 26, 23, 3, -26 },
  { 2621, 17, 27, 20, 2, -27 },
  { 2679, 20, 26, 21, 0, -26 },
  { 2744, 21, 26, 27, 3, -26 },
  { 2813, 23, 26, 23, 0, -26 },
  { 2888, 34, 26, 35, 0, -26 },
  { 2999, 22, 26, 23, 0, -26 },
  { 3071, 22, 26, 22, 0, -26 },
  { 3143, 19, 26, 21, 1, -26 },
  { 3205, 8, 32, 12, 3, -26 },
  { 3237, 14, 26, 14, 0, -26 },
  { 3283, 8, 32, 12, 1, -26 },
  { 3315, 19, 17, 21, 1, -27 },
  { 3356, 16, 3, 16, 0, 3 },
  { 3362, 9, 6, 11, 1, -28 },
  { 3369, 16, 20, 21, 2, -20 },
  { 3409, 18, 28, 23, 3, -28 },
  { 3472, 15, 20, 18, 2, -20 },
  { 3510, 18, 28, 23, 2, -28 },
  { 3573, 17, 20, 21, 2, -20 },
  { 3616, 14, 28, 13, 1, -28 },
  { 3665, 18, 29, 23, 2, -20 },
  { 3731, 17, 28, 23, 3, -28 },
  { 3791, 4, 28, 10, 3, -28 },
  { 3805, 9, 37, 10, -2, -28 },
  { 3847, 17, 28, 21, 3, -28 },
  { 3907, 4, 28, 10, 3, -28 },
  { 3921, 29, 20, 35, 3, -20 },
  { 3994, 17, 20, 23, 3, -20 },
  { 4037, 19, 20, 23, 2, -20 },
  { 4085, 18, 29, 23, 3, -20 },
  { 4151, 18, 29, 23, 2, -20 },
  { 4217, 12, 20, 16, 3, -20 },
  { 4247, 14, 20, 18, 2, -20 },
  { 4282, 12, 24, 14, 1, -24 },
  { 4318, 17, 20, 23, 3, -20 },
  { 4361, 20, 20, 20, 0, -20 },
  { 4411, 29, 20, 30, 0, -20 },
  { 4484, 19, 20, 20, 1, -20 },
  { 4532, 20, 29, 20, 0, -20 },
  { 4605, 15, 20, 18, 1, -20 },
  { 4643, 12, 32, 14, 1, -26 },
  { 4691, 3, 37, 20, 9, -28 },
  { 4705, 12, 32, 14, 1, -26 },
  { 4753, 17, 6, 21, 2, -16 },
};

const GFXfont NotoSans_Medium37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium37pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_MEDIUM37PT7B_H_
