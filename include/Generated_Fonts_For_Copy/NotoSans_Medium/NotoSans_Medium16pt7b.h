#ifndef _NOTOSANS_MEDIUM16PT7B_H_
#define _NOTOSANS_MEDIUM16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF5, 0x3C, 0xDE, 0xF7, 0x30, 0x09, 0x82, 0x41, 0x91, 0xFF,
  0x13, 0x04, 0x8F, 0xFB, 0xFE, 0x22, 0x09, 0x82, 0x40, 0x10, 0x7B, 0xFE,
  0x8D, 0x1E, 0x0F, 0x0B, 0x13, 0x2F, 0xF0, 0x81, 0x00, 0x60, 0x4F, 0x08,
  0x91, 0x89, 0x90, 0x9B, 0x09, 0x2E, 0xF5, 0xB2, 0xD3, 0x09, 0x11, 0x93,
  0x11, 0xB3, 0x0E, 0x18, 0x0F, 0x81, 0x98, 0x33, 0x06, 0xC0, 0x70, 0x1E,
  0x36, 0x66, 0xC7, 0x98, 0x73, 0x9E, 0x3E, 0x70, 0xFE, 0x74, 0xCC, 0x88,
  0x88, 0x8C, 0xC4, 0x63, 0xE2, 0x33, 0x11, 0x11, 0x13, 0x32, 0x6C, 0x30,
  0x23, 0x5F, 0xF3, 0x8D, 0x93, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x08, 0xFA, 0xF0, 0xF0, 0x0C, 0x21, 0x86, 0x10, 0xC2, 0x18, 0x61, 0x0C,
  0x00, 0x10, 0xFB, 0x1E, 0x3C, 0x30, 0x60, 0xC1, 0xC3, 0x8D, 0xBB, 0xE0,
  0x3B, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x11, 0xFA, 0x18, 0x30, 0x60,
  0x83, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x31, 0xFA, 0x18, 0x30, 0x6F, 0x9F,
  0x03, 0x02, 0x0E, 0x3F, 0xE0, 0x06, 0x07, 0x02, 0x82, 0x43, 0x23, 0x11,
  0x09, 0xFF, 0x02, 0x01, 0x00, 0x80, 0x7F, 0x83, 0x06, 0x0F, 0xC9, 0xC1,
  0x81, 0x07, 0x1F, 0xF0, 0x0C, 0x7D, 0x86, 0x0C, 0x17, 0xB1, 0xE1, 0xC3,
  0x85, 0x99, 0xE0, 0xFE, 0x0C, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x61,
  0x80, 0x18, 0xFB, 0x1E, 0x3C, 0x6F, 0x9F, 0x63, 0x83, 0x07, 0x1B, 0xE0,
  0x10, 0xFB, 0x1C, 0x18, 0x38, 0xFF, 0xBD, 0x06, 0x0C, 0x33, 0xC0, 0xF0,
  0x03, 0xC0, 0x6C, 0x00, 0x03, 0x6B, 0x00, 0x02, 0x0C, 0x63, 0x0C, 0x0E,
  0x07, 0x81, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x81, 0x80, 0xC0, 0x60, 0x63,
  0xBC, 0x40, 0x31, 0xFA, 0x18, 0x30, 0x41, 0x86, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x1F, 0xC1, 0x83, 0x10, 0x0D, 0x9F, 0x29, 0x89, 0x4C, 0x4E, 0x46,
  0x53, 0x32, 0xCE, 0xE2, 0x00, 0x18, 0x10, 0x7F, 0x80, 0x0C, 0x03, 0x81,
  0xA0, 0x6C, 0x33, 0x0C, 0x43, 0xF9, 0xFE, 0x60, 0xD0, 0x3C, 0x0C, 0xFF,
  0x61, 0xB0, 0xD8, 0x6F, 0xE7, 0xFB, 0x0D, 0x83, 0xC1, 0xE3, 0xBF, 0x80,
  0x0E, 0x1F, 0xD8, 0x58, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x1C,
  0x47, 0xE0, 0xFF, 0x30, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x06,
  0xC1, 0xB3, 0xCF, 0xE0, 0xFE, 0x08, 0x20, 0xFF, 0xF8, 0x20, 0x82, 0x0F,
  0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x00, 0x06, 0x1F,
  0xDC, 0x2C, 0x0C, 0x06, 0x03, 0x1F, 0x81, 0xC0, 0xB0, 0x5C, 0x63, 0xF0,
  0x81, 0x81, 0x81, 0x81, 0xFF, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0xF6,
  0x66, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xBE,
  0x87, 0x8C, 0x98, 0x98, 0xB0, 0xF0, 0x98, 0x8C, 0x8C, 0x86, 0x83, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xC0, 0xFC, 0x17,
  0x82, 0xD0, 0xDB, 0x17, 0x22, 0xE4, 0xDC, 0xD3, 0x8E, 0x71, 0xCE, 0x31,
  0x80, 0xC1, 0xF0, 0xF8, 0x76, 0x39, 0x9C, 0xCE, 0x37, 0x0F, 0x87, 0xC1,
  0xE0, 0xE0, 0x0C, 0x07, 0xF1, 0x87, 0x60, 0x6C, 0x05, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xCC, 0x19, 0xC6, 0x1F, 0x80, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0x0C, 0x07, 0xF1, 0x87, 0x60, 0x6C,
  0x05, 0x80, 0xF0, 0x1E, 0x02, 0xC0, 0xCC, 0x19, 0xC6, 0x1F, 0x80, 0x30,
  0x03, 0x00, 0x30, 0xFE, 0x61, 0xB0, 0xD8, 0x6C, 0x37, 0xF3, 0x31, 0x8C,
  0xC6, 0x61, 0xB0, 0x60, 0x18, 0xFF, 0x0E, 0x0C, 0x0E, 0x0F, 0x07, 0x06,
  0x0E, 0x3F, 0xE0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0x41, 0xB9, 0xCF, 0xC0, 0xC0, 0xD0, 0x66, 0x19, 0x84, 0x23, 0x0C,
  0xC3, 0x20, 0x58, 0x1E, 0x07, 0x00, 0xC0, 0xC3, 0x86, 0x87, 0x09, 0x8A,
  0x33, 0x14, 0x66, 0x6C, 0xC4, 0xD9, 0x0D, 0x16, 0x1E, 0x3C, 0x3C, 0x78,
  0x30, 0x60, 0x60, 0xC0, 0xE1, 0x88, 0xC3, 0x30, 0x78, 0x1C, 0x03, 0x01,
  0xE0, 0xC8, 0x23, 0x18, 0x6C, 0x1C, 0xC1, 0xB1, 0x88, 0xC6, 0xC1, 0x60,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xFE, 0x06, 0x0C, 0x0C, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0xC0, 0xFF, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xFF, 0xC1, 0x06, 0x08, 0x30, 0xC1, 0x06, 0x18, 0x20, 0xC0, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFF, 0x10, 0x30, 0x28, 0x28, 0x44, 0x44, 0xC2,
  0x83, 0xFE, 0xCC, 0x38, 0xFC, 0x18, 0x37, 0xF8, 0xE1, 0xE7, 0xFA, 0xC0,
  0xC0, 0xC0, 0xDC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6, 0xDE, 0x3D,
  0xFC, 0x30, 0xC3, 0x0C, 0x19, 0x7C, 0x03, 0x03, 0x03, 0x3B, 0x7F, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7B, 0x38, 0xFF, 0x1E, 0x1F, 0xF8, 0x30,
  0x31, 0x3E, 0x3C, 0xC2, 0x1F, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3B,
  0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7B, 0x03, 0x02, 0xFE, 0x7C,
  0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xF3, 0xFF, 0xFF, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC0,
  0xC0, 0xC0, 0xC3, 0xC6, 0xCC, 0xD8, 0xF0, 0xF8, 0xCC, 0xC6, 0xC7, 0xFF,
  0xFF, 0xFF, 0xDC, 0x67, 0xFF, 0xF0, 0xC7, 0x86, 0x3C, 0x21, 0xE1, 0x0F,
  0x08, 0x78, 0x43, 0xC2, 0x18, 0xDC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0xDC,
  0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6, 0xDE, 0xC0, 0xC0, 0xC0, 0xC0,
  0x3B, 0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7B, 0x03, 0x03, 0x03,
  0x03, 0xDF, 0xEE, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x7B, 0xF8, 0x30, 0x78,
  0x70, 0xE3, 0xF8, 0x20, 0x87, 0xFF, 0x61, 0x86, 0x18, 0x60, 0xC3, 0xC0,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7B, 0xC1, 0xC3, 0x63,
  0x62, 0x26, 0x34, 0x3C, 0x1C, 0x18, 0xC6, 0x1E, 0x38, 0x91, 0x4C, 0xCA,
  0x66, 0xDB, 0x14, 0xD0, 0xA3, 0x87, 0x1C, 0x38, 0xC0, 0xC3, 0x63, 0x36,
  0x1C, 0x18, 0x1C, 0x36, 0x62, 0xC3, 0xC1, 0xC3, 0x63, 0x62, 0x26, 0x36,
  0x34, 0x1C, 0x18, 0x18, 0x18, 0xF0, 0xE0, 0xFF, 0xF1, 0x86, 0x31, 0x84,
  0x30, 0xFC, 0x1C, 0xC3, 0x0C, 0x30, 0xCC, 0x0C, 0x30, 0xC3, 0x0C, 0x1C,
  0x10, 0xFF, 0xFF, 0xC3, 0x18, 0xC6, 0x30, 0x6C, 0x63, 0x18, 0xCC, 0x40,
  0x63, 0xFC,
};

const GFXglyph NotoSans_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 10, 11, 10, 0, -11 },
  { 21, 7, 13, 9, 1, -12 },
  { 33, 12, 12, 14, 1, -12 },
  { 51, 11, 12, 12, 1, -12 },
  { 68, 2, 4, 4, 1, -11 },
  { 69, 4, 14, 5, 1, -11 },
  { 76, 4, 14, 5, 0, -11 },
  { 83, 7, 7, 9, 1, -12 },
  { 90, 7, 8, 9, 1, -10 },
  { 97, 2, 4, 4, 1, -2 },
  { 98, 4, 1, 5, 1, -5 },
  { 99, 2, 2, 4, 1, -2 },
  { 100, 6, 11, 6, 0, -11 },
  { 109, 7, 12, 9, 1, -12 },
  { 120, 5, 11, 9, 1, -11 },
  { 127, 7, 12, 9, 1, -12 },
  { 138, 7, 12, 9, 1, -12 },
  { 149, 9, 11, 9, 0, -11 },
  { 162, 7, 11, 9, 1, -11 },
  { 172, 7, 12, 9, 1, -12 },
  { 183, 7, 11, 9, 1, -11 },
  { 193, 7, 12, 9, 1, -12 },
  { 204, 7, 12, 9, 1, -12 },
  { 215, 2, 9, 4, 1, -9 },
  { 218, 3, 11, 4, 0, -9 },
  { 223, 7, 8, 9, 1, -10 },
  { 230, 7, 5, 9, 1, -8 },
  { 235, 7, 8, 9, 1, -10 },
  { 242, 7, 12, 7, 0, -12 },
  { 253, 13, 12, 14, 1, -11 },
  { 273, 10, 11, 10, 0, -11 },
  { 287, 9, 11, 10, 1, -11 },
  { 300, 9, 12, 10, 1, -12 },
  { 314, 10, 11, 12, 1, -11 },
  { 328, 6, 11, 9, 2, -11 },
  { 337, 6, 11, 8, 2, -11 },
  { 346, 9, 12, 12, 1, -12 },
  { 360, 8, 11, 12, 2, -11 },
  { 371, 4, 11, 6, 1, -11 },
  { 377, 4, 14, 5, -1, -11 },
  { 384, 8, 11, 10, 2, -11 },
  { 395, 7, 11, 9, 1, -11 },
  { 405, 11, 11, 15, 2, -11 },
  { 421, 9, 11, 12, 2, -11 },
  { 434, 11, 12, 13, 1, -12 },
  { 451, 8, 11, 10, 1, -11 },
  { 462, 11, 15, 13, 1, -12 },
  { 483, 9, 11, 10, 1, -11 },
  { 496, 7, 12, 9, 1, -12 },
  { 507, 9, 11, 9, 0, -11 },
  { 520, 9, 11, 12, 1, -11 },
  { 533, 10, 11, 10, 0, -11 },
  { 547, 15, 11, 15, 0, -11 },
  { 568, 10, 11, 10, 0, -11 },
  { 582, 9, 11, 9, 0, -11 },
  { 595, 8, 11, 9, 1, -11 },
  { 606, 4, 14, 5, 1, -11 },
  { 613, 6, 11, 6, 0, -11 },
  { 622, 4, 14, 5, 0, -11 },
  { 629, 8, 8, 9, 1, -12 },
  { 637, 7, 1, 7, 0, 1 },
  { 638, 3, 2, 5, 1, -12 },
  { 639, 7, 9, 9, 1, -9 },
  { 647, 8, 12, 10, 1, -12 },
  { 659, 6, 9, 8, 1, -9 },
  { 666, 8, 12, 10, 1, -12 },
  { 678, 7, 9, 9, 1, -9 },
  { 686, 6, 12, 6, 0, -12 },
  { 695, 8, 13, 10, 1, -9 },
  { 708, 8, 12, 10, 1, -12 },
  { 720, 2, 12, 4, 1, -12 },
  { 723, 4, 16, 4, -1, -12 },
  { 731, 8, 12, 9, 1, -12 },
  { 743, 2, 12, 4, 1, -12 },
  { 746, 13, 9, 15, 1, -9 },
  { 761, 8, 9, 10, 1, -9 },
  { 770, 8, 9, 10, 1, -9 },
  { 779, 8, 13, 10, 1, -9 },
  { 792, 8, 13, 10, 1, -9 },
  { 805, 6, 9, 7, 1, -9 },
  { 812, 6, 9, 8, 1, -9 },
  { 819, 6, 11, 6, 0, -11 },
  { 828, 8, 9, 10, 1, -9 },
  { 837, 8, 9, 8, 0, -9 },
  { 846, 13, 9, 13, 0, -9 },
  { 861, 8, 9, 9, 0, -9 },
  { 870, 8, 13, 8, 0, -9 },
  { 883, 6, 9, 8, 1, -9 },
  { 890, 6, 14, 6, 0, -11 },
  { 901, 1, 16, 9, 4, -12 },
  { 903, 5, 14, 6, 1, -11 },
  { 912, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_Medium16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium16pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_MEDIUM16PT7B_H_
