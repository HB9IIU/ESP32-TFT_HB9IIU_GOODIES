#ifndef _NOTOSANS_MEDIUM44PT7B_H_
#define _NOTOSANS_MEDIUM44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0xCF, 0xFF, 0xFF, 0xFF,
  0x8C, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x3C, 0x00,
  0x1C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x70, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x03, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x78, 0x1C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x3C,
  0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xEE, 0x7C, 0x7C, 0x70, 0x23,
  0xC3, 0x80, 0x3E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0xC7, 0x00, 0x3F, 0x38,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0x3F, 0x00, 0x38, 0x7C, 0x01, 0xC3,
  0xE0, 0x0E, 0x1F, 0x00, 0x70, 0xFA, 0x03, 0x87, 0xDE, 0x1C, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x3C, 0x01,
  0xF7, 0xC0, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0,
  0x0F, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xE0, 0x3C, 0x00, 0xF0, 0x38, 0x1E,
  0x00, 0x3C, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x83, 0xC0, 0x03, 0xC0, 0xE1,
  0xE0, 0x00, 0xF0, 0x38, 0x78, 0x00, 0x3C, 0x1E, 0x3C, 0x7F, 0x0F, 0x07,
  0x8F, 0x3F, 0xE1, 0xE1, 0xE7, 0x9F, 0xFC, 0x7D, 0xF1, 0xE7, 0x8F, 0x0F,
  0xFC, 0xF1, 0xE1, 0xE1, 0xFE, 0x38, 0xF0, 0x78, 0x1E, 0x1E, 0x3C, 0x0E,
  0x00, 0x0F, 0x0F, 0x03, 0x80, 0x03, 0xC3, 0xC0, 0xF0, 0x01, 0xE0, 0xF0,
  0x3C, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x03, 0x80, 0x0F, 0x03,
  0xC0, 0xE0, 0x07, 0x80, 0xF0, 0x78, 0x01, 0xC0, 0x1C, 0x1E, 0x00, 0xF0,
  0x07, 0x8F, 0x80, 0x78, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x3F, 0xE0, 0x0F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x07,
  0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x7F, 0xF8, 0x07, 0xC3, 0xF3,
  0xF0, 0x1F, 0x1F, 0x87, 0xF0, 0x7C, 0x7C, 0x07, 0xE3, 0xE3, 0xE0, 0x0F,
  0xCF, 0x8F, 0x80, 0x1F, 0xFC, 0x3E, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x7F,
  0x83, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0xFC, 0x1F, 0x81,
  0xFF, 0xC0, 0x3F, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0x07, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0xF8, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x08, 0x0F, 0x01, 0xF0, 0xF0, 0xFF, 0xEF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0x7C,
  0x06, 0x07, 0x00, 0x20, 0x40, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x1E, 0x78, 0xF1, 0xE3, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xFF, 0xFF, 0xFF, 0xE3, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC1, 0xFD, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x3F, 0x07, 0xF1,
  0xFF, 0x3F, 0xF7, 0xEF, 0xFC, 0xFF, 0x8F, 0x60, 0xF4, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xE0, 0xFE, 0x3C, 0x01, 0xF0, 0xC0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xE0, 0x7E, 0x18, 0x01, 0xF8, 0x80, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7D, 0x80, 0x07, 0xEF, 0xF7, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0,
  0xF8, 0x07, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F,
  0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xC7, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE8, 0x00, 0x3E, 0xC0, 0x0F, 0xCF, 0xEF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x7C, 0xFF, 0xC3, 0xEF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7E, 0x07, 0xE1, 0xFD, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C,
  0x07, 0xC1, 0xF8, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0xFC, 0x07, 0xE7, 0xC0,
  0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xEF, 0x80, 0x7F,
  0x7F, 0x0F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xBE, 0x1F, 0xF9, 0xF0, 0x0C,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x83, 0x0F, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3F, 0xFF, 0xFF, 0xFE,
  0x30, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xC0, 0xFC, 0x40, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x3F, 0xE0, 0x78, 0xF0, 0x1F, 0xFF, 0x07, 0x1E, 0x07, 0xFF,
  0xE0, 0xF7, 0x81, 0xF0, 0x3C, 0x1E, 0xF0, 0x7C, 0x07, 0x83, 0xDE, 0x0F,
  0x00, 0xE0, 0x7B, 0x81, 0xE0, 0x1C, 0x07, 0x70, 0x78, 0x03, 0x80, 0xFE,
  0x0F, 0x00, 0x70, 0x3F, 0xC1, 0xE0, 0x1E, 0x07, 0xF8, 0x3C, 0x03, 0xC0,
  0xFF, 0x07, 0x80, 0x78, 0x1F, 0xE0, 0xF0, 0x0F, 0x03, 0x9C, 0x0F, 0x03,
  0xE0, 0xF3, 0x81, 0xF0, 0xFE, 0x3C, 0x78, 0x1F, 0xFD, 0xFF, 0x8F, 0x01,
  0xFF, 0x1F, 0xE0, 0xF0, 0x1F, 0x81, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x07, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x7E,
  0x1F, 0xC0, 0x04, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x04, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF8, 0x01,
  0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x7F,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xF8, 0x1F, 0x07, 0xF0, 0x00, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF8,
  0x00, 0x7C, 0x7F, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xED, 0xFE,
  0xFF, 0xCF, 0xF8, 0xFF, 0x07, 0x00, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x7C, 0x00,
  0xFC, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0,
  0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF7, 0x80, 0x01,
  0xEF, 0xF7, 0x80, 0x01, 0xEF, 0xF7, 0xC0, 0x01, 0xEF, 0xF3, 0xC0, 0x03,
  0xCF, 0xF3, 0xE0, 0x03, 0xCF, 0xF1, 0xE0, 0x07, 0x8F, 0xF1, 0xE0, 0x07,
  0x8F, 0xF1, 0xF0, 0x07, 0x8F, 0xF0, 0xF0, 0x0F, 0x0F, 0xF0, 0xF0, 0x0F,
  0x0F, 0xF0, 0xF8, 0x0F, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E,
  0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0x3C,
  0x0F, 0xF0, 0x3E, 0x78, 0x0F, 0xF0, 0x1E, 0x78, 0x0F, 0xF0, 0x1F, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0,
  0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0x7C, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xF3, 0xF0, 0x03, 0xFC, 0x7C,
  0x00, 0xFF, 0x1F, 0x80, 0x3F, 0xC3, 0xE0, 0x0F, 0xF0, 0x7C, 0x03, 0xFC,
  0x1F, 0x80, 0xFF, 0x03, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x1F, 0x83,
  0xFC, 0x03, 0xE0, 0xFF, 0x00, 0xFC, 0x3F, 0xC0, 0x1F, 0x0F, 0xF0, 0x03,
  0xE3, 0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x1F, 0x3F, 0xC0, 0x03, 0xEF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x3F, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x87, 0xE7, 0xE0, 0x04, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x3F, 0x87, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xF0, 0x01, 0xF1, 0xF0, 0x03,
  0xBC, 0x00, 0xF0, 0xF8, 0x03, 0xDE, 0x00, 0xF8, 0x7C, 0x01, 0xEF, 0x00,
  0x7C, 0x1E, 0x00, 0xF7, 0xC0, 0x3E, 0x0F, 0x80, 0xF9, 0xE0, 0x1E, 0x07,
  0xC0, 0x78, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x78, 0x0F, 0x80, 0xF0, 0x1E,
  0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x0F, 0x03, 0xC0, 0x3E, 0x0F, 0x07, 0x83,
  0xE0, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x03,
  0xE3, 0xC0, 0x78, 0x78, 0x01, 0xF1, 0xE0, 0x3C, 0x7C, 0x00, 0x78, 0xF0,
  0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0x1F, 0x78, 0x03, 0xCF,
  0x00, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x01,
  0xEE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0x80, 0x01,
  0xE7, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x38,
  0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0xF7, 0xC0, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0C, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xF7, 0xFF,
  0xEF, 0x3F, 0xFC, 0xF1, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0xF0, 0x3C, 0xFF, 0xE1, 0xEF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x3E,
  0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xE0, 0x3F, 0x7F, 0xEF,
  0xF3, 0xDF, 0xFF, 0x1E, 0x7F, 0xF0, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x01, 0x8F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF,
  0x1F, 0xFF, 0xFC, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x00, 0x3F, 0x7C,
  0x00, 0xFD, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x01, 0xFC, 0xFF,
  0x3F, 0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0xCF, 0x03, 0xFC, 0x3C, 0x01, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0x1F,
  0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x21, 0xFE, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x20,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF8, 0x3C, 0x1F, 0xF8, 0xF1, 0xFF, 0xF7, 0xC7, 0xFF,
  0xFF, 0x3F, 0x03, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0x80, 0x7F, 0x3F, 0xCF, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFF, 0xF7, 0xC0, 0xFF, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x80, 0x07,
  0xE3, 0xF0, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x02, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x0F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC, 0xFF, 0xFF, 0xEF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0x31, 0xEF, 0xFF, 0x78, 0xC0, 0x00, 0x01, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x78, 0x01, 0x80, 0x78, 0x1F, 0x83, 0xF0, 0x3C, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF4, 0x7E, 0xFF, 0x9F,
  0xF3, 0xFC, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x07, 0xEF, 0x00, 0xFC, 0xF0, 0x1F,
  0x8F, 0x03, 0xF0, 0xF0, 0x7E, 0x0F, 0x0F, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F,
  0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xCF, 0x80, 0xF8, 0x7C, 0x0F, 0x07, 0xE0, 0xF0, 0x3E, 0x0F,
  0x01, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E,
  0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xFE, 0x01, 0xFC,
  0x3C, 0xFF, 0xE1, 0xFF, 0xCF, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFE, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x01, 0xE0, 0x03, 0xFC, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0,
  0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0,
  0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07,
  0x80, 0x0F, 0xE0, 0xFF, 0x0F, 0x3F, 0xFC, 0xF7, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x3C, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1,
  0xFC, 0x7F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xE0,
  0xFE, 0x07, 0x9F, 0xFC, 0x3D, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xE0, 0x7E,
  0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBF, 0x00,
  0x7D, 0xFC, 0x07, 0xCF, 0xFD, 0xFE, 0x7B, 0xFF, 0xE3, 0xCF, 0xFE, 0x1E,
  0x3F, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x3C, 0x1F, 0xF8,
  0xF1, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x3F, 0x03, 0xFD, 0xF8, 0x03, 0xF7,
  0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x7F, 0x3F, 0xC7, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF, 0xE7, 0xC0, 0xFF,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xE0, 0xFF, 0x87, 0xFF,
  0x3F, 0xFD, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEF, 0x80,
  0x37, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x8C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x7E, 0xFC, 0x07, 0xF7, 0xF9, 0xFF, 0x9F, 0xFF, 0xBC, 0x7F, 0xF9,
  0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x0F,
  0x00, 0x78, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C,
  0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x01, 0xE3,
  0xC0, 0x03, 0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x00, 0x7D, 0xF0, 0x07, 0xE0,
  0x0F, 0x3E, 0x01, 0xFC, 0x03, 0xE3, 0xC0, 0x3F, 0xC0, 0x7C, 0x7C, 0x07,
  0x78, 0x0F, 0x8F, 0x81, 0xEF, 0x01, 0xE1, 0xF0, 0x3D, 0xE0, 0x7C, 0x1E,
  0x07, 0x9E, 0x0F, 0x83, 0xE1, 0xF3, 0xC1, 0xE0, 0x7C, 0x3C, 0x78, 0x3C,
  0x07, 0x87, 0x8F, 0x8F, 0x80, 0xF0, 0xF0, 0xF1, 0xF0, 0x1F, 0x3C, 0x1E,
  0x3C, 0x03, 0xE7, 0x83, 0xC7, 0x80, 0x3C, 0xF0, 0x3D, 0xF0, 0x07, 0x9C,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0x0F, 0xF0, 0x1E, 0xF0, 0x01,
  0xFE, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFD,
  0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x1F, 0x03, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x01, 0xF8,
  0x7C, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F,
  0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x3C,
  0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xF3,
  0xE0, 0x01, 0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x09, 0xFF, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x0F, 0xFA, 0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 32, 12, 3, -31 },
  { 25, 13, 11, 19, 3, -31 },
  { 43, 26, 31, 28, 1, -31 },
  { 144, 21, 36, 25, 2, -33 },
  { 239, 34, 32, 37, 2, -32 },
  { 375, 30, 32, 32, 2, -32 },
  { 495, 5, 11, 10, 3, -31 },
  { 502, 10, 38, 14, 2, -31 },
  { 550, 11, 38, 14, 1, -31 },
  { 603, 20, 20, 24, 2, -33 },
  { 653, 21, 21, 25, 2, -26 },
  { 709, 7, 11, 12, 2, -5 },
  { 719, 11, 4, 14, 2, -14 },
  { 725, 6, 7, 12, 3, -6 },
  { 731, 17, 32, 17, 0, -32 },
  { 799, 21, 32, 25, 2, -32 },
  { 883, 12, 31, 25, 4, -31 },
  { 930, 21, 32, 25, 2, -32 },
  { 1014, 21, 32, 25, 2, -32 },
  { 1098, 23, 32, 25, 1, -32 },
  { 1190, 20, 31, 25, 3, -31 },
  { 1268, 21, 32, 25, 2, -32 },
  { 1352, 21, 31, 25, 2, -31 },
  { 1434, 21, 32, 25, 2, -32 },
  { 1518, 21, 32, 25, 2, -32 },
  { 1602, 6, 25, 12, 3, -24 },
  { 1621, 8, 30, 12, 1, -24 },
  { 1651, 21, 22, 25, 2, -27 },
  { 1709, 21, 13, 25, 2, -22 },
  { 1744, 21, 22, 25, 2, -27 },
  { 1802, 19, 33, 20, 0, -32 },
  { 1881, 35, 36, 40, 2, -32 },
  { 2039, 29, 32, 29, 0, -32 },
  { 2155, 22, 31, 29, 4, -31 },
  { 2241, 24, 32, 28, 3, -32 },
  { 2337, 26, 31, 32, 4, -31 },
  { 2438, 18, 31, 25, 4, -31 },
  { 2508, 18, 31, 23, 4, -31 },
  { 2578, 26, 32, 32, 3, -32 },
  { 2682, 25, 31, 33, 4, -31 },
  { 2779, 12, 31, 16, 2, -31 },
  { 2826, 12, 40, 13, -3, -31 },
  { 2886, 24, 31, 28, 4, -31 },
  { 2979, 18, 31, 24, 4, -31 },
  { 3049, 32, 31, 40, 4, -31 },
  { 3173, 26, 31, 34, 4, -31 },
  { 3274, 29, 32, 35, 3, -32 },
  { 3390, 21, 31, 27, 4, -31 },
  { 3472, 29, 39, 35, 3, -32 },
  { 3614, 23, 31, 28, 4, -31 },
  { 3704, 20, 32, 24, 2, -32 },
  { 3784, 23, 31, 25, 1, -31 },
  { 3874, 25, 31, 32, 4, -31 },
  { 3971, 27, 31, 27, 0, -31 },
  { 4076, 41, 31, 41, 0, -31 },
  { 4235, 27, 31, 27, 0, -31 },
  { 4340, 26, 31, 26, 0, -31 },
  { 4441, 23, 31, 25, 1, -31 },
  { 4531, 10, 38, 15, 3, -31 },
  { 4579, 17, 32, 17, 0, -32 },
  { 4647, 10, 38, 15, 1, -31 },
  { 4695, 23, 20, 25, 1, -32 },
  { 4753, 19, 3, 19, 0, 4 },
  { 4761, 10, 7, 13, 2, -34 },
  { 4770, 20, 24, 25, 2, -24 },
  { 4830, 21, 33, 27, 4, -33 },
  { 4917, 18, 24, 22, 2, -24 },
  { 4971, 22, 33, 27, 2, -33 },
  { 5062, 21, 24, 25, 2, -24 },
  { 5125, 17, 34, 16, 1, -34 },
  { 5198, 22, 35, 27, 2, -24 },
  { 5295, 20, 33, 28, 4, -33 },
  { 5378, 6, 33, 12, 3, -33 },
  { 5403, 11, 44, 12, -2, -33 },
  { 5464, 20, 33, 25, 4, -33 },
  { 5547, 4, 33, 12, 4, -33 },
  { 5564, 34, 24, 42, 4, -24 },
  { 5666, 20, 24, 28, 4, -24 },
  { 5726, 23, 24, 27, 2, -24 },
  { 5795, 21, 35, 27, 4, -24 },
  { 5887, 22, 35, 27, 2, -24 },
  { 5984, 14, 24, 19, 4, -24 },
  { 6026, 17, 24, 21, 2, -24 },
  { 6077, 15, 29, 17, 1, -29 },
  { 6132, 21, 24, 28, 3, -24 },
  { 6195, 23, 24, 23, 0, -24 },
  { 6264, 35, 24, 36, 0, -24 },
  { 6369, 22, 24, 24, 1, -24 },
  { 6435, 23, 35, 23, 0, -24 },
  { 6536, 17, 24, 21, 2, -24 },
  { 6587, 14, 38, 17, 1, -31 },
  { 6654, 4, 43, 24, 10, -33 },
  { 6676, 15, 38, 17, 1, -31 },
  { 6748, 21, 7, 25, 2, -19 },
};

const GFXfont NotoSans_Medium44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium44pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_MEDIUM44PT7B_H_
