#ifndef _NOTOSANS_MEDIUM24PT7B_H_
#define _NOTOSANS_MEDIUM24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0xDB, 0x60, 0x3F, 0xE0, 0xCF, 0x9F, 0x3E, 0x7C,
  0x58, 0x80, 0x06, 0x30, 0x18, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x63, 0xFF,
  0xFF, 0xFF, 0xC6, 0x30, 0x18, 0xC0, 0x63, 0x0F, 0xFF, 0xBF, 0xFE, 0x31,
  0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x06, 0x00, 0x60, 0x3F,
  0xE7, 0xFE, 0x66, 0x4E, 0x60, 0xE6, 0x07, 0x60, 0x7E, 0x01, 0xFC, 0x07,
  0xE0, 0x6E, 0x06, 0x70, 0x66, 0xE7, 0xEF, 0xFC, 0x3F, 0x00, 0x60, 0x06,
  0x00, 0x7C, 0x06, 0x1B, 0x83, 0x0C, 0x61, 0xC3, 0x18, 0x60, 0xC6, 0x30,
  0x31, 0x8C, 0x0C, 0x66, 0x23, 0x19, 0xBE, 0x6E, 0xCD, 0xDF, 0x36, 0x30,
  0x19, 0x8C, 0x0E, 0x63, 0x03, 0x18, 0xC1, 0x86, 0x30, 0x61, 0x8C, 0x30,
  0x3F, 0x1C, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x0C, 0x38, 0x06, 0x1C,
  0x03, 0x0E, 0x01, 0xCE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x3F, 0x07, 0x3D,
  0xC3, 0x18, 0x73, 0x9C, 0x1D, 0xCE, 0x07, 0xC7, 0x01, 0xC1, 0xC3, 0xF0,
  0xFF, 0xDC, 0x3F, 0x87, 0x80, 0xFF, 0xF0, 0x1C, 0xE3, 0x1C, 0x61, 0x8E,
  0x38, 0xC3, 0x0C, 0x30, 0xE3, 0x8E, 0x18, 0x61, 0xC3, 0x0E, 0x1C, 0xE1,
  0x87, 0x0C, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xC7, 0x18, 0x61, 0x8E, 0x38,
  0xC7, 0x18, 0xC0, 0x0E, 0x01, 0xC0, 0x18, 0x62, 0x3F, 0xFE, 0xFF, 0xC3,
  0x80, 0xD8, 0x3B, 0x8E, 0x38, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x77, 0x6E, 0xCC, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x81, 0x80, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0xE0, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x0E, 0xE0, 0x6E,
  0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0x60, 0x66,
  0x0E, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x0E, 0x3D, 0xFF, 0x74, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3F, 0x8F, 0xFC,
  0x60, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0x9F, 0xF9, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0xFC, 0x1F, 0x80,
  0x3C, 0x03, 0x80, 0x30, 0x06, 0x01, 0xE0, 0x3F, 0xFE, 0x7F, 0x80, 0x00,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x6E, 0x07, 0x70, 0x33, 0x83, 0x1C,
  0x38, 0xE1, 0x87, 0x18, 0x39, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x7F, 0xCF, 0xF9, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x1B,
  0x83, 0xFE, 0x7F, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xF0, 0x7F,
  0xFE, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x38, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE7, 0x8F, 0xFC, 0xF8, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06,
  0x70, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x3F, 0x87, 0xFC, 0x70, 0xE6,
  0x06, 0x60, 0x67, 0x0E, 0x39, 0xC1, 0xF8, 0x1F, 0x87, 0xBC, 0x60, 0xEE,
  0x06, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xFC,
  0x70, 0xEE, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x7E, 0x0F, 0x71, 0xF3, 0xF6,
  0x1E, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0xC7, 0xF8, 0x7E, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x77, 0x70, 0x00, 0x00, 0x00, 0x76, 0x6E, 0xCC,
  0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x0C, 0x00, 0x7F, 0xBF,
  0xE4, 0x1C, 0x03, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x70, 0x0E, 0x1C, 0x00, 0x63, 0x02, 0x0C, 0xC3, 0xF8, 0xD8, 0xE3,
  0x1B, 0x38, 0x63, 0xC6, 0x0C, 0x78, 0xC1, 0x8F, 0x18, 0x31, 0xE3, 0x0E,
  0x3E, 0x33, 0x6C, 0xC7, 0xCF, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x02,
  0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x06, 0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x30,
  0x18, 0x38, 0x3F, 0xF8, 0x3F, 0xFC, 0x30, 0x1C, 0x70, 0x0C, 0x70, 0x0E,
  0x60, 0x0E, 0xE0, 0x07, 0xFF, 0xCF, 0xFE, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0xCE, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE3, 0xC0, 0x8E,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x87, 0xFE, 0x07, 0xF8,
  0xFF, 0x83, 0xFF, 0x8E, 0x0F, 0x38, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x81,
  0xEE, 0x1F, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0xF0, 0x11, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0xFF, 0xC1, 0xFD, 0x80, 0x3B, 0x80,
  0x77, 0x00, 0xE7, 0x01, 0xCF, 0x03, 0x8F, 0xFF, 0x07, 0xFC, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1C, 0xFF, 0xF8, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x7F, 0xFE, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xEF, 0x8E, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC3, 0x8E, 0x38, 0x73,
  0x83, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xB8, 0x38, 0xE1, 0xC7, 0x0E, 0x1C,
  0x70, 0x73, 0x83, 0x9C, 0x0E, 0xE0, 0x38, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xFE, 0x01, 0xFD, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFB, 0x03, 0x7E, 0xC0, 0xDF, 0xB8, 0x67, 0xE6,
  0x19, 0xF9, 0x8E, 0x7E, 0x73, 0x1F, 0x8C, 0xC7, 0xE3, 0x71, 0xF8, 0xF8,
  0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE0, 0xC1, 0xC0, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0xF7, 0x03, 0xFC, 0x0F, 0xB8, 0x3E, 0x70, 0xF9, 0xC3, 0xE3, 0x8F,
  0x8E, 0x3E, 0x1C, 0xF8, 0x3B, 0xE0, 0xEF, 0x81, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1C, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x07,
  0x70, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x78, 0x0E, 0x3C, 0x1E, 0x1F, 0xFC, 0x07, 0xF0,
  0xFF, 0x9F, 0xFB, 0x87, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xFF,
  0xDF, 0xF3, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x07,
  0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x78, 0x0E, 0x3C, 0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFE, 0x38, 0x79, 0xC0,
  0xCE, 0x07, 0x70, 0x33, 0x83, 0x9C, 0x3C, 0xFF, 0xC7, 0xF8, 0x38, 0xE1,
  0xC3, 0x8E, 0x1C, 0x70, 0x73, 0x83, 0x9C, 0x0E, 0xE0, 0x38, 0x3F, 0xCF,
  0xFD, 0xC1, 0x70, 0x0E, 0x00, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0x80, 0x70, 0x06, 0x01, 0xF0, 0x7F, 0xFE, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x19, 0x80, 0xE7, 0x87, 0x8F, 0xFC, 0x1F, 0xC0, 0xE0, 0x0E, 0xC0, 0x19,
  0xC0, 0x73, 0x80, 0xE3, 0x03, 0x87, 0x07, 0x0E, 0x0C, 0x0C, 0x38, 0x1C,
  0x70, 0x38, 0xC0, 0x33, 0x80, 0x77, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x38, 0x0D, 0x81, 0xE0, 0x77, 0x07, 0x81,
  0xDC, 0x1F, 0x06, 0x70, 0x6C, 0x18, 0xC3, 0xB0, 0xE3, 0x8C, 0xC3, 0x8E,
  0x33, 0x8C, 0x39, 0xC6, 0x30, 0x67, 0x19, 0xC1, 0x98, 0x77, 0x07, 0x60,
  0xD8, 0x0F, 0x83, 0x60, 0x3C, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0xF0, 0x1C, 0xE0, 0x70, 0xE0, 0xC0, 0xE3, 0x81, 0xCE,
  0x01, 0xDC, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3B, 0x00,
  0x67, 0x01, 0xC7, 0x07, 0x0E, 0x0C, 0x0E, 0x38, 0x0E, 0xE0, 0x1E, 0xE0,
  0x1D, 0xC0, 0xE7, 0x03, 0x8E, 0x1C, 0x38, 0x70, 0x73, 0x80, 0xCC, 0x03,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x03, 0x80, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80, 0x06, 0x00, 0xE0, 0x0F, 0x01,
  0xB0, 0x19, 0x83, 0x18, 0x30, 0xC6, 0x0C, 0x60, 0x6C, 0x06, 0xC0, 0x30,
  0xFF, 0xFF, 0xF0, 0xE3, 0x86, 0x7F, 0x87, 0xF8, 0x83, 0x80, 0x70, 0x0E,
  0x1F, 0xDF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xBF, 0xB7, 0xE6, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0xF8, 0xDF, 0xCF, 0x0E, 0xE0,
  0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEF, 0x0E, 0xDF,
  0xCC, 0xF8, 0x1F, 0xCF, 0xF7, 0x05, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x18, 0x07, 0x04, 0xFF, 0x1F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x71, 0xF7, 0x3F, 0xF7, 0x0F, 0x60, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0F, 0x3F, 0xB1, 0xF3, 0x1F, 0x83,
  0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x6F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x23, 0xFE, 0x1F, 0xE0, 0x0F, 0xC7, 0xE1, 0x80, 0x60, 0x18,
  0x1F, 0xCF, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0x1F, 0x33, 0xFB, 0x70, 0xF6, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0xF3, 0xFF, 0x1F,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x71, 0xE7, 0xFC, 0x1F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x37, 0xF7, 0x87, 0xE0, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0C, 0xDF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x71, 0x80, 0x00, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1A, 0xEF, 0xB8,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC1, 0xF8, 0x77, 0x1C, 0xE7,
  0x1D, 0xC3, 0x70, 0x7E, 0x0F, 0xE1, 0xCE, 0x38, 0xE7, 0x1C, 0xE1, 0xDC,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xCF, 0x8F, 0x9B, 0xFB,
  0xFB, 0xC7, 0xC3, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38,
  0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70,
  0x7E, 0x0E, 0x0E, 0xCF, 0x9B, 0xFB, 0xC3, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0x1F, 0x83, 0xFE,
  0x70, 0xE6, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x07,
  0x70, 0xE3, 0xFE, 0x1F, 0xC0, 0xCF, 0x8D, 0xFC, 0xF0, 0xEE, 0x0E, 0xE0,
  0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xF0, 0xED, 0xFC, 0xCF,
  0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x33,
  0xFB, 0x70, 0xF6, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76,
  0x07, 0x70, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0xCF, 0xDF, 0xF8, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x9F, 0xEE, 0x0B, 0x80, 0xF0, 0x1F, 0x03,
  0xF0, 0x1E, 0x01, 0xC0, 0x78, 0x1B, 0xFE, 0xFF, 0x00, 0x18, 0x0C, 0x0E,
  0x0F, 0xEF, 0xF1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x7E, 0x1F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xFC, 0x1F, 0x87, 0xBF, 0xB3, 0xE6, 0xE0, 0x3B, 0x03,
  0x9C, 0x1C, 0xE0, 0xC3, 0x0E, 0x1C, 0x70, 0xE3, 0x03, 0x38, 0x1D, 0x80,
  0x6C, 0x03, 0xE0, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0xEC, 0x1E, 0x1D,
  0x83, 0xC3, 0x38, 0xD8, 0x63, 0x1B, 0x1C, 0x63, 0x73, 0x8E, 0xE6, 0x61,
  0xD8, 0xCC, 0x1B, 0x1B, 0x83, 0x61, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80,
  0xE0, 0xF0, 0x70, 0x71, 0x83, 0x8E, 0x38, 0x3B, 0x80, 0xD8, 0x07, 0xC0,
  0x1C, 0x01, 0xF0, 0x1D, 0xC0, 0xEE, 0x0E, 0x38, 0xE0, 0xEF, 0x07, 0x80,
  0xE0, 0x3B, 0x03, 0x9C, 0x1C, 0xE0, 0xC3, 0x0E, 0x1C, 0x70, 0x63, 0x03,
  0x38, 0x1D, 0x80, 0x6C, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x07, 0xC0, 0x3C, 0x00, 0xFF, 0xBF, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0,
  0x0E, 0x3C, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x39, 0xE3, 0x83, 0x83, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x70, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x07,
  0x1E, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xC0, 0x7C, 0x1F,
  0xFF, 0x87, 0xE0,
};

const GFXglyph NotoSans_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 17, 7, 2, -17 },
  { 8, 7, 6, 10, 2, -17 },
  { 14, 14, 17, 16, 1, -17 },
  { 44, 12, 19, 14, 1, -18 },
  { 73, 18, 17, 20, 1, -17 },
  { 112, 17, 17, 18, 1, -17 },
  { 149, 2, 6, 6, 2, -17 },
  { 151, 6, 21, 7, 1, -17 },
  { 167, 6, 21, 7, 1, -17 },
  { 183, 11, 11, 13, 1, -18 },
  { 199, 12, 11, 14, 1, -14 },
  { 216, 4, 6, 7, 1, -3 },
  { 219, 6, 3, 8, 1, -8 },
  { 222, 3, 3, 7, 2, -3 },
  { 224, 9, 17, 9, 0, -17 },
  { 244, 12, 17, 14, 1, -17 },
  { 270, 7, 17, 14, 2, -17 },
  { 285, 12, 17, 14, 1, -17 },
  { 311, 11, 17, 14, 1, -17 },
  { 335, 13, 17, 14, 0, -17 },
  { 363, 11, 17, 14, 1, -17 },
  { 387, 12, 17, 14, 1, -17 },
  { 413, 12, 17, 14, 1, -17 },
  { 439, 12, 17, 14, 1, -17 },
  { 465, 12, 17, 14, 1, -17 },
  { 491, 3, 13, 7, 2, -13 },
  { 496, 4, 16, 7, 1, -13 },
  { 504, 12, 12, 14, 1, -15 },
  { 522, 11, 7, 14, 1, -12 },
  { 532, 12, 12, 14, 1, -15 },
  { 550, 10, 17, 11, 0, -17 },
  { 572, 19, 19, 22, 1, -17 },
  { 618, 16, 17, 16, 0, -17 },
  { 652, 12, 17, 16, 2, -17 },
  { 678, 14, 17, 15, 1, -17 },
  { 708, 14, 17, 18, 2, -17 },
  { 738, 10, 17, 13, 2, -17 },
  { 760, 10, 17, 13, 2, -17 },
  { 782, 15, 17, 17, 1, -17 },
  { 814, 14, 17, 18, 2, -17 },
  { 844, 7, 17, 9, 1, -17 },
  { 859, 7, 22, 7, -2, -17 },
  { 879, 13, 17, 15, 2, -17 },
  { 907, 10, 17, 13, 2, -17 },
  { 929, 18, 17, 22, 2, -17 },
  { 968, 14, 17, 19, 2, -17 },
  { 998, 16, 17, 19, 1, -17 },
  { 1032, 11, 17, 15, 2, -17 },
  { 1056, 16, 21, 19, 1, -17 },
  { 1098, 13, 17, 15, 2, -17 },
  { 1126, 11, 17, 13, 1, -17 },
  { 1150, 13, 17, 13, 0, -17 },
  { 1178, 14, 17, 18, 2, -17 },
  { 1208, 15, 17, 15, 0, -17 },
  { 1240, 22, 17, 23, 0, -17 },
  { 1287, 15, 17, 15, 0, -17 },
  { 1319, 14, 17, 14, 0, -17 },
  { 1349, 12, 17, 14, 1, -17 },
  { 1375, 5, 21, 8, 2, -17 },
  { 1389, 9, 17, 9, 0, -17 },
  { 1409, 5, 21, 8, 1, -17 },
  { 1423, 12, 11, 14, 1, -17 },
  { 1440, 10, 2, 10, 0, 2 },
  { 1443, 5, 3, 7, 1, -18 },
  { 1445, 11, 13, 14, 1, -13 },
  { 1463, 12, 18, 15, 2, -18 },
  { 1490, 10, 13, 12, 1, -13 },
  { 1507, 12, 18, 15, 1, -18 },
  { 1534, 12, 13, 14, 1, -13 },
  { 1554, 10, 18, 9, 0, -18 },
  { 1577, 12, 19, 15, 1, -13 },
  { 1606, 11, 18, 15, 2, -18 },
  { 1631, 3, 18, 6, 2, -18 },
  { 1638, 6, 24, 6, -1, -18 },
  { 1656, 11, 18, 13, 2, -18 },
  { 1681, 3, 18, 6, 2, -18 },
  { 1688, 19, 13, 23, 2, -13 },
  { 1719, 11, 13, 15, 2, -13 },
  { 1737, 12, 13, 15, 1, -13 },
  { 1757, 12, 19, 15, 2, -13 },
  { 1786, 12, 19, 15, 1, -13 },
  { 1815, 8, 13, 10, 2, -13 },
  { 1828, 10, 13, 12, 1, -13 },
  { 1845, 9, 16, 9, 0, -16 },
  { 1863, 11, 13, 15, 2, -13 },
  { 1881, 13, 13, 13, 0, -13 },
  { 1903, 19, 13, 19, 0, -13 },
  { 1934, 13, 13, 13, 0, -13 },
  { 1956, 13, 19, 13, 0, -13 },
  { 1987, 10, 13, 11, 1, -13 },
  { 2004, 7, 21, 9, 1, -17 },
  { 2023, 2, 24, 13, 6, -18 },
  { 2029, 8, 21, 9, 1, -17 },
  { 2050, 12, 3, 14, 1, -10 },
};

const GFXfont NotoSans_Medium24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium24pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_MEDIUM24PT7B_H_
