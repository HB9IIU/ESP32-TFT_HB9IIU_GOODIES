#ifndef _NOTOSANS_MEDIUM56PT7B_H_
#define _NOTOSANS_MEDIUM56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0x38, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xF9, 0xE7, 0xF1, 0xF8, 0x78, 0x1C, 0xFC, 0x1E,
  0x00, 0x3F, 0x07, 0x80, 0x0F, 0xC1, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0xFE,
  0x1E, 0x00, 0x1F, 0x87, 0x80, 0x07, 0xF9, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xEF, 0xF8, 0x00,
  0x78, 0xFF, 0x00, 0x1E, 0x1F, 0xC0, 0x07, 0x83, 0xF0, 0x01, 0xE0, 0xFC,
  0x00, 0x78, 0x3F, 0x00, 0x1E, 0x0F, 0xF0, 0x07, 0x87, 0xFF, 0x81, 0xE3,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x00, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0x3E,
  0x1F, 0x00, 0x00, 0x78, 0x07, 0x83, 0xE0, 0x20, 0x0F, 0x81, 0xF0, 0xF8,
  0x7F, 0xC1, 0xF0, 0x3E, 0x1F, 0x1F, 0xFC, 0x3E, 0x07, 0xC7, 0xC7, 0xFF,
  0xC3, 0xE1, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x3E, 0x0F, 0x87,
  0xFF, 0x8F, 0xC7, 0xC1, 0xF0, 0x7F, 0xE1, 0xF1, 0xF0, 0x1F, 0x07, 0xF8,
  0x7C, 0x3E, 0x03, 0xE0, 0x10, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC1, 0xFE, 0xFE, 0x00, 0x7E,
  0x0F, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x07,
  0xF0, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0,
  0xFC, 0x00, 0x3F, 0x9F, 0x83, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x00,
  0xFF, 0xF0, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x7F, 0x81,
  0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x60, 0x1E, 0x00, 0xCF, 0x83,
  0xC1, 0xF9, 0xFF, 0x79, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF8, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03,
  0xE0, 0x03, 0xC0, 0x70, 0x00, 0x10, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0x9F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xBF, 0xFF, 0x9F,
  0xBF, 0x8F, 0xCF, 0x07, 0xE7, 0x03, 0xF1, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xF0, 0x0F, 0xF0, 0xF0, 0x00, 0xFC, 0x30, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE7, 0xFF, 0x0F, 0x80, 0x0F, 0xE0, 0xC0, 0x00, 0xFE, 0x10,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x3F, 0xEF, 0xF8, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0,
  0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1C, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xA0,
  0x00, 0x0F, 0xEF, 0x00, 0x0F, 0xF3, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x30, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xFF, 0x80, 0xFC, 0x7F, 0xFC, 0x1F,
  0xBF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0xFF, 0xCF, 0xF8, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC7, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x1F, 0xE1, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x0F, 0xF8, 0x3F,
  0x80, 0xFF, 0x1F, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F,
  0xE7, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFE,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFD,
  0xFC, 0x01, 0xFF, 0x7F, 0xC3, 0xFF, 0xCF, 0xFF, 0xFD, 0xF1, 0xFF, 0xFE,
  0xFC, 0x3F, 0xFF, 0x3F, 0x03, 0xFF, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x9C, 0x0E, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xE7, 0xE3,
  0xF1, 0xF9, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9E, 0x00,
  0x7F, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xFF, 0xC0, 0x3E,
  0x1F, 0x00, 0x7F, 0xFF, 0x03, 0xE3, 0xE0, 0x1F, 0xFF, 0xF0, 0x1E, 0x3E,
  0x03, 0xFF, 0xFF, 0x01, 0xF7, 0xC0, 0x7F, 0x01, 0xF0, 0x1F, 0x7C, 0x07,
  0xE0, 0x1F, 0x01, 0xF7, 0xC0, 0xFC, 0x01, 0xF0, 0x0F, 0x78, 0x0F, 0x80,
  0x1F, 0x00, 0xFF, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xF8, 0x1F, 0x00, 0x1F,
  0x00, 0xFF, 0x81, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x1F, 0x00, 0x1F, 0x00,
  0xFF, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xFF,
  0x81, 0xF0, 0x03, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xEF, 0x80,
  0xF8, 0x03, 0xF0, 0x3E, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xC7, 0x80, 0x7E,
  0x1F, 0xF8, 0xFC, 0x7C, 0x07, 0xFF, 0xE7, 0xFF, 0x87, 0xC0, 0x3F, 0xFC,
  0x3F, 0xF0, 0x7C, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7E, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFE, 0xFC, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xBF, 0x00,
  0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x1E, 0x07,
  0xFC, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xE0, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xE1, 0xF8, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x0F, 0xF8, 0x3F,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x04, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x1F, 0xFF, 0xBF, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x0F, 0xC3, 0xFE,
  0x00, 0x07, 0xE0, 0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xD0, 0xFF, 0xBF, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xEF, 0x80, 0x00, 0x0F, 0xBF, 0xF7, 0xE0, 0x00,
  0x07, 0xDF, 0xFD, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xEF,
  0xFF, 0x7E, 0x00, 0x01, 0xF7, 0xFF, 0x9F, 0x00, 0x01, 0xF3, 0xFF, 0xCF,
  0x80, 0x00, 0xF9, 0xFF, 0xE7, 0xE0, 0x00, 0xFC, 0xFF, 0xF1, 0xF0, 0x00,
  0x7C, 0x7F, 0xF8, 0xF8, 0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0xFE, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0x87, 0xFF, 0x87,
  0xE0, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x07, 0xC1, 0xFF, 0xE0, 0xFC, 0x03,
  0xE0, 0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x01, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xFE, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0x01,
  0xF0, 0x7C, 0x07, 0xFF, 0x80, 0xFC, 0x7E, 0x03, 0xFF, 0xC0, 0x3E, 0x3E,
  0x01, 0xFF, 0xE0, 0x1F, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x00, 0x7F,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xF8, 0x00, 0x0F, 0xFC,
  0xFE, 0x00, 0x07, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0x9F, 0xC0, 0x01, 0xFF,
  0xC7, 0xE0, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0x3F,
  0xF8, 0x7F, 0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x0F, 0xFE, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x00,
  0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xF0, 0x07, 0xF0, 0x3F, 0xF8, 0x03, 0xF8,
  0x1F, 0xFC, 0x00, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0x87, 0xFF, 0x00, 0x1F,
  0xC3, 0xFF, 0x80, 0x07, 0xF1, 0xFF, 0xC0, 0x01, 0xF8, 0xFF, 0xE0, 0x00,
  0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xBF, 0xF8, 0x00, 0x1F, 0xDF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x7F, 0xEF, 0xC0,
  0x07, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xEF, 0xC0, 0x07, 0xFB, 0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x07, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFF, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFE, 0x00, 0x78, 0xFE, 0x00, 0x04, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xDF,
  0x00, 0x1F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x58, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x05, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xF9,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x03, 0xE0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC,
  0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x01, 0xF8,
  0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0x9F, 0x80, 0x00,
  0xFD, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xF0, 0x1F, 0xE0, 0x60, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xF0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xF7, 0xF8, 0x3F, 0xFC,
  0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xC7, 0xC7, 0xFF, 0xE1, 0xF0, 0x7F, 0xF0,
  0x7C, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x78, 0x01,
  0xF0, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0x07, 0xCF, 0xFF, 0xF0, 0xFB, 0xFF,
  0xFF, 0x1F, 0xFC, 0x3F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x03, 0xF9, 0xFF, 0x00, 0xFF,
  0x3F, 0xFC, 0x7F, 0xC7, 0xDF, 0xFF, 0xF8, 0xF9, 0xFF, 0xFE, 0x1E, 0x1F,
  0xFF, 0x03, 0xC1, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0x1F, 0x0F, 0xF0, 0x02, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x18,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x03, 0xFF, 0x8F, 0xC1, 0xFF, 0xF9, 0xF8, 0x7F, 0xFF, 0xBF, 0x1F,
  0xFF, 0xFB, 0xE7, 0xFC, 0x1F, 0xFC, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x0F,
  0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x7F, 0xCF, 0xFC, 0x3F, 0xF8, 0xFF, 0xFF, 0xDF, 0x0F, 0xFF, 0xF3, 0xE0,
  0xFF, 0xFC, 0x7C, 0x07, 0xFE, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x61, 0xFF,
  0x81, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFC, 0x08, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x1F, 0xFF, 0x8F, 0x87, 0xFF, 0xF9,
  0xF1, 0xFF, 0xFF, 0xBE, 0x7F, 0xC1, 0xFF, 0xCF, 0xE0, 0x0F, 0xFB, 0xF8,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xE7,
  0xF0, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0x7E, 0x0F, 0xFF, 0xCF, 0xC0, 0x7F, 0xE1, 0xF8, 0x00, 0xE0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x40, 0x00, 0x3F, 0x8E, 0x00, 0x0F, 0xF1, 0xFF,
  0x9F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x3F, 0x1F,
  0xFE, 0x0F, 0x8F, 0xFF, 0xC3, 0xE7, 0xFF, 0xF8, 0xFB, 0xFF, 0xFF, 0x3F,
  0xF8, 0x3F, 0xEF, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC,
  0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFC, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xEE, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xEF,
  0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC7, 0xF0, 0x03, 0xE3, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x3E,
  0x7E, 0x00, 0x0F, 0xBF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8,
  0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFE, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xEF, 0xE0, 0x03,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3C, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xE3, 0xE7, 0xFF, 0xFC, 0xFB,
  0xFF, 0xFF, 0x3F, 0xF8, 0x3F, 0xEF, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x0F,
  0xFE, 0x03, 0xE3, 0xFF, 0xF0, 0x7C, 0xFF, 0xFF, 0x0F, 0xBF, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x0F, 0xF3, 0xFF,
  0xCF, 0xFC, 0x7D, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xE1, 0xF1, 0xFF, 0xF0,
  0x3E, 0x1F, 0xFC, 0x07, 0xE0, 0x10, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x1F, 0xFF, 0x8F, 0x87, 0xFF,
  0xF9, 0xF1, 0xFF, 0xFF, 0xBE, 0x7F, 0xC1, 0xFF, 0xCF, 0xE0, 0x0F, 0xFB,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xE7, 0xF0, 0x07, 0xFC, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x7E, 0x0F, 0xFF, 0xCF, 0xC0, 0x7F, 0xE1, 0xF8, 0x01, 0xE0, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xBC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xFF, 0xFB, 0xFF, 0xBE, 0xFF, 0xEF, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x07, 0xCF, 0xC0, 0x02, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xEF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x60, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x18, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFB, 0xF0, 0x01, 0xFF, 0x7F,
  0x00, 0x7F, 0xEF, 0xFC, 0x7F, 0xFC, 0xFF, 0xFF, 0xDF, 0x8F, 0xFF, 0xFB,
  0xF0, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xBE, 0x00,
  0xFC, 0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xBE, 0x00, 0xF8,
  0x3F, 0x00, 0xFB, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x1F, 0x03, 0xF0, 0x1F, 0x81,
  0xF1, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x0F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x00, 0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x00, 0x7E, 0x7C, 0x07, 0xCF, 0xC0, 0x07, 0xEF, 0x80, 0x3E, 0xFC, 0x00,
  0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x00, 0x3E,
  0xF0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x0F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x04, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x4F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFA, 0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_Medium56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 41, 15, 4, -40 },
  { 37, 16, 14, 24, 4, -40 },
  { 65, 34, 40, 36, 1, -40 },
  { 235, 26, 46, 32, 3, -43 },
  { 385, 43, 42, 48, 2, -41 },
  { 611, 38, 42, 41, 3, -41 },
  { 811, 6, 14, 13, 4, -40 },
  { 822, 14, 49, 17, 2, -40 },
  { 908, 13, 49, 17, 2, -40 },
  { 988, 27, 26, 31, 2, -43 },
  { 1076, 26, 27, 32, 3, -33 },
  { 1164, 9, 14, 15, 2, -7 },
  { 1180, 14, 6, 18, 2, -18 },
  { 1191, 7, 8, 15, 4, -7 },
  { 1198, 21, 40, 22, 0, -40 },
  { 1303, 27, 42, 32, 3, -41 },
  { 1445, 17, 40, 32, 4, -40 },
  { 1530, 26, 41, 32, 3, -41 },
  { 1664, 27, 42, 32, 2, -41 },
  { 1806, 30, 40, 32, 1, -40 },
  { 1956, 26, 41, 32, 3, -40 },
  { 2090, 27, 41, 32, 3, -40 },
  { 2229, 28, 40, 32, 2, -40 },
  { 2369, 26, 42, 32, 3, -41 },
  { 2506, 26, 41, 32, 3, -40 },
  { 2640, 7, 32, 15, 4, -31 },
  { 2668, 9, 38, 15, 2, -31 },
  { 2711, 26, 28, 32, 3, -34 },
  { 2802, 26, 16, 32, 3, -28 },
  { 2854, 26, 28, 32, 3, -34 },
  { 2945, 23, 42, 25, 1, -41 },
  { 3066, 44, 45, 50, 3, -40 },
  { 3314, 37, 40, 37, 0, -40 },
  { 3499, 29, 40, 37, 5, -40 },
  { 3644, 31, 42, 36, 3, -41 },
  { 3807, 33, 40, 41, 5, -40 },
  { 3972, 23, 40, 31, 5, -40 },
  { 4087, 23, 40, 30, 5, -40 },
  { 4202, 33, 42, 41, 3, -41 },
  { 4376, 32, 40, 42, 5, -40 },
  { 4536, 16, 40, 20, 2, -40 },
  { 4616, 15, 51, 16, -4, -40 },
  { 4712, 30, 40, 35, 5, -40 },
  { 4862, 23, 40, 30, 5, -40 },
  { 4977, 41, 40, 51, 5, -40 },
  { 5182, 33, 40, 43, 5, -40 },
  { 5347, 38, 42, 44, 3, -41 },
  { 5547, 26, 40, 34, 5, -40 },
  { 5677, 38, 51, 44, 3, -41 },
  { 5920, 30, 40, 35, 5, -40 },
  { 6070, 25, 42, 31, 3, -41 },
  { 6202, 30, 40, 31, 1, -40 },
  { 6352, 31, 41, 41, 5, -40 },
  { 6511, 34, 40, 34, 0, -40 },
  { 6681, 52, 40, 53, 0, -40 },
  { 6941, 34, 40, 34, 0, -40 },
  { 7111, 33, 40, 33, 0, -40 },
  { 7276, 28, 40, 32, 2, -40 },
  { 7416, 13, 49, 18, 4, -40 },
  { 7496, 21, 40, 22, 0, -40 },
  { 7601, 13, 49, 18, 1, -40 },
  { 7681, 28, 25, 32, 2, -40 },
  { 7769, 24, 4, 24, 0, 5 },
  { 7781, 13, 9, 17, 2, -43 },
  { 7796, 26, 32, 32, 2, -31 },
  { 7900, 27, 44, 35, 5, -43 },
  { 8049, 23, 32, 28, 3, -31 },
  { 8141, 27, 44, 35, 3, -43 },
  { 8290, 26, 32, 32, 3, -31 },
  { 8394, 21, 43, 20, 1, -43 },
  { 8507, 27, 44, 35, 3, -31 },
  { 8656, 26, 43, 35, 5, -43 },
  { 8796, 7, 42, 15, 4, -42 },
  { 8833, 14, 55, 15, -3, -42 },
  { 8930, 26, 43, 31, 5, -43 },
  { 9070, 6, 43, 15, 5, -43 },
  { 9103, 44, 31, 53, 5, -31 },
  { 9274, 26, 31, 35, 5, -31 },
  { 9375, 28, 32, 34, 3, -31 },
  { 9487, 27, 44, 35, 5, -31 },
  { 9636, 27, 44, 35, 3, -31 },
  { 9785, 18, 31, 24, 5, -31 },
  { 9855, 22, 32, 27, 3, -31 },
  { 9943, 19, 38, 21, 1, -37 },
  { 10034, 27, 31, 35, 4, -30 },
  { 10139, 30, 30, 30, 0, -30 },
  { 10252, 44, 30, 45, 1, -30 },
  { 10417, 29, 30, 30, 1, -30 },
  { 10526, 30, 43, 30, 0, -30 },
  { 10688, 23, 30, 27, 2, -30 },
  { 10775, 19, 49, 22, 1, -40 },
  { 10892, 5, 56, 31, 13, -43 },
  { 10927, 18, 49, 22, 2, -40 },
  { 11038, 26, 8, 32, 3, -24 },
};

const GFXfont NotoSans_Medium56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium56pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_MEDIUM56PT7B_H_
