#ifndef _NOTOSANS_MEDIUM58PT7B_H_
#define _NOTOSANS_MEDIUM58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF1, 0xFE, 0x38, 0x7E, 0x3F, 0x07, 0x00, 0x8F, 0xE0, 0xE0, 0x01, 0xF8,
  0x1C, 0x00, 0x3F, 0x03, 0x80, 0x07, 0xE0, 0x70, 0x00, 0xFE, 0x0E, 0x00,
  0x0F, 0xE1, 0xC0, 0x01, 0xFE, 0x38, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0x1F, 0xF0, 0x00, 0xE0, 0xFE, 0x00, 0x1C, 0x0F, 0xC0, 0x03, 0x81, 0xF8,
  0x00, 0x70, 0x3F, 0x00, 0x0E, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0x80, 0x38,
  0x3F, 0xFE, 0x07, 0x1F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x1F, 0x07, 0xF8, 0x1F,
  0x01, 0xF0, 0xF8, 0xFF, 0xE0, 0xF8, 0x1F, 0x8F, 0x8F, 0xFF, 0x83, 0xE0,
  0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC7, 0xE1, 0xF0, 0x7F, 0xFC,
  0x7E, 0x3E, 0x07, 0xC1, 0xFF, 0xC3, 0xE1, 0xF0, 0x3E, 0x07, 0xFC, 0x3F,
  0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x03,
  0xF1, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0xFF,
  0xF0, 0x01, 0xF8, 0x3F, 0xE7, 0xF8, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x03,
  0xF0, 0x7F, 0x01, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x87, 0xE0, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0xE7, 0xE0,
  0xF0, 0xFE, 0x7F, 0xEF, 0x7F, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x7F, 0x7E, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xDF, 0x07, 0xE6, 0x07,
  0xF2, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0x00, 0x7F, 0x83, 0xC0, 0x03, 0xF8, 0x10, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFC, 0x07, 0xFC, 0x3E, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xEC, 0x00, 0x01, 0xFE,
  0xF8, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3A, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFB, 0x00, 0x00, 0xFF, 0x7C, 0x00, 0x7F, 0xCF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xE0, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x1F, 0xF0, 0x0F, 0xC7, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF,
  0x0F, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x03, 0xFC, 0xFF,
  0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xFC,
  0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xF0, 0x03,
  0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x03, 0xFE,
  0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF,
  0xE7, 0xE0, 0xFF, 0xF0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x38, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x0F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF,
  0x9E, 0x00, 0x3F, 0xA0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0xFF,
  0x01, 0xF0, 0x7C, 0x01, 0xFF, 0xFE, 0x03, 0xE3, 0xE0, 0x0F, 0xFF, 0xF8,
  0x0F, 0x8F, 0x80, 0x7F, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xF8, 0x0F, 0x80,
  0x7D, 0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xF7, 0xC0, 0x7E, 0x00, 0xF8, 0x07,
  0xDF, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x78, 0x0F, 0xC0, 0x0F, 0x80, 0x7F,
  0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xFE,
  0x03, 0xE0, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7F, 0xE0,
  0x3E, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xBE, 0x03,
  0xE0, 0x07, 0xE0, 0x3E, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFB, 0xE0, 0x3F,
  0x00, 0xFE, 0x07, 0xC7, 0x80, 0x7E, 0x07, 0xFC, 0x1F, 0x1F, 0x01, 0xFF,
  0x7E, 0xFF, 0xF8, 0x7C, 0x03, 0xFF, 0xF3, 0xFF, 0xC1, 0xF0, 0x07, 0xFF,
  0x87, 0xFE, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x00, 0xFF,
  0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFC, 0xFE,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x8F, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFF, 0xBF, 0x80, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE3, 0xFE,
  0x07, 0xFE, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x02,
  0x07, 0xFF, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x80, 0x0F, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0xC3, 0xF8, 0x00,
  0x0F, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x01, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0x83, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0xC0,
  0x01, 0xE0, 0x3F, 0xE0, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFB,
  0xF0, 0x00, 0x7F, 0xFF, 0x7E, 0x00, 0x0F, 0xFF, 0xEF, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0xC0, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0xF0, 0x00,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x74, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x83, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xFD, 0xF8, 0x00,
  0x0F, 0xF3, 0xF0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF0,
  0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80,
  0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xEF, 0x80, 0x00, 0x0F, 0xBF, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xFE,
  0xFC, 0x00, 0x01, 0xF3, 0xFF, 0x9F, 0x00, 0x00, 0x7C, 0xFF, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0xF9, 0xF8, 0x00, 0x0F, 0x8F, 0xFE, 0x3E, 0x00, 0x03,
  0xE3, 0xFF, 0x8F, 0xC0, 0x01, 0xF8, 0xFF, 0xE3, 0xF0, 0x00, 0x7C, 0x3F,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xFE, 0x1F, 0x80, 0x0F, 0xC3, 0xFF, 0x83,
  0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0xF8, 0x3F, 0x00,
  0x7C, 0x0F, 0xFE, 0x07, 0xC0, 0x1F, 0x03, 0xFF, 0x81, 0xF8, 0x0F, 0xC0,
  0xFF, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFE,
  0x03, 0xF0, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x1F, 0x00, 0xFF, 0xE0, 0x1F,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x3F,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xF8,
  0x00, 0x0F, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xC0, 0x00, 0xFF, 0xE7,
  0xF8, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xC0, 0x03, 0xFF,
  0x87, 0xF0, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xC0, 0x0F,
  0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xC0,
  0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xF8, 0x00, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0x83, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0xE0, 0x01, 0xFE, 0x3F, 0xF8,
  0x00, 0x3F, 0x8F, 0xFE, 0x00, 0x07, 0xF3, 0xFF, 0x80, 0x01, 0xFC, 0xFF,
  0xE0, 0x00, 0x3F, 0xBF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0xFC, 0xFE, 0x00,
  0x3F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFC,
  0x7F, 0xC7, 0xF8, 0x00, 0xF1, 0xFC, 0x00, 0x04, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF3, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x1F,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF0, 0x3F, 0x01, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xE0,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xE0, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFC, 0x03, 0xF7, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0xFF, 0xEF, 0xCF, 0xFF, 0xF1, 0xF1,
  0xFF, 0xF8, 0x7C, 0x3F, 0xF8, 0x1F, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC3, 0xFF, 0x80, 0xFC,
  0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFC, 0xFF,
  0xC0, 0x3F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFB, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF,
  0xE0, 0xF8, 0xFF, 0xFC, 0x0F, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFC, 0xFC, 0x3F, 0xC0, 0x04, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x3F, 0xE0, 0x0E, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x1F, 0xFE, 0x3F, 0x07, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xBF, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0x03, 0xFF, 0xF1, 0xF0, 0x1F, 0xFC,
  0x1F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x7F, 0x80, 0x07,
  0x0F, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0x9F,
  0x1F, 0xFF, 0xFD, 0xF1, 0xFF, 0x07, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xF8,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xF3, 0xF0, 0x1F,
  0xFC, 0x3F, 0x00, 0x08, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x20,
  0x00, 0x0F, 0xE3, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0xC3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x7F, 0xF8, 0x3F, 0x3F, 0xFF, 0x87, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFE, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xEF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF0,
  0x7F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xBF, 0x00, 0x1F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x07, 0xF8,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0x3F, 0x87, 0xE0, 0x07, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xC3, 0xFF,
  0xC0, 0x3F, 0xFC, 0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x07, 0xFF, 0x83, 0xE3,
  0xFF, 0xFC, 0x7C, 0xFF, 0xFF, 0xCF, 0xBF, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF,
  0xBF, 0xE0, 0x07, 0xF7, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x83, 0xFF, 0x80, 0xF8,
  0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFC, 0xFF,
  0xC0, 0x3F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF,
  0xE0, 0xFC, 0xFF, 0xFC, 0x0F, 0xC3, 0xFF, 0x80, 0xFC, 0x07, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0x9F, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xE3, 0xF0, 0x1F, 0xFC,
  0x3F, 0x00, 0x08, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0x7C, 0x7F, 0xEF,
  0x9F, 0xFD, 0xF7, 0xFF, 0xBF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0x3F,
  0x00, 0x04, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFB, 0x80, 0x07, 0xF7,
  0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xEF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x06, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF7, 0xF8,
  0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xF3,
  0xF0, 0xFF, 0xFE, 0x3F, 0x03, 0xFF, 0x81, 0xF0, 0x01, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0xFC, 0x01,
  0xF7, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x3F, 0x00, 0xFD,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x3E,
  0x03, 0xF0, 0x3F, 0x01, 0xF1, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC1, 0xF0, 0x7E,
  0x01, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x00,
  0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xC0, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x01, 0xF3,
  0xE0, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x27, 0xFE, 0x00, 0x05, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF4, 0x00,
  0x1F, 0xFC, 0x80, 0x00, 0x1C, 0x00,
};

const GFXglyph NotoSans_Medium58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 42, 16, 4, -41 },
  { 43, 17, 15, 25, 4, -41 },
  { 75, 35, 41, 37, 1, -41 },
  { 255, 27, 47, 33, 3, -44 },
  { 414, 45, 43, 49, 2, -42 },
  { 656, 40, 43, 43, 3, -42 },
  { 871, 6, 15, 14, 4, -41 },
  { 883, 14, 50, 18, 2, -41 },
  { 971, 14, 50, 18, 2, -41 },
  { 1059, 28, 26, 32, 2, -44 },
  { 1150, 27, 29, 33, 3, -35 },
  { 1248, 10, 14, 16, 2, -7 },
  { 1266, 15, 5, 19, 2, -18 },
  { 1276, 8, 9, 16, 4, -8 },
  { 1285, 21, 42, 22, 1, -42 },
  { 1396, 28, 43, 33, 3, -42 },
  { 1547, 17, 41, 33, 5, -41 },
  { 1635, 28, 42, 33, 3, -42 },
  { 1782, 28, 43, 33, 2, -42 },
  { 1933, 31, 42, 33, 1, -42 },
  { 2096, 27, 42, 33, 3, -41 },
  { 2238, 28, 43, 33, 3, -42 },
  { 2389, 29, 41, 33, 2, -41 },
  { 2538, 28, 43, 33, 3, -42 },
  { 2689, 27, 43, 33, 3, -42 },
  { 2835, 8, 33, 16, 4, -32 },
  { 2868, 10, 39, 16, 2, -32 },
  { 2917, 27, 30, 33, 3, -36 },
  { 3019, 27, 16, 33, 3, -28 },
  { 3073, 27, 30, 33, 3, -36 },
  { 3175, 23, 43, 26, 1, -42 },
  { 3299, 46, 47, 52, 3, -42 },
  { 3570, 38, 42, 38, 0, -42 },
  { 3770, 30, 41, 38, 5, -41 },
  { 3924, 32, 43, 37, 3, -42 },
  { 4096, 34, 41, 42, 5, -41 },
  { 4271, 23, 41, 32, 6, -41 },
  { 4389, 23, 41, 31, 6, -41 },
  { 4507, 35, 43, 42, 3, -42 },
  { 4696, 32, 41, 43, 6, -41 },
  { 4860, 16, 41, 21, 2, -41 },
  { 4942, 16, 52, 17, -4, -41 },
  { 5046, 31, 41, 37, 6, -41 },
  { 5205, 24, 41, 31, 5, -41 },
  { 5328, 42, 41, 53, 6, -41 },
  { 5544, 34, 41, 45, 6, -41 },
  { 5719, 39, 43, 45, 3, -42 },
  { 5929, 28, 41, 35, 5, -41 },
  { 6073, 39, 52, 45, 3, -42 },
  { 6327, 31, 41, 37, 5, -41 },
  { 6486, 26, 43, 32, 3, -42 },
  { 6626, 31, 41, 33, 1, -41 },
  { 6785, 33, 42, 43, 5, -41 },
  { 6959, 36, 41, 36, 0, -41 },
  { 7144, 54, 41, 55, 0, -41 },
  { 7421, 35, 41, 35, 0, -41 },
  { 7601, 34, 41, 34, 0, -41 },
  { 7776, 29, 41, 33, 2, -41 },
  { 7925, 14, 50, 19, 4, -41 },
  { 8013, 21, 42, 22, 1, -42 },
  { 8124, 14, 50, 19, 1, -41 },
  { 8212, 29, 27, 33, 2, -42 },
  { 8310, 25, 4, 25, 0, 5 },
  { 8323, 13, 9, 18, 2, -44 },
  { 8338, 26, 33, 33, 3, -32 },
  { 8446, 28, 45, 36, 5, -44 },
  { 8604, 24, 33, 28, 3, -32 },
  { 8703, 28, 45, 36, 3, -44 },
  { 8861, 27, 33, 33, 3, -32 },
  { 8973, 22, 44, 21, 1, -44 },
  { 9094, 28, 46, 36, 3, -32 },
  { 9255, 27, 44, 36, 5, -44 },
  { 9404, 7, 43, 16, 4, -43 },
  { 9442, 14, 57, 16, -3, -43 },
  { 9542, 27, 44, 32, 5, -44 },
  { 9691, 6, 44, 16, 5, -44 },
  { 9724, 45, 32, 55, 5, -32 },
  { 9904, 27, 32, 36, 5, -32 },
  { 10012, 29, 33, 35, 3, -32 },
  { 10132, 28, 46, 36, 5, -32 },
  { 10293, 28, 46, 36, 3, -32 },
  { 10454, 19, 32, 25, 5, -32 },
  { 10530, 23, 33, 28, 3, -32 },
  { 10625, 20, 39, 22, 1, -38 },
  { 10723, 28, 32, 36, 4, -31 },
  { 10835, 31, 31, 31, 0, -31 },
  { 10956, 45, 31, 47, 1, -31 },
  { 11131, 30, 31, 32, 1, -31 },
  { 11248, 31, 45, 31, 0, -31 },
  { 11423, 24, 31, 28, 2, -31 },
  { 11516, 19, 50, 22, 1, -41 },
  { 11635, 4, 58, 32, 14, -44 },
  { 11664, 19, 50, 22, 2, -41 },
  { 11783, 27, 9, 33, 3, -25 },
};

const GFXfont NotoSans_Medium58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium58pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_MEDIUM58PT7B_H_
