#ifndef _NOTOSANS_MEDIUM65PT7B_H_
#define _NOTOSANS_MEDIUM65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFC, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFB, 0xF8, 0x78, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xF3, 0xE1, 0xF8, 0xFF, 0x0F,
  0x80, 0x63, 0xF8, 0x3E, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x3E, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x3F, 0xC3, 0xE0, 0x00, 0x7F, 0xCF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xF9, 0xFF, 0x80, 0x03, 0xE1,
  0xFE, 0x00, 0x0F, 0x83, 0xFC, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0xF8, 0x1F,
  0xC0, 0x03, 0xE0, 0x7F, 0x00, 0x0F, 0x81, 0xFE, 0x00, 0x3E, 0x0F, 0xEE,
  0x00, 0xF8, 0x7F, 0xBF, 0x83, 0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x7F,
  0xC0, 0xFC, 0x03, 0xE0, 0xF8, 0x7F, 0xF8, 0x1F, 0x01, 0xF8, 0x7E, 0x3F,
  0xFF, 0x07, 0xE0, 0x7E, 0x3F, 0x0F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC7,
  0xF1, 0xFC, 0x3F, 0xFF, 0xC7, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xE1, 0xF8,
  0xFC, 0x07, 0xC1, 0xFF, 0xF0, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0xF8, 0x3F,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0x83, 0xE0, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x07, 0xFC,
  0x7F, 0xC0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x07,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0xC1, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xFD,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x40, 0x07, 0xC0, 0x04, 0xF0, 0x0F, 0x80, 0x79, 0xFE, 0x1F, 0x07, 0xF3,
  0xFF, 0xBE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE1,
  0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x08, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x0F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xBF, 0x3F, 0xE7, 0xEF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xBF, 0x07, 0xF3, 0xC0, 0xFE, 0x30, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0x80, 0x07, 0xFC, 0x1E, 0x00, 0x07, 0xF8,
  0x30, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0x00, 0x07, 0xFC, 0x18,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x40,
  0x00, 0x03, 0xFE, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE8, 0x00,
  0x00, 0xFF, 0x3C, 0x00, 0x0F, 0xFC, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0xFF, 0xFC, 0x07, 0xE7, 0xFF, 0xFE, 0x1F, 0xDF, 0xFF, 0xFE, 0x3F, 0xBF,
  0xFF, 0xFE, 0x7F, 0xFC, 0x07, 0xFC, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0x80,
  0x03, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F,
  0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x05, 0xD0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x01,
  0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD,
  0xFC, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x20,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF4,
  0x00, 0x00, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0xF3, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xE1, 0xE0, 0x07, 0x83, 0xF8, 0x7F,
  0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xE0, 0x0F, 0xF8, 0xE0, 0x00,
  0xFF, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x03, 0xE1, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x3E, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xCF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xF9, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x1F,
  0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x7F, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x07, 0xE0, 0x01,
  0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7C,
  0x00, 0x3F, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xBE, 0x01,
  0xF0, 0x00, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0xF8,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x9F, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xF3,
  0xF0, 0x0F, 0xE0, 0x7F, 0xE0, 0xFC, 0x7E, 0x01, 0xFF, 0xFF, 0xBF, 0xFF,
  0x07, 0xC0, 0x1F, 0xFF, 0xE7, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xF8, 0x7F,
  0xF8, 0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0,
  0x07, 0xFF, 0xE3, 0xF8, 0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x03,
  0xFF, 0x3F, 0x80, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xF0, 0x00, 0x1C, 0x0F,
  0xFC, 0x00, 0x00, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x80,
  0xFF, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0xC3, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0xC3, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x3F,
  0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x0F,
  0xFC, 0x00, 0x00, 0x10, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x7F,
  0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xF1, 0xFF, 0x80,
  0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x01, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0xC3, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x0F, 0xEF, 0xF8, 0x00, 0x01, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFD,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xE0,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x3F,
  0x7F, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0x7F, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0xFC, 0xFE, 0x00, 0x00, 0x7E,
  0x7F, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0x7F, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x00, 0x01, 0xF8,
  0x7F, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0xFE, 0x1F, 0x80, 0x01, 0xF8,
  0x7F, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0xFE, 0x1F, 0xC0, 0x03, 0xF0,
  0x7F, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0xFE, 0x0F, 0xC0, 0x07, 0xE0,
  0x7F, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x0F, 0xC0,
  0x7F, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x0F, 0xC0,
  0x7F, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0x80,
  0x7F, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x3F, 0x00,
  0x7F, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xE0, 0x00, 0x0F, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0xF1, 0xFE, 0x00,
  0x03, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0x00,
  0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xE0,
  0x03, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0xF8, 0x00, 0x7F, 0x83, 0xFF, 0xE0, 0x00, 0xFF, 0x0F, 0xFF, 0x80,
  0x01, 0xFE, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0xF8, 0x00, 0x0F, 0xF3,
  0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFB, 0xF8,
  0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFE, 0x0F, 0xE0,
  0x01, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x38, 0x7F, 0x80, 0x00, 0x21, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xB0, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x1F, 0xF3, 0xFF,
  0x83, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x7F, 0xC0, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x07, 0xF7, 0xFE, 0x00,
  0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFE, 0x01,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xF9, 0xF9, 0xFF, 0xFF, 0x8F,
  0xC7, 0xFF, 0xF8, 0x3E, 0x0F, 0xFF, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x00, 0xFE, 0x0F, 0xFE, 0x00,
  0xFE, 0x3F, 0xFF, 0x80, 0xFE, 0x7F, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFC,
  0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFC,
  0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F, 0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0x80,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xE0, 0xFF, 0x80, 0x04, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0x87, 0xFF, 0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x7F, 0x00, 0x7F, 0xF0,
  0x7F, 0x01, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xFF,
  0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0x1F, 0xE0, 0x03,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFC,
  0x3F, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0x03, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF8, 0x08, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x03, 0xFF,
  0xFE, 0x3F, 0x07, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0xBF, 0x1F, 0xF8,
  0x0F, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x7F, 0x03, 0xFF,
  0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x07,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x10, 0x00, 0x01, 0xFE, 0x1C, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0x3F, 0x83, 0xFF, 0xC0,
  0x7F, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xF1, 0xFD, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x00, 0x3F, 0xDF,
  0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x40, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0x80, 0x1C, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0x1F, 0xC0,
  0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x1F, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xF0, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xEF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0x07, 0xE3,
  0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE,
  0x03, 0xFF, 0x7F, 0xF0, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0x00,
  0x03, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0x00,
  0xFC, 0x3F, 0xFF, 0x80, 0xFC, 0x7F, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFC,
  0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xC0, 0x03, 0xFC,
  0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x80,
  0xFE, 0x0F, 0xFE, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0xFE, 0x3F,
  0x07, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF,
  0x1F, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xFE, 0x7F,
  0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x07, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF3, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xBF, 0x0F, 0xFE, 0xFC,
  0x7F, 0xFB, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xF8,
  0x01, 0xE3, 0xF8, 0x00, 0x08, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xB8, 0x00, 0x0F, 0xEF, 0xC0, 0x0F, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x10, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xFC, 0xFC, 0x3F, 0xFF, 0xE1,
  0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0xFD, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xE7, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x80, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x0F, 0xC1,
  0xFC, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x3F,
  0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0x80, 0x1F, 0x9F, 0x80, 0x01, 0xF9,
  0xF0, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x3F, 0xF8, 0x00, 0x04,
  0xFF, 0xFC, 0x00, 0x1B, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x80,
  0x00, 0x7F, 0xF1, 0x00, 0x00, 0x17, 0x00,
};

const GFXglyph NotoSans_Medium65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 9, 47, 18, 4, -46 },
  { 54, 20, 16, 28, 4, -46 },
  { 94, 38, 46, 42, 2, -46 },
  { 313, 30, 53, 37, 4, -49 },
  { 512, 50, 48, 55, 3, -47 },
  { 812, 45, 48, 48, 3, -47 },
  { 1082, 7, 16, 15, 4, -46 },
  { 1096, 15, 56, 20, 3, -46 },
  { 1201, 16, 56, 20, 2, -46 },
  { 1313, 31, 29, 36, 2, -49 },
  { 1426, 31, 32, 37, 3, -39 },
  { 1550, 11, 16, 18, 2, -8 },
  { 1572, 17, 6, 21, 2, -20 },
  { 1585, 9, 10, 18, 4, -9 },
  { 1597, 23, 47, 25, 1, -47 },
  { 1733, 31, 48, 37, 3, -47 },
  { 1919, 19, 46, 37, 5, -46 },
  { 2029, 31, 47, 37, 3, -47 },
  { 2212, 31, 48, 37, 3, -47 },
  { 2398, 35, 47, 37, 1, -47 },
  { 2604, 30, 47, 37, 4, -46 },
  { 2781, 31, 48, 37, 3, -47 },
  { 2967, 31, 46, 37, 3, -46 },
  { 3146, 31, 48, 37, 3, -47 },
  { 3332, 31, 48, 37, 3, -47 },
  { 3518, 9, 37, 18, 4, -36 },
  { 3560, 11, 44, 18, 2, -36 },
  { 3621, 31, 33, 37, 3, -40 },
  { 3749, 31, 18, 37, 3, -32 },
  { 3819, 31, 33, 37, 3, -40 },
  { 3947, 26, 48, 29, 1, -47 },
  { 4103, 51, 53, 58, 4, -47 },
  { 4441, 43, 47, 43, 0, -47 },
  { 4694, 33, 46, 43, 6, -46 },
  { 4884, 35, 48, 41, 4, -47 },
  { 5094, 38, 46, 48, 6, -46 },
  { 5313, 26, 46, 36, 6, -46 },
  { 5463, 26, 46, 34, 6, -46 },
  { 5613, 38, 48, 47, 4, -47 },
  { 5841, 36, 46, 49, 6, -46 },
  { 6048, 18, 46, 23, 2, -46 },
  { 6152, 18, 59, 19, -5, -46 },
  { 6285, 35, 46, 41, 6, -46 },
  { 6487, 27, 46, 35, 6, -46 },
  { 6643, 48, 46, 60, 6, -46 },
  { 6919, 38, 46, 50, 6, -46 },
  { 7138, 43, 48, 51, 4, -47 },
  { 7396, 30, 46, 40, 6, -46 },
  { 7569, 43, 58, 51, 4, -47 },
  { 7881, 34, 46, 41, 6, -46 },
  { 8077, 30, 48, 36, 3, -47 },
  { 8257, 35, 46, 37, 1, -46 },
  { 8459, 36, 47, 48, 6, -46 },
  { 8671, 40, 46, 40, 0, -46 },
  { 8901, 60, 46, 61, 1, -46 },
  { 9246, 39, 46, 40, 0, -46 },
  { 9471, 38, 46, 38, 0, -46 },
  { 9690, 33, 46, 37, 2, -46 },
  { 9880, 15, 56, 21, 5, -46 },
  { 9985, 23, 47, 25, 1, -47 },
  { 10121, 14, 56, 21, 2, -46 },
  { 10219, 33, 30, 37, 2, -47 },
  { 10343, 28, 4, 28, 0, 6 },
  { 10357, 14, 11, 20, 3, -50 },
  { 10377, 29, 37, 37, 3, -36 },
  { 10512, 32, 50, 40, 5, -49 },
  { 10712, 27, 37, 32, 3, -36 },
  { 10837, 32, 50, 40, 3, -49 },
  { 11037, 31, 37, 37, 3, -36 },
  { 11181, 25, 50, 23, 1, -50 },
  { 11338, 32, 52, 40, 3, -36 },
  { 11546, 31, 49, 41, 5, -49 },
  { 11736, 8, 48, 18, 5, -48 },
  { 11784, 17, 64, 18, -4, -48 },
  { 11920, 31, 49, 36, 5, -49 },
  { 12110, 7, 49, 18, 5, -49 },
  { 12153, 51, 36, 62, 5, -36 },
  { 12383, 31, 36, 41, 5, -36 },
  { 12523, 33, 37, 40, 3, -36 },
  { 12676, 32, 52, 40, 5, -36 },
  { 12884, 32, 52, 40, 3, -36 },
  { 13092, 22, 36, 28, 5, -36 },
  { 13191, 26, 37, 32, 3, -36 },
  { 13312, 22, 44, 25, 1, -43 },
  { 13433, 30, 36, 41, 5, -35 },
  { 13568, 34, 35, 34, 0, -35 },
  { 13717, 51, 35, 52, 1, -35 },
  { 13941, 33, 35, 35, 1, -35 },
  { 14086, 34, 51, 34, 0, -35 },
  { 14303, 27, 35, 31, 2, -35 },
  { 14422, 21, 56, 25, 2, -46 },
  { 14569, 6, 64, 36, 15, -49 },
  { 14617, 21, 56, 25, 2, -46 },
  { 14764, 31, 10, 37, 3, -28 },
};

const GFXfont NotoSans_Medium65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium65pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_MEDIUM65PT7B_H_
