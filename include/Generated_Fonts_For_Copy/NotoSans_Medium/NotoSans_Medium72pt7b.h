#ifndef _NOTOSANS_MEDIUM72PT7B_H_
#define _NOTOSANS_MEDIUM72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0xF8, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF8, 0xF8, 0x3F, 0x07, 0xF8, 0x3E, 0x01, 0xC3, 0xFC, 0x0F, 0x80,
  0x00, 0xFF, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x0F, 0xF0, 0x3E,
  0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0x3F, 0xE0,
  0xF8, 0x00, 0x07, 0xFC, 0x3E, 0x00, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x0F,
  0x83, 0xFE, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x00, 0xF8, 0x0F, 0xE0, 0x00,
  0x3E, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0x80,
  0x00, 0xF8, 0x0F, 0xE8, 0x00, 0x3E, 0x07, 0xFB, 0xC0, 0x0F, 0x83, 0xFE,
  0xFF, 0x03, 0xE7, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x3F, 0xF0, 0x1F,
  0x80, 0x7F, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x87, 0xFF,
  0xF0, 0x7F, 0x01, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7E, 0x07, 0xF0, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF,
  0x87, 0xE1, 0xFC, 0x0F, 0xE1, 0xFF, 0xFE, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1,
  0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFF, 0xE0, 0xFE, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x81, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0x81, 0xFF, 0xC7, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x87, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xE7,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xFB, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x19, 0xF0, 0x0F, 0x80,
  0x7E, 0xFF, 0xC3, 0xE0, 0xFF, 0xBF, 0xFE, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC,
  0x3F, 0x87, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x1F, 0xEF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x8F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0xFF, 0xBF, 0xDF, 0xF1, 0xFF, 0xFF, 0x0F, 0xF7, 0xF0,
  0x7F, 0x9F, 0x03, 0xFC, 0xF0, 0x1F, 0xE2, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0x1F,
  0xE0, 0x30, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE0, 0xFE,
  0x00, 0x0F, 0xFC, 0x1E, 0x00, 0x01, 0xFF, 0x06, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0xF0, 0x00, 0x01, 0xFF, 0xBF, 0x80, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF3, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFC, 0xFF, 0xFF, 0x02, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xA0, 0x00,
  0x00, 0x7F, 0xDE, 0x00, 0x00, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x60, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0x87, 0xFF,
  0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0x83, 0xF9, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF,
  0x3F, 0x80, 0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0xE0, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xF7, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1E, 0x1F, 0xCF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3E, 0x00, 0x03, 0x80,
  0x7F, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF0, 0x7F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0xCF, 0xC0,
  0x03, 0xFE, 0x38, 0x00, 0x0F, 0xF9, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x7E, 0x0F,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xFF, 0x1F, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF8,
  0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xF9, 0xF8,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x80,
  0x7F, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x7D, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0x9F, 0x80, 0x3F, 0x00, 0x0F,
  0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xE7, 0xE0, 0x07,
  0xF0, 0x0F, 0xFC, 0x07, 0xE1, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0x07, 0xF0,
  0xFC, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xC0, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x07,
  0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xEF,
  0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xF0, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xC0,
  0x00, 0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFE,
  0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xDF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x7F, 0xFE, 0xFE, 0x00, 0x00,
  0x07, 0xF7, 0xFF, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0xFE, 0x7F, 0x00,
  0x00, 0x0F, 0xE7, 0xFF, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0xFE, 0x7F,
  0x00, 0x00, 0x0F, 0xC7, 0xFF, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0xFE,
  0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xFF, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0x7F,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xFF, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x00, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x7F,
  0x80, 0x00, 0x07, 0xFF, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0xF3, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x9F, 0xF0, 0x00, 0x07,
  0xFF, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFF, 0xE0, 0x00, 0x07, 0xFD, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x00,
  0xFF, 0xF9, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x01, 0xFF,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFC,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x18, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x1F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFD, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xFC, 0x07, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x00,
  0x07, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xEF, 0xE7, 0xFF, 0xFF, 0xE7, 0xF1, 0xFF, 0xFF, 0xE3, 0xF8, 0x7F,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xFF,
  0x80, 0x1F, 0xC1, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0x3F,
  0xFF, 0xFE, 0x0F, 0xEF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x3F,
  0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFB, 0xFF, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0xFE, 0x0F, 0xC3,
  0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7C, 0x1F, 0xF0, 0x00,
  0x21, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x10, 0xFF, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xEF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x01,
  0xFF, 0xF9, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xEF, 0xF8,
  0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0xF8,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x07, 0xFF,
  0x00, 0x07, 0xC0, 0xFF, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xC0, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0x81,
  0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0xFF, 0xDF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0xE7, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xC0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xC7,
  0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x10, 0x00, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x3F,
  0xF0, 0x7F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0x83, 0xFF, 0xFC,
  0x0F, 0xE3, 0xFF, 0xFF, 0x83, 0xF9, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFC, 0x0C, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFC, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x81, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE,
  0x7F, 0xC0, 0x00, 0x3F, 0xBF, 0xF0, 0x00, 0x0F, 0xEF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x38, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x1F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x0F, 0xE7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xF7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0xFF,
  0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xE0, 0x0F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0x1F, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0xC1, 0xFD, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x01, 0xFF,
  0x1F, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF,
  0xFF, 0x0F, 0xE7, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0xFF, 0xF0, 0x3F, 0x87,
  0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0x81,
  0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0xFF, 0xDF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0xE7, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xC0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0x87,
  0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x31, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF8, 0xFF, 0xCF, 0xF8, 0x00, 0x78, 0xFF, 0x00, 0x00, 0x8F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0x80,
  0x03, 0xFE, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF,
  0xFF, 0x8F, 0xC0, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x3F, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x23, 0xFF,
  0xF8, 0x00, 0x1D, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF7, 0x00, 0x03, 0xFF, 0xFC, 0xC0, 0x00, 0x1F, 0xFE, 0x10, 0x00, 0x00,
  0x1E, 0x00,
};

const GFXglyph NotoSans_Medium72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 10, 52, 20, 5, -51 },
  { 66, 21, 18, 31, 5, -51 },
  { 114, 43, 51, 47, 2, -51 },
  { 389, 34, 59, 41, 4, -55 },
  { 640, 55, 53, 61, 3, -52 },
  { 1005, 49, 53, 53, 4, -52 },
  { 1330, 7, 18, 17, 5, -51 },
  { 1346, 17, 62, 22, 3, -51 },
  { 1478, 18, 62, 22, 2, -51 },
  { 1618, 34, 33, 39, 3, -55 },
  { 1759, 35, 35, 41, 3, -43 },
  { 1913, 11, 17, 20, 3, -8 },
  { 1937, 18, 7, 23, 3, -23 },
  { 1953, 10, 10, 20, 5, -9 },
  { 1966, 26, 52, 28, 1, -52 },
  { 2135, 35, 53, 41, 3, -52 },
  { 2367, 21, 51, 41, 6, -51 },
  { 2501, 35, 52, 41, 3, -52 },
  { 2729, 34, 53, 41, 3, -52 },
  { 2955, 39, 52, 41, 1, -52 },
  { 3209, 33, 52, 41, 4, -51 },
  { 3424, 34, 53, 41, 4, -52 },
  { 3650, 35, 51, 41, 3, -51 },
  { 3874, 35, 53, 41, 3, -52 },
  { 4106, 35, 53, 41, 3, -52 },
  { 4338, 10, 41, 20, 5, -40 },
  { 4390, 13, 49, 20, 2, -40 },
  { 4470, 35, 36, 41, 3, -44 },
  { 4628, 33, 20, 41, 4, -35 },
  { 4711, 35, 36, 41, 3, -44 },
  { 4869, 29, 53, 32, 1, -52 },
  { 5062, 57, 58, 65, 4, -52 },
  { 5476, 47, 52, 47, 0, -52 },
  { 5782, 36, 51, 47, 7, -51 },
  { 6012, 39, 53, 46, 4, -52 },
  { 6271, 41, 51, 53, 7, -51 },
  { 6533, 29, 51, 40, 7, -51 },
  { 6718, 29, 51, 38, 7, -51 },
  { 6903, 43, 53, 52, 4, -52 },
  { 7188, 40, 51, 54, 7, -51 },
  { 7443, 20, 51, 25, 3, -51 },
  { 7571, 20, 65, 21, -6, -51 },
  { 7734, 39, 51, 46, 7, -51 },
  { 7983, 30, 51, 38, 7, -51 },
  { 8175, 52, 51, 66, 7, -51 },
  { 8507, 42, 51, 56, 7, -51 },
  { 8775, 48, 53, 56, 4, -52 },
  { 9093, 33, 51, 44, 7, -51 },
  { 9304, 48, 64, 56, 4, -52 },
  { 9688, 38, 51, 46, 7, -51 },
  { 9931, 32, 53, 40, 4, -52 },
  { 10143, 39, 51, 40, 1, -51 },
  { 10392, 41, 52, 53, 6, -51 },
  { 10659, 44, 51, 44, 0, -51 },
  { 10940, 66, 51, 68, 1, -51 },
  { 11361, 44, 51, 44, 0, -51 },
  { 11642, 42, 51, 42, 0, -51 },
  { 11910, 37, 51, 41, 2, -51 },
  { 12146, 16, 62, 24, 6, -51 },
  { 12270, 26, 52, 28, 1, -52 },
  { 12439, 16, 62, 24, 2, -51 },
  { 12563, 37, 33, 41, 2, -52 },
  { 12716, 31, 5, 31, 0, 6 },
  { 12736, 16, 11, 22, 3, -55 },
  { 12758, 33, 40, 41, 3, -39 },
  { 12923, 35, 56, 45, 6, -55 },
  { 13168, 29, 41, 35, 4, -40 },
  { 13317, 35, 56, 45, 4, -55 },
  { 13562, 34, 41, 41, 4, -40 },
  { 13737, 28, 55, 26, 1, -55 },
  { 13930, 35, 57, 45, 4, -40 },
  { 14180, 34, 55, 45, 6, -55 },
  { 14414, 9, 54, 19, 5, -54 },
  { 14475, 18, 71, 19, -4, -54 },
  { 14635, 34, 55, 40, 6, -55 },
  { 14869, 8, 55, 19, 6, -55 },
  { 14924, 57, 40, 68, 6, -40 },
  { 15209, 34, 40, 45, 6, -40 },
  { 15379, 36, 41, 44, 4, -40 },
  { 15564, 35, 57, 45, 6, -40 },
  { 15814, 35, 57, 45, 4, -40 },
  { 16064, 23, 40, 30, 6, -40 },
  { 16179, 28, 41, 35, 4, -40 },
  { 16323, 25, 49, 28, 1, -48 },
  { 16477, 34, 40, 45, 5, -39 },
  { 16647, 38, 39, 38, 0, -39 },
  { 16833, 56, 39, 58, 1, -39 },
  { 17106, 37, 39, 39, 1, -39 },
  { 17287, 38, 56, 38, 0, -39 },
  { 17553, 29, 39, 34, 3, -39 },
  { 17695, 23, 62, 28, 2, -51 },
  { 17874, 6, 72, 40, 17, -55 },
  { 17928, 24, 62, 28, 2, -51 },
  { 18114, 35, 10, 41, 3, -30 },
};

const GFXfont NotoSans_Medium72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium72pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_MEDIUM72PT7B_H_
