#ifndef _NOTOSANS_MEDIUM69PT7B_H_
#define _NOTOSANS_MEDIUM69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x00, 0xFF, 0x03,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC7,
  0xC0, 0xF8, 0xFF, 0x07, 0xC0, 0x18, 0xFF, 0x07, 0xC0, 0x00, 0xFE, 0x07,
  0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0xFE, 0x07,
  0xC0, 0x00, 0xFF, 0x07, 0xC0, 0x00, 0xFF, 0x87, 0xC0, 0x00, 0x7F, 0xC7,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xC7, 0xFE, 0x00, 0x07,
  0xC1, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x07,
  0xC0, 0x7F, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x07,
  0xC0, 0xFF, 0xC0, 0x07, 0xC1, 0xFE, 0xF8, 0x07, 0xC3, 0xFE, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x3F,
  0xC0, 0x3E, 0x00, 0xFC, 0x3F, 0x87, 0xFF, 0x81, 0xF8, 0x0F, 0xC1, 0xF8,
  0x7F, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0x07, 0xF0,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF,
  0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0xFF, 0x87, 0xE1, 0xF8, 0x07, 0xE0,
  0xFF, 0xF8, 0x3F, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0x83, 0xF0, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xFC,
  0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFF,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x60, 0x07, 0xC0, 0x06, 0xFC, 0x07, 0xC0, 0x7E,
  0xFF, 0xC7, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xF7, 0xF7, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0x7E, 0x0F, 0xF3, 0xC0, 0xFF, 0x30, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0x00, 0x03,
  0xFE, 0x0F, 0x00, 0x00, 0xFF, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7E, 0x00, 0x0F, 0xF8,
  0x1C, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x40, 0x00, 0x00, 0xFF, 0xB0, 0x00, 0x00, 0xFF,
  0x9F, 0x80, 0x01, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x07, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x80, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x1F,
  0xF8, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x40, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0x0F, 0xFF, 0xE0, 0x1F, 0xC7,
  0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0xF0, 0x7E,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xF3,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0xC7,
  0xFF, 0xFF, 0xEF, 0xE3, 0xFF, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xF3, 0xF8,
  0x1F, 0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xF8, 0xF8, 0x07, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF,
  0xE7, 0xE0, 0x01, 0xFE, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0x87, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x3F,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xE7, 0xE0, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x3F, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFD, 0xF0, 0x07, 0xE0,
  0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xFF, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3E, 0xFC,
  0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x07,
  0xCF, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0xC1, 0xF8, 0xFC, 0x01, 0xFF, 0xBF, 0xDF, 0xDF, 0xE1, 0xF8, 0x03, 0xFF,
  0xFE, 0x7F, 0xFF, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0x80,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xEF,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x87, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF4, 0x07, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x05,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0x3F,
  0x80, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x1F,
  0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xC0,
  0x00, 0x3F, 0x87, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFB, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x01,
  0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xE3, 0xF8,
  0x00, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0xFF, 0x7F, 0x00, 0x00, 0x03,
  0xF7, 0xFF, 0xDF, 0xC0, 0x00, 0x01, 0xFD, 0xFF, 0xF3, 0xF0, 0x00, 0x00,
  0x7E, 0x7F, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xFF, 0x3F, 0x80, 0x00,
  0x0F, 0xC7, 0xFF, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xFF, 0xF1, 0xFC, 0x00,
  0x01, 0xFC, 0x7F, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xFF, 0x0F, 0xE0,
  0x00, 0x1F, 0x87, 0xFF, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7F, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xFF, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xFF,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFF,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xF7,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFD, 0xFE, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xFC, 0x00, 0x03, 0xFC,
  0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xF9, 0xFE, 0x00,
  0x0F, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x7F, 0xFC, 0x3F, 0xF0, 0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x18,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x01, 0xFE,
  0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x03, 0xFF, 0x01, 0xC0, 0x01, 0xFE, 0x02, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xE7, 0xFE, 0x00,
  0x1F, 0xDF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC,
  0xFF, 0xFF, 0xF9, 0xF8, 0xFF, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x07, 0xE0,
  0x7F, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x1F,
  0xFE, 0x00, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0xF8, 0x3F, 0xBF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC7, 0xFF,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xCF, 0xFC, 0x00,
  0x3F, 0xE7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0xF0, 0x7E, 0x3F, 0xFF, 0xF0, 0x3F, 0x0F,
  0xFF, 0xF0, 0x1F, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xC3,
  0xFF, 0x00, 0x0C, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x23,
  0xFF, 0x00, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0x03, 0xFF,
  0xFE, 0x3F, 0x83, 0xFF, 0xFF, 0x9F, 0xC3, 0xFF, 0xFF, 0xEF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF,
  0xFF, 0xBF, 0x83, 0xFF, 0xFF, 0x8F, 0xC0, 0x7F, 0xFF, 0x07, 0xE0, 0x1F,
  0xFF, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x1F,
  0xF8, 0x00, 0x1C, 0x1F, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0x87, 0xE0, 0xFF, 0xFF, 0xE3, 0xF0, 0xFF,
  0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xFE, 0x7F,
  0xE0, 0x07, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xE7, 0xF0, 0x1F,
  0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0xC1, 0xFC, 0x00, 0x1C, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0xC0, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x0F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xC0, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFE, 0x7F, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x3E, 0x3F, 0xBF,
  0xDF, 0xFF, 0xFF, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x3D, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0x00, 0x14, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x07, 0xFC,
  0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0xE0,
  0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xC3, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x3F, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0xFF, 0xE0, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFC, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFC, 0x1F, 0xFE, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0x0F, 0xFF, 0xF0, 0x1F, 0x8F,
  0xFF, 0xFE, 0x0F, 0xCF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x0F, 0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xFF,
  0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xFC, 0x1F, 0xCF,
  0xFF, 0xFC, 0x0F, 0xE3, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0xF8, 0x03, 0xF8,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0x87, 0xE0, 0xFF, 0xFF,
  0xE3, 0xF0, 0xFF, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0,
  0x3F, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x1F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF,
  0xE7, 0xF0, 0x1F, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xC1, 0xFC, 0x00, 0x3C,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0x87, 0xF0, 0x00, 0x18, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0xC0, 0x00, 0x0F, 0xEF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0x87, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x1F, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xC3, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0x87, 0xF0,
  0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF7, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xDF, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF3, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE1, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x03,
  0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xF7, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x06,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x8F, 0xFF, 0xC0, 0x00, 0xDF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFD, 0xC0, 0x01, 0xFF, 0xFC, 0x80, 0x00, 0x1F, 0xFC, 0x40,
  0x00, 0x00, 0x40, 0x00,
};

const GFXglyph NotoSans_Medium69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 50, 19, 5, -49 },
  { 58, 21, 18, 30, 4, -49 },
  { 106, 41, 49, 45, 2, -49 },
  { 358, 32, 56, 39, 4, -52 },
  { 582, 53, 51, 59, 3, -50 },
  { 920, 48, 51, 51, 3, -50 },
  { 1226, 8, 18, 16, 4, -49 },
  { 1244, 16, 60, 22, 3, -49 },
  { 1364, 17, 60, 22, 2, -49 },
  { 1492, 32, 31, 38, 3, -52 },
  { 1616, 33, 33, 39, 3, -41 },
  { 1753, 11, 17, 19, 3, -8 },
  { 1777, 17, 7, 22, 3, -22 },
  { 1792, 9, 10, 19, 5, -9 },
  { 1804, 25, 49, 27, 1, -49 },
  { 1958, 33, 51, 39, 3, -50 },
  { 2169, 20, 49, 39, 6, -49 },
  { 2292, 33, 50, 39, 3, -50 },
  { 2499, 33, 51, 39, 3, -50 },
  { 2710, 37, 49, 39, 1, -49 },
  { 2937, 32, 50, 39, 4, -49 },
  { 3137, 34, 51, 39, 3, -50 },
  { 3354, 33, 49, 39, 3, -49 },
  { 3557, 33, 51, 39, 3, -50 },
  { 3768, 33, 51, 39, 3, -50 },
  { 3979, 9, 39, 19, 5, -38 },
  { 4023, 12, 47, 19, 2, -38 },
  { 4094, 33, 34, 39, 3, -42 },
  { 4235, 32, 19, 39, 4, -34 },
  { 4311, 33, 34, 39, 3, -42 },
  { 4452, 28, 51, 31, 1, -50 },
  { 4631, 54, 55, 62, 4, -49 },
  { 5003, 45, 49, 45, 0, -49 },
  { 5279, 36, 49, 45, 6, -49 },
  { 5500, 38, 51, 44, 4, -50 },
  { 5743, 40, 49, 50, 6, -49 },
  { 5988, 27, 49, 38, 7, -49 },
  { 6154, 27, 49, 36, 7, -49 },
  { 6320, 41, 51, 50, 4, -50 },
  { 6582, 38, 49, 52, 7, -49 },
  { 6815, 19, 49, 24, 3, -49 },
  { 6932, 19, 63, 20, -5, -49 },
  { 7082, 37, 49, 44, 7, -49 },
  { 7309, 29, 49, 37, 6, -49 },
  { 7487, 50, 49, 63, 7, -49 },
  { 7794, 40, 49, 54, 7, -49 },
  { 8039, 46, 51, 54, 4, -50 },
  { 8333, 33, 49, 42, 6, -49 },
  { 8536, 46, 62, 54, 4, -50 },
  { 8893, 37, 49, 44, 6, -49 },
  { 9120, 32, 51, 38, 3, -50 },
  { 9324, 37, 49, 39, 1, -49 },
  { 9551, 39, 50, 51, 6, -49 },
  { 9795, 42, 49, 42, 0, -49 },
  { 10053, 63, 49, 65, 1, -49 },
  { 10439, 42, 49, 42, 0, -49 },
  { 10697, 40, 49, 40, 0, -49 },
  { 10942, 35, 49, 40, 2, -49 },
  { 11157, 16, 60, 23, 5, -49 },
  { 11277, 25, 49, 27, 1, -49 },
  { 11431, 15, 60, 23, 2, -49 },
  { 11544, 35, 32, 39, 2, -50 },
  { 11684, 30, 5, 30, 0, 6 },
  { 11703, 15, 11, 21, 3, -53 },
  { 11724, 31, 39, 39, 3, -38 },
  { 11876, 33, 53, 43, 6, -52 },
  { 12095, 28, 39, 34, 4, -38 },
  { 12232, 33, 53, 43, 4, -52 },
  { 12451, 32, 39, 40, 4, -38 },
  { 12607, 27, 53, 25, 1, -53 },
  { 12786, 33, 55, 43, 4, -38 },
  { 13013, 32, 52, 43, 6, -52 },
  { 13221, 9, 51, 19, 5, -51 },
  { 13279, 18, 68, 19, -4, -51 },
  { 13432, 32, 52, 39, 6, -52 },
  { 13640, 7, 52, 19, 6, -52 },
  { 13686, 54, 38, 65, 6, -38 },
  { 13943, 32, 38, 43, 6, -38 },
  { 14095, 35, 39, 42, 4, -38 },
  { 14266, 33, 55, 43, 6, -38 },
  { 14493, 33, 55, 43, 4, -38 },
  { 14720, 22, 38, 29, 6, -38 },
  { 14825, 28, 39, 34, 3, -38 },
  { 14962, 24, 47, 26, 1, -46 },
  { 15103, 33, 38, 43, 5, -37 },
  { 15260, 36, 37, 36, 0, -37 },
  { 15427, 54, 37, 56, 1, -37 },
  { 15677, 36, 37, 37, 1, -37 },
  { 15844, 36, 54, 36, 0, -37 },
  { 16087, 28, 37, 33, 2, -37 },
  { 16217, 22, 60, 27, 2, -49 },
  { 16382, 6, 68, 38, 16, -52 },
  { 16433, 23, 60, 27, 2, -49 },
  { 16606, 33, 10, 39, 3, -29 },
};

const GFXfont NotoSans_Medium69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium69pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_MEDIUM69PT7B_H_
