#ifndef _NOTOSANS_MEDIUM14PT7B_H_
#define _NOTOSANS_MEDIUM14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0xF0, 0x99, 0x99, 0x1B, 0x09, 0x04, 0x8F, 0xF1, 0x21,
  0xA3, 0xFC, 0x48, 0x24, 0x16, 0x00, 0x20, 0x8F, 0xE8, 0xA3, 0xC1, 0xC9,
  0xA7, 0xF2, 0x08, 0xE1, 0x24, 0xC9, 0x22, 0x50, 0x95, 0xFA, 0x90, 0xA4,
  0x49, 0x32, 0x48, 0x70, 0x78, 0x26, 0x13, 0x0F, 0x03, 0x06, 0xCE, 0x35,
  0x0E, 0xC7, 0x3C, 0xC0, 0xF0, 0x6B, 0x49, 0x24, 0x99, 0x30, 0xC6, 0x22,
  0x33, 0x33, 0x32, 0x6C, 0x30, 0x8A, 0x7F, 0x33, 0x64, 0x80, 0x30, 0xCF,
  0xFF, 0x30, 0xC0, 0xFA, 0xE0, 0xF0, 0x08, 0xC4, 0x23, 0x11, 0x88, 0x46,
  0x00, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xE0, 0x37, 0xD1, 0x11,
  0x11, 0x11, 0x7A, 0x30, 0xC3, 0x08, 0x63, 0x18, 0xC3, 0xF0, 0xFA, 0x30,
  0xC3, 0x78, 0x70, 0x41, 0x8F, 0xE0, 0x04, 0x0C, 0x14, 0x34, 0x24, 0x44,
  0xC4, 0xFF, 0x04, 0x04, 0xFF, 0x0C, 0x30, 0xF8, 0x30, 0x41, 0x8F, 0xE0,
  0x3D, 0x8C, 0x20, 0xFF, 0x18, 0x61, 0xCD, 0xE0, 0xFC, 0x10, 0xC2, 0x18,
  0x43, 0x0C, 0x21, 0x80, 0x7B, 0x38, 0x73, 0x79, 0xE8, 0x61, 0x8D, 0xE0,
  0x7B, 0x38, 0x61, 0x8F, 0xF0, 0x43, 0x1B, 0xC0, 0xF0, 0x0F, 0x6C, 0x00,
  0x1A, 0x58, 0x04, 0x33, 0xB0, 0xC0, 0xE0, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0x07, 0x03, 0x0D, 0xCC, 0x00, 0xFA, 0x30, 0xC3, 0x18, 0xC2, 0x00, 0x20,
  0xC0, 0x1F, 0x04, 0x19, 0x01, 0x4F, 0xB9, 0x13, 0x26, 0x64, 0xDC, 0xFE,
  0xC0, 0x08, 0x00, 0xFC, 0x00, 0x0C, 0x0E, 0x05, 0x06, 0xC3, 0x21, 0x11,
  0xFC, 0xC2, 0x41, 0xE0, 0xC0, 0xFD, 0x8F, 0x0E, 0x3F, 0xD8, 0xF0, 0xE1,
  0xC7, 0xF8, 0x3E, 0xC7, 0x06, 0x08, 0x10, 0x30, 0x60, 0x62, 0x7C, 0xFC,
  0xC6, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC6, 0xFC, 0xFF, 0x0C, 0x30,
  0xFF, 0x0C, 0x30, 0xC3, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0xFC, 0x30, 0xC3,
  0x00, 0x3F, 0x61, 0xC0, 0xC0, 0x80, 0x8F, 0xC1, 0xC1, 0x61, 0x3F, 0xC1,
  0xC1, 0xC1, 0xC1, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xE9, 0x24, 0x92,
  0x5C, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC0, 0xC3, 0xC4, 0xCC, 0xD8,
  0xF0, 0xF8, 0xC8, 0xCC, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xF0, 0xE0, 0xFC, 0x1F, 0x87, 0xF8, 0xBD, 0x17, 0xA6, 0xF6, 0x9E,
  0x53, 0xCE, 0x78, 0x8C, 0xC1, 0xF0, 0xFC, 0x7A, 0x3D, 0x9E, 0x6F, 0x17,
  0x8F, 0xC3, 0xE1, 0xC0, 0x3E, 0x31, 0xB0, 0x78, 0x38, 0x0C, 0x07, 0x07,
  0x83, 0x63, 0x1F, 0x00, 0xFD, 0x9F, 0x1E, 0x3C, 0x7F, 0xB0, 0x60, 0xC1,
  0x80, 0x3E, 0x31, 0xB0, 0x78, 0x38, 0x0C, 0x07, 0x07, 0x83, 0x63, 0x1F,
  0x01, 0x80, 0x70, 0xFC, 0xC6, 0xC6, 0xC6, 0xCC, 0xF8, 0xCC, 0xCC, 0xC6,
  0xC3, 0x7F, 0x18, 0x30, 0x70, 0xE0, 0xC1, 0x8F, 0xE0, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC3, 0x63, 0x3E, 0xC1, 0xA0, 0x90, 0xCC, 0x42, 0x21, 0x30,
  0xD0, 0x28, 0x1C, 0x0C, 0x00, 0xC2, 0x1A, 0x38, 0xD1, 0x44, 0xCA, 0x26,
  0x5B, 0x16, 0x58, 0xA2, 0x85, 0x14, 0x38, 0xE0, 0x83, 0x00, 0xC3, 0x31,
  0x09, 0x83, 0x81, 0x80, 0xE0, 0xD0, 0x4C, 0x63, 0x61, 0xC0, 0xC3, 0x42,
  0x66, 0x24, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0x06, 0x04, 0x0C,
  0x18, 0x10, 0x30, 0x60, 0x40, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x70, 0xC2,
  0x10, 0xC2, 0x18, 0x42, 0x18, 0x40, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0x18, 0x18, 0x2C, 0x24, 0x66, 0xC3, 0xFC, 0x88, 0x80, 0x33, 0xF0, 0xCF,
  0xEE, 0x38, 0xFD, 0xC1, 0x83, 0x06, 0xCF, 0xD8, 0xF1, 0xE3, 0xC7, 0x8E,
  0xF0, 0x3B, 0xF1, 0x08, 0x43, 0x2F, 0x06, 0x0C, 0x19, 0xBF, 0xF8, 0xE1,
  0xC3, 0x87, 0x9D, 0xF8, 0x31, 0xBC, 0x7F, 0xFE, 0x0C, 0x5F, 0x1C, 0xE2,
  0x1E, 0xF9, 0x86, 0x18, 0x61, 0x86, 0x00, 0x37, 0xFF, 0x1C, 0x38, 0x70,
  0xF1, 0xBF, 0x06, 0x0B, 0xF0, 0xC1, 0x83, 0x06, 0xCF, 0xD8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0xCF, 0xFF, 0xF0, 0x30, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xE0, 0xC1, 0x83, 0x06, 0x3C, 0xDB, 0x3C, 0x78, 0xD9, 0x9B, 0x18, 0xFF,
  0xFF, 0xFC, 0x98, 0xDF, 0xFF, 0x18, 0xE2, 0x1C, 0x43, 0x88, 0x71, 0x0E,
  0x21, 0x99, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x38, 0xFB, 0x1C, 0x38,
  0x70, 0xF1, 0x3C, 0x99, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xFE, 0xC1, 0x83,
  0x00, 0x37, 0xFF, 0x1C, 0x38, 0x70, 0xF3, 0xBF, 0x06, 0x0C, 0x18, 0x9D,
  0xF1, 0x8C, 0x63, 0x18, 0x76, 0xE1, 0xC3, 0x86, 0x3E, 0x23, 0xFE, 0xC6,
  0x31, 0x8C, 0x38, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xBF, 0xC3, 0x8D,
  0x1B, 0x22, 0xC5, 0x0E, 0x0C, 0xC4, 0x38, 0xCD, 0x29, 0xA5, 0x26, 0xB4,
  0x73, 0x8C, 0x61, 0x8C, 0xC2, 0xCC, 0xB1, 0xC1, 0x87, 0x99, 0x63, 0xC3,
  0x8D, 0x1B, 0x22, 0xC5, 0x0E, 0x0C, 0x10, 0x63, 0x80, 0x7D, 0xF0, 0x86,
  0x30, 0x84, 0x3F, 0x19, 0x88, 0x42, 0x73, 0x84, 0x21, 0x0C, 0x30, 0xFF,
  0xFC, 0xE1, 0x08, 0x42, 0x1C, 0x64, 0x21, 0x09, 0xC0, 0xE6, 0x70,
};

const GFXglyph NotoSans_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 9, 10, 9, 0, -10 },
  { 18, 6, 12, 8, 1, -11 },
  { 27, 10, 10, 12, 1, -10 },
  { 40, 9, 10, 10, 1, -10 },
  { 52, 1, 4, 3, 1, -10 },
  { 53, 3, 12, 4, 1, -10 },
  { 58, 4, 12, 4, 0, -10 },
  { 64, 6, 7, 8, 1, -11 },
  { 70, 6, 6, 8, 1, -8 },
  { 75, 2, 4, 4, 1, -2 },
  { 76, 3, 1, 5, 1, -4 },
  { 77, 2, 2, 4, 1, -2 },
  { 78, 5, 10, 5, 0, -10 },
  { 85, 6, 10, 8, 1, -10 },
  { 93, 4, 10, 8, 1, -10 },
  { 98, 6, 10, 8, 1, -10 },
  { 106, 6, 10, 8, 1, -10 },
  { 114, 8, 10, 8, 0, -10 },
  { 124, 6, 10, 8, 1, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 6, 10, 8, 1, -10 },
  { 164, 2, 8, 4, 1, -8 },
  { 166, 3, 10, 4, 0, -8 },
  { 170, 6, 7, 8, 1, -9 },
  { 176, 6, 4, 8, 1, -7 },
  { 179, 6, 7, 8, 1, -9 },
  { 185, 6, 10, 6, 0, -10 },
  { 193, 11, 11, 13, 1, -10 },
  { 209, 9, 10, 9, 0, -10 },
  { 221, 7, 10, 9, 1, -10 },
  { 230, 7, 10, 9, 1, -10 },
  { 239, 8, 10, 10, 1, -10 },
  { 249, 6, 10, 8, 1, -10 },
  { 257, 6, 10, 7, 1, -10 },
  { 265, 8, 10, 10, 1, -10 },
  { 275, 8, 10, 10, 1, -10 },
  { 285, 3, 10, 5, 1, -10 },
  { 289, 4, 13, 4, -1, -10 },
  { 296, 8, 10, 9, 1, -10 },
  { 306, 6, 10, 7, 1, -10 },
  { 314, 11, 10, 13, 1, -10 },
  { 328, 9, 10, 11, 1, -10 },
  { 340, 9, 10, 11, 1, -10 },
  { 352, 7, 10, 9, 1, -10 },
  { 361, 9, 12, 11, 1, -10 },
  { 375, 8, 10, 9, 1, -10 },
  { 385, 6, 10, 8, 1, -10 },
  { 393, 8, 10, 8, 0, -10 },
  { 403, 8, 10, 10, 1, -10 },
  { 413, 9, 10, 9, 0, -10 },
  { 425, 13, 10, 13, 0, -10 },
  { 442, 9, 10, 9, 0, -10 },
  { 454, 8, 10, 8, 0, -10 },
  { 464, 8, 10, 8, 0, -10 },
  { 474, 3, 12, 5, 1, -10 },
  { 479, 5, 10, 5, 0, -10 },
  { 486, 4, 12, 5, 0, -10 },
  { 492, 8, 6, 8, 0, -10 },
  { 498, 6, 1, 6, 0, 1 },
  { 499, 3, 3, 4, 1, -11 },
  { 501, 6, 8, 8, 1, -8 },
  { 507, 7, 11, 9, 1, -11 },
  { 517, 5, 8, 7, 1, -8 },
  { 522, 7, 11, 9, 1, -11 },
  { 532, 6, 8, 8, 1, -8 },
  { 538, 6, 11, 5, 0, -11 },
  { 547, 7, 11, 9, 1, -8 },
  { 557, 7, 11, 9, 1, -11 },
  { 567, 2, 10, 4, 1, -10 },
  { 570, 4, 13, 4, -1, -10 },
  { 577, 7, 11, 8, 1, -11 },
  { 587, 2, 11, 4, 1, -11 },
  { 590, 11, 8, 13, 1, -8 },
  { 601, 7, 8, 9, 1, -8 },
  { 608, 7, 8, 9, 1, -8 },
  { 615, 7, 11, 9, 1, -8 },
  { 625, 7, 11, 9, 1, -8 },
  { 635, 5, 8, 6, 1, -8 },
  { 640, 5, 8, 7, 1, -8 },
  { 645, 5, 9, 5, 0, -9 },
  { 651, 7, 8, 9, 1, -8 },
  { 658, 7, 8, 7, 0, -8 },
  { 665, 11, 8, 11, 0, -8 },
  { 676, 7, 8, 8, 0, -8 },
  { 683, 7, 11, 7, 0, -8 },
  { 693, 6, 8, 7, 0, -8 },
  { 699, 5, 12, 5, 0, -10 },
  { 707, 1, 14, 8, 3, -11 },
  { 709, 5, 12, 5, 0, -10 },
  { 717, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_Medium14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium14pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_MEDIUM14PT7B_H_
