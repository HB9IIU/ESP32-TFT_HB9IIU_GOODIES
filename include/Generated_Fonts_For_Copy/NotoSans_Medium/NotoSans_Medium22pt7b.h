#ifndef _NOTOSANS_MEDIUM22PT7B_H_
#define _NOTOSANS_MEDIUM22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium22pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xF6, 0xE7, 0xCD, 0x9B,
  0x34, 0x68, 0xC0, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x19, 0x80, 0x8C, 0x7F,
  0xFF, 0xFF, 0xE3, 0x10, 0x19, 0x80, 0x8C, 0x3F, 0xFC, 0x63, 0x03, 0x10,
  0x19, 0x80, 0x8C, 0x0C, 0x60, 0x04, 0x01, 0x01, 0xF9, 0xFF, 0xE4, 0xB9,
  0x0E, 0x41, 0xD0, 0x7E, 0x07, 0xE0, 0x7C, 0x13, 0x04, 0xE1, 0x7F, 0xFD,
  0xFC, 0x04, 0x01, 0x00, 0x38, 0x0C, 0x3E, 0x0C, 0x33, 0x04, 0x18, 0xC6,
  0x0C, 0x66, 0x06, 0x33, 0x03, 0x1B, 0x31, 0x99, 0xBE, 0x7D, 0xB3, 0x1C,
  0xD8, 0xC0, 0xCC, 0x60, 0x46, 0x30, 0x63, 0x18, 0x61, 0x8C, 0x30, 0x6C,
  0x30, 0x3C, 0x1F, 0x00, 0x7F, 0x00, 0xC7, 0x01, 0x8E, 0x03, 0x1C, 0x07,
  0x70, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x0C, 0xE6, 0x3B, 0x87, 0x67, 0x07,
  0xCE, 0x07, 0x1C, 0x1F, 0x1F, 0xF7, 0x1F, 0xC7, 0xFD, 0xB4, 0x80, 0x19,
  0x8C, 0xC6, 0x73, 0x18, 0xC6, 0x31, 0x8C, 0x73, 0x8C, 0x61, 0x8E, 0xC7,
  0x18, 0xE3, 0x18, 0xE3, 0x18, 0xC6, 0x31, 0x9C, 0xC6, 0x73, 0x38, 0x0C,
  0x03, 0x00, 0xC2, 0x31, 0xFF, 0xFF, 0xF1, 0xE0, 0xFC, 0x33, 0x1C, 0xE0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x6D, 0xFD, 0x80, 0xFF, 0xC0, 0x6F, 0x60, 0x03, 0x03, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60,
  0xE0, 0x1E, 0x07, 0xF1, 0xC6, 0x30, 0x6E, 0x0D, 0x81, 0xB0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0x70, 0x66, 0x0C, 0xC3, 0x8F, 0xE0, 0xF8, 0x0C,
  0x77, 0xFB, 0xCC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1F,
  0x0F, 0xF3, 0x87, 0x20, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x3F, 0x3F, 0xE6,
  0x1C, 0x03, 0x00, 0xC0, 0x70, 0x38, 0xF8, 0x3F, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xE0, 0x7F, 0xFB, 0xFC, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x6C, 0x06,
  0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0xC6, 0x0C, 0x60, 0xCF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0xC0, 0x0C, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18,
  0x07, 0xE1, 0xFE, 0x43, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x7F, 0xF9,
  0xFC, 0x07, 0x83, 0xF0, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x33, 0xC6, 0xFE,
  0xF1, 0xDC, 0x1F, 0x03, 0xF0, 0x76, 0x0C, 0xE1, 0x8F, 0xF0, 0xF8, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x1F, 0x0F, 0xF1,
  0x87, 0x70, 0x66, 0x0C, 0xC3, 0x8E, 0xE0, 0xF0, 0x3F, 0x8E, 0x3B, 0x83,
  0x60, 0x7C, 0x0F, 0xC1, 0x9F, 0xF1, 0xF8, 0x1E, 0x0F, 0xF1, 0x86, 0x70,
  0x6C, 0x0D, 0x81, 0xB0, 0x3F, 0x0F, 0x7F, 0xC7, 0xD8, 0x03, 0x00, 0x60,
  0x1C, 0x07, 0x1F, 0xC3, 0xF0, 0x6F, 0x60, 0x00, 0x00, 0x06, 0xF6, 0x7D,
  0x80, 0x00, 0x0D, 0xFD, 0xB0, 0x00, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x80, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC1, 0xE0, 0xF0, 0xF8, 0x18, 0x02, 0x00, 0x00, 0x3E, 0x7F, 0x90,
  0xE0, 0x30, 0x18, 0x0C, 0x0C, 0x1C, 0x0C, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x70, 0x30, 0x01, 0xF0, 0x01, 0xFF, 0x01, 0xC0, 0x60, 0xE0, 0x0C,
  0x30, 0x41, 0x98, 0xFE, 0x66, 0x71, 0x8B, 0x18, 0x63, 0xC6, 0x18, 0xF1,
  0x86, 0x2C, 0x63, 0x9B, 0x18, 0xE6, 0x43, 0xEF, 0x18, 0x61, 0x07, 0x00,
  0x00, 0xE0, 0x10, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x0E, 0xC0, 0x33, 0x00, 0xCE, 0x07, 0x18, 0x18, 0x70,
  0xFF, 0xC3, 0xFF, 0x0C, 0x0E, 0x70, 0x19, 0x80, 0x66, 0x01, 0xF8, 0x03,
  0xFE, 0x1F, 0xFB, 0x07, 0x60, 0x7C, 0x0F, 0x81, 0xF0, 0x77, 0xF8, 0xFF,
  0xD8, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xFF, 0xF7, 0xFC, 0x07, 0xE1,
  0xFF, 0x3C, 0x37, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x81, 0x1F, 0xF0, 0xFF, 0xFE, 0x07,
  0xFE, 0x30, 0x79, 0x80, 0xEC, 0x07, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x60, 0xF3, 0xFF, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFF, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x07, 0xF0, 0xFF, 0xCF, 0x06, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0xFF, 0x07, 0xD8, 0x06, 0xC0, 0x37, 0x01, 0x9C, 0x0C, 0x7F,
  0xE1, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xCF, 0xBF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3F, 0xFE, 0xC0, 0x7C, 0x0E, 0xC1, 0xCC, 0x38, 0xC7,
  0x0C, 0x60, 0xCC, 0x0D, 0xC0, 0xFE, 0x0E, 0x60, 0xC7, 0x0C, 0x38, 0xC1,
  0x8C, 0x1C, 0xC0, 0xEC, 0x07, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xD8, 0x1B, 0xD8, 0x1B, 0xCC,
  0x33, 0xCC, 0x33, 0xCC, 0x33, 0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0x83, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x3D, 0xC1, 0xE6, 0x0F, 0x38, 0x78, 0xC3, 0xC7, 0x1E, 0x1C, 0xF0,
  0x67, 0x83, 0xBC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0x07, 0xE0, 0x3F,
  0xE0, 0xE0, 0xE3, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x3B, 0x00, 0x67, 0x01, 0xC7, 0x07, 0x87,
  0xFE, 0x07, 0xF0, 0xFE, 0x3F, 0xEC, 0x3F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0xFF, 0xBF, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x07,
  0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x3B, 0x00, 0x67, 0x01, 0xC7,
  0x07, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0xFE, 0x0F, 0xF8, 0xC3, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x38, 0xFF, 0x0F, 0xF0, 0xC3, 0x0C, 0x38, 0xC1, 0xCC, 0x1C, 0xC0, 0xEC,
  0x07, 0x1F, 0x1F, 0xF7, 0x0B, 0x80, 0xE0, 0x38, 0x07, 0x00, 0xF8, 0x1F,
  0x80, 0xF0, 0x1C, 0x03, 0x00, 0xE0, 0x7F, 0xFB, 0xFC, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x77, 0x07, 0x7F, 0xE1, 0xF8, 0xE0, 0x1F, 0x80,
  0x66, 0x03, 0x9C, 0x0C, 0x70, 0x30, 0xC1, 0xC3, 0x86, 0x06, 0x18, 0x18,
  0xE0, 0x73, 0x00, 0xCC, 0x03, 0x70, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0x98, 0x3C, 0x0C, 0xC1, 0xE0, 0xE7,
  0x0D, 0x86, 0x18, 0x6C, 0x30, 0xC7, 0x61, 0x86, 0x33, 0x9C, 0x39, 0x8C,
  0xC0, 0xCC, 0x66, 0x06, 0xC3, 0x30, 0x36, 0x0F, 0x81, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x38, 0x1E, 0x01, 0xC0, 0x70, 0xE0, 0x3B, 0x81, 0x8C, 0x1C,
  0x71, 0xC1, 0xCC, 0x06, 0xE0, 0x3E, 0x00, 0xE0, 0x07, 0x80, 0x7C, 0x03,
  0x70, 0x31, 0x83, 0x8E, 0x18, 0x39, 0xC0, 0xDC, 0x07, 0xE0, 0x3B, 0x01,
  0x9C, 0x1C, 0x60, 0xC3, 0x8E, 0x0C, 0x60, 0x76, 0x01, 0xB0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07,
  0x03, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xFE, 0x0C, 0x01, 0x80, 0x78, 0x0D, 0x03, 0x30, 0x62, 0x18, 0x63, 0x04,
  0x40, 0xD8, 0x0C, 0xFF, 0xC0, 0xE3, 0x0C, 0x30, 0x3F, 0x1F, 0xE2, 0x1C,
  0x03, 0x00, 0xCF, 0xF7, 0x8F, 0x83, 0xC1, 0xF8, 0x7F, 0xFD, 0xF3, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCF, 0xFB, 0x87, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1F, 0xFE, 0xDF, 0x00, 0x1F, 0x9F, 0xDC,
  0x2C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x5F, 0xE3, 0xF0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x3C, 0xDF, 0xDB, 0x87, 0xE0, 0xFC,
  0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xD8, 0x3B, 0xFB, 0x3E, 0x60, 0x1F,
  0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0D, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0E,
  0x08, 0xFF, 0x0F, 0xE0, 0x0F, 0x8F, 0x86, 0x07, 0x03, 0x83, 0xFB, 0xFC,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00,
  0x1E, 0x67, 0xED, 0xC3, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0xEC, 0x1D, 0xFD, 0x9F, 0x30, 0x06, 0x01, 0xD0, 0x33, 0xFE, 0x7F, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCF, 0xFB, 0x87, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xF0, 0xFF,
  0xFF, 0xFF, 0x18, 0xC0, 0x01, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC7, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7C,
  0x3B, 0x1C, 0xCE, 0x37, 0x0F, 0x83, 0xF0, 0xEE, 0x31, 0xCC, 0x33, 0x0E,
  0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDF, 0x1F, 0x7F, 0xDF, 0xF8,
  0x78, 0xF8, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83,
  0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x30, 0xDF, 0x3F, 0xEE,
  0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x60,
  0xEE, 0x1C, 0xFF, 0x0F, 0xC0, 0xDF, 0x3F, 0xEE, 0x1F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x7F, 0xFB, 0x7C, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x00, 0x1E, 0x6F, 0xED, 0xC3, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xEC, 0x1D, 0xFD, 0x9F, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0xCF, 0xBF, 0xC7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x00, 0x3F, 0xBF, 0xB0, 0x58, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03,
  0xC1, 0xFF, 0xDF, 0xC0, 0x10, 0x10, 0x30, 0x7F, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x3F, 0x1F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF8, 0x7F, 0xFD, 0xFB, 0xE0, 0x76,
  0x06, 0x60, 0xE7, 0x0C, 0x30, 0xC3, 0x1C, 0x39, 0x81, 0x98, 0x1B, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0xE1, 0xC1, 0xD8, 0x78, 0x66, 0x1E, 0x19, 0x87,
  0x8E, 0x73, 0x63, 0x0C, 0xCC, 0xC3, 0x33, 0x70, 0xD8, 0xD8, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x70, 0xE0, 0x67, 0x0C, 0x39, 0xC1,
  0x98, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x19, 0x83, 0x9C, 0x70, 0xEE,
  0x07, 0xE0, 0x76, 0x06, 0x60, 0xE7, 0x0C, 0x30, 0xC3, 0x1C, 0x19, 0x81,
  0x98, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x0F,
  0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x3F, 0xFF, 0xF0, 0x06, 0x3C, 0xE1, 0x83, 0x06, 0x0C, 0x18,
  0x71, 0xC3, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x78, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38,
  0x3C, 0x79, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xE3, 0x80, 0xFC, 0x3F, 0xFE,
  0x0E, 0x00,
};

const GFXglyph NotoSans_Medium22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 7, 6, 9, 1, -16 },
  { 15, 13, 16, 14, 1, -16 },
  { 41, 10, 18, 13, 1, -17 },
  { 64, 17, 16, 19, 1, -16 },
  { 98, 15, 16, 16, 1, -16 },
  { 128, 3, 6, 5, 1, -16 },
  { 131, 5, 19, 7, 1, -16 },
  { 143, 5, 19, 7, 1, -16 },
  { 155, 10, 10, 12, 1, -17 },
  { 168, 10, 11, 13, 1, -13 },
  { 182, 3, 6, 6, 1, -3 },
  { 185, 5, 2, 7, 1, -7 },
  { 187, 4, 3, 6, 1, -3 },
  { 189, 8, 16, 8, 0, -16 },
  { 205, 11, 16, 13, 1, -16 },
  { 227, 6, 16, 13, 2, -16 },
  { 239, 11, 16, 13, 1, -16 },
  { 261, 10, 16, 13, 1, -16 },
  { 281, 12, 16, 13, 0, -16 },
  { 305, 10, 16, 13, 1, -16 },
  { 325, 11, 16, 13, 1, -16 },
  { 347, 11, 16, 13, 1, -16 },
  { 369, 11, 16, 13, 1, -16 },
  { 391, 11, 16, 13, 1, -16 },
  { 413, 4, 12, 6, 1, -12 },
  { 419, 3, 15, 6, 1, -12 },
  { 425, 11, 11, 13, 1, -13 },
  { 441, 10, 6, 13, 1, -11 },
  { 449, 11, 11, 13, 1, -13 },
  { 465, 9, 16, 10, 0, -16 },
  { 483, 18, 18, 20, 1, -16 },
  { 524, 14, 16, 14, 0, -16 },
  { 552, 11, 16, 14, 2, -16 },
  { 574, 12, 16, 14, 1, -16 },
  { 598, 13, 16, 16, 2, -16 },
  { 624, 9, 16, 12, 2, -16 },
  { 642, 9, 16, 12, 2, -16 },
  { 660, 13, 16, 16, 1, -16 },
  { 686, 12, 16, 16, 2, -16 },
  { 710, 6, 16, 8, 1, -16 },
  { 722, 6, 20, 6, -2, -16 },
  { 737, 12, 16, 14, 2, -16 },
  { 761, 9, 16, 12, 2, -16 },
  { 779, 16, 16, 20, 2, -16 },
  { 811, 13, 16, 17, 2, -16 },
  { 837, 15, 16, 17, 1, -16 },
  { 867, 10, 16, 13, 2, -16 },
  { 887, 15, 20, 17, 1, -16 },
  { 925, 12, 16, 14, 2, -16 },
  { 949, 10, 16, 12, 1, -16 },
  { 969, 12, 16, 12, 0, -16 },
  { 993, 12, 16, 16, 2, -16 },
  { 1017, 14, 16, 14, 0, -16 },
  { 1045, 21, 16, 21, 0, -16 },
  { 1087, 13, 16, 13, 0, -16 },
  { 1113, 13, 16, 13, 0, -16 },
  { 1139, 11, 16, 13, 1, -16 },
  { 1161, 5, 19, 7, 2, -16 },
  { 1173, 8, 16, 8, 0, -16 },
  { 1189, 5, 19, 7, 1, -16 },
  { 1201, 11, 10, 13, 1, -16 },
  { 1215, 10, 1, 10, 0, 2 },
  { 1217, 5, 4, 7, 1, -17 },
  { 1220, 10, 12, 13, 1, -12 },
  { 1235, 10, 17, 14, 2, -17 },
  { 1257, 9, 12, 11, 1, -12 },
  { 1271, 11, 17, 14, 1, -17 },
  { 1295, 11, 12, 13, 1, -12 },
  { 1312, 9, 17, 8, 0, -17 },
  { 1332, 11, 17, 14, 1, -12 },
  { 1356, 10, 17, 14, 2, -17 },
  { 1378, 2, 16, 6, 2, -16 },
  { 1382, 5, 21, 6, -1, -16 },
  { 1396, 10, 17, 12, 2, -17 },
  { 1418, 2, 17, 6, 2, -17 },
  { 1423, 17, 12, 21, 2, -12 },
  { 1449, 10, 12, 14, 2, -12 },
  { 1464, 11, 12, 13, 1, -12 },
  { 1481, 10, 17, 14, 2, -12 },
  { 1503, 11, 17, 14, 1, -12 },
  { 1527, 7, 12, 9, 2, -12 },
  { 1538, 9, 12, 11, 1, -12 },
  { 1552, 8, 15, 8, 0, -15 },
  { 1567, 10, 12, 14, 2, -12 },
  { 1582, 12, 12, 12, 0, -12 },
  { 1600, 18, 12, 18, 0, -12 },
  { 1627, 12, 12, 12, 0, -12 },
  { 1645, 12, 17, 12, 0, -12 },
  { 1671, 9, 12, 11, 1, -12 },
  { 1685, 7, 19, 8, 1, -16 },
  { 1702, 2, 22, 12, 5, -17 },
  { 1708, 7, 19, 8, 1, -16 },
  { 1725, 11, 3, 13, 1, -9 },
};

const GFXfont NotoSans_Medium22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium22pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_MEDIUM22PT7B_H_
