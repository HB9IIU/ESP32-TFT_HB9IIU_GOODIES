#ifndef _NOTOSANS_MEDIUM59PT7B_H_
#define _NOTOSANS_MEDIUM59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xFC, 0x1F, 0xFF, 0x07,
  0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB,
  0xF0, 0x3E, 0xFC, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0x78,
  0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0x87, 0xF0, 0xF0, 0x38, 0x7E, 0x0F, 0x00,
  0x0F, 0xE0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xFE,
  0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7F, 0x8F, 0x00, 0x07, 0xFE, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0xF0, 0xFE,
  0x00, 0x0F, 0x07, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00,
  0xF0, 0x7F, 0x80, 0x0F, 0x07, 0xEE, 0x00, 0xF0, 0xFE, 0xFE, 0x0F, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC3,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE1, 0xF8,
  0x7F, 0xC1, 0xF0, 0x1F, 0x0F, 0x8F, 0xFF, 0x07, 0xC0, 0xF8, 0xFC, 0x7F,
  0xFC, 0x3E, 0x0F, 0x87, 0xC7, 0xF7, 0xF1, 0xFF, 0xFC, 0x7C, 0x3E, 0x0F,
  0x87, 0xFF, 0xC3, 0xE3, 0xF0, 0x7E, 0x1F, 0xFC, 0x3E, 0x1F, 0x01, 0xF0,
  0x7F, 0xC3, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFC, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x1F, 0xFF, 0xF0, 0x01, 0xFC, 0x3F,
  0xE7, 0xF8, 0x01, 0xF8, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE,
  0x03, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0,
  0xFE, 0x00, 0x3F, 0xE7, 0xE0, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x16,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xE7, 0x9E,
  0x79, 0xE7, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x40, 0x0F, 0x00, 0x27, 0xC0, 0xF0, 0x3E, 0x7F, 0xCF, 0x1F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xBF, 0x7F, 0x9F, 0xFF, 0x8F,
  0xDF, 0x07, 0xEF, 0x03, 0xF3, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xE0, 0x01,
  0xFC, 0x38, 0x00, 0x1F, 0xC1, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7E, 0x00, 0x7F, 0xC3, 0x80, 0x01, 0xFC, 0x20, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x80, 0x00,
  0x1F, 0xCF, 0x80, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xCC, 0x00, 0x03, 0xFC, 0xF8, 0x00, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x38, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x0F, 0xC3, 0xFF, 0xC0,
  0xFC, 0x7F, 0xFE, 0x0F, 0xCF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF,
  0x07, 0xFC, 0xFF, 0xC0, 0x1F, 0xEF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x28, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF8,
  0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x3F,
  0x80, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x7F, 0x00, 0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0x3F, 0xE1, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0x1F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFE, 0x3F, 0x03, 0xFF, 0x87,
  0xE0, 0x01, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7A, 0x00, 0x00,
  0x10, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x04, 0x07,
  0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7E, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x7C, 0x01, 0xFE, 0x60, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xFF,
  0xFC, 0x0F, 0x83, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0x8F, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0x1F, 0x00, 0xFF, 0x07, 0xE0, 0x3E, 0x7E, 0x03, 0xF8, 0x07,
  0xC0, 0x3C, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7D, 0xF0, 0x1F, 0x80, 0x1F,
  0x00, 0xFB, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF7, 0x80, 0xFC, 0x00, 0x7C,
  0x03, 0xFF, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x0F, 0xC0,
  0x3D, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0x3E, 0x01,
  0xF7, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0xFC, 0x01, 0xFC, 0x0F,
  0x9F, 0x00, 0xF8, 0x03, 0xF8, 0x1F, 0x1F, 0x01, 0xF8, 0x0F, 0xF0, 0x7C,
  0x3E, 0x01, 0xFF, 0xFD, 0xFF, 0xF8, 0x7C, 0x03, 0xFF, 0xF9, 0xFF, 0xE0,
  0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xF8, 0x00, 0x20, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x0F, 0xFE, 0x3F,
  0x80, 0x03, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xF8,
  0x0F, 0xF8, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x20, 0x3F, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x3F,
  0x80, 0x03, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x0F, 0xFE, 0x0F, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xF0, 0x3F, 0xF0, 0x00,
  0x0C, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0x0F, 0xF8, 0x00, 0x0F, 0xC3, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFD, 0x03, 0xFE, 0xFF, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x60, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xE7, 0xE0,
  0x00, 0x7F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x7F,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF7, 0xF8, 0x00,
  0x07, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x01, 0xFE, 0xFC, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7D, 0xFF, 0xDF, 0x00, 0x00, 0x0F,
  0xBF, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xFF, 0x7E, 0x00, 0x00, 0x7C, 0xFF,
  0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xFF, 0x9F,
  0x80, 0x00, 0x7C, 0xFF, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xFE, 0x3F, 0x00,
  0x03, 0xF3, 0xFF, 0xC3, 0xE0, 0x00, 0x7C, 0x7F, 0xF8, 0x7E, 0x00, 0x1F,
  0x8F, 0xFF, 0x0F, 0xC0, 0x03, 0xE1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x3F,
  0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xFF, 0x83, 0xF0, 0x03, 0xE0, 0xFF, 0xF0,
  0x3E, 0x00, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xFF, 0xC0, 0xFC,
  0x03, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0x01, 0xF8, 0x1F,
  0x01, 0xFF, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xFF, 0x80, 0x7E, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0xFE,
  0x00, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0x9F, 0x00, 0x7F, 0xF8, 0x01,
  0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0x9F,
  0xC0, 0x00, 0xFF, 0xE7, 0xF8, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x0F, 0xFE,
  0x1F, 0xC0, 0x03, 0xFF, 0x87, 0xF0, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x3F,
  0xF8, 0x3F, 0xC0, 0x0F, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xF8, 0x00,
  0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0x83, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0xE0,
  0x01, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0x8F, 0xFE, 0x00, 0x07, 0xF1, 0xFF,
  0x80, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0x9F, 0xF8, 0x00, 0x07, 0xF7,
  0xFE, 0x00, 0x01, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x5A, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xE0, 0x3F, 0xFC, 0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x5F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xE3, 0xF8,
  0x00, 0x18, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x40, 0x00, 0x0F,
  0xEE, 0x00, 0x03, 0xFD, 0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xDF,
  0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x00,
  0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xC0, 0x0F, 0xE0, 0x40, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xDF, 0xF8, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xE7, 0xCF, 0xFF, 0xF1, 0xF1, 0xFF, 0xF8,
  0x7C, 0x3F, 0xFC, 0x0F, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0xFC, 0x7F, 0xFC,
  0x0F, 0xCF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC0, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x80, 0x1F,
  0xEF, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xF9,
  0xFF, 0xFF, 0x0F, 0x87, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x1E, 0x3F, 0xC0, 0x02, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0x1F, 0xE0, 0x0E, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0xFC, 0x0F, 0xFF, 0xC7, 0xE0, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFF, 0xFD, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x0F,
  0xFE, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0xE7, 0xFC, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xEF,
  0xC1, 0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xE3, 0xF0, 0x1F, 0xFC, 0x0F, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x81, 0xFE, 0x03, 0xFC,
  0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x02, 0x1F, 0xE0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x05, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0x81, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xF8, 0x1F, 0xFF, 0x8F, 0xC1, 0xFF, 0xFE, 0x7E, 0x1F, 0xFF, 0xFB, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFE, 0x3F,
  0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0x83, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF,
  0xC7, 0xE0, 0x1F, 0xF8, 0x3F, 0x00, 0x0C, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0xF0, 0x3F, 0x1F, 0xFF, 0x87, 0xE7,
  0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFB, 0xFF, 0x80, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7E, 0x3C, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE8, 0x3F, 0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0xFF,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFB, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0xC0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFE, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF,
  0x8F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3E, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xEF,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F, 0xFF, 0xC3,
  0xE3, 0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC0,
  0x7F, 0xBF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFF,
  0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x1F, 0xF8,
  0x0F, 0x87, 0xFF, 0xC0, 0xF8, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xF0, 0xFC, 0x7F, 0xFE, 0x0F, 0xC3, 0xFF,
  0x80, 0xFC, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0xF8, 0x1F, 0xFF, 0x8F, 0xC1, 0xFF, 0xFE,
  0x7E, 0x1F, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xFC,
  0xFE, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x7F,
  0xCF, 0xF8, 0x07, 0xFE, 0x3F, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0x83,
  0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xC7, 0xE0, 0x1F, 0xF8, 0x7F, 0x00, 0x0C,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF9, 0xBF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFE, 0xFF, 0x9F, 0xC0, 0x07, 0x3F, 0x00,
  0x02, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xF7, 0xF8,
  0x7F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x01, 0xE8, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x60, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF7,
  0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF, 0xE1, 0xF0, 0x3F, 0xFC, 0x1F,
  0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xF0, 0x03,
  0xF9, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x7D, 0xF8, 0x07, 0xF0,
  0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x07,
  0xE0, 0x3E, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE1, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x03, 0xF0,
  0x7C, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x3E, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8,
  0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x80,
  0x7C, 0xFC, 0x00, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x07,
  0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x13, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC8, 0x00,
  0x0F, 0xF8,
};

const GFXglyph NotoSans_Medium59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 43, 16, 4, -42 },
  { 44, 18, 15, 25, 4, -42 },
  { 78, 36, 42, 38, 1, -42 },
  { 267, 28, 48, 34, 3, -45 },
  { 435, 45, 44, 50, 3, -43 },
  { 683, 40, 44, 43, 3, -43 },
  { 903, 6, 15, 14, 4, -42 },
  { 915, 15, 51, 18, 2, -42 },
  { 1011, 14, 51, 18, 2, -42 },
  { 1101, 28, 27, 32, 2, -45 },
  { 1196, 28, 28, 34, 3, -35 },
  { 1294, 10, 15, 16, 2, -7 },
  { 1313, 15, 6, 19, 2, -19 },
  { 1325, 8, 9, 16, 4, -8 },
  { 1334, 21, 42, 23, 1, -42 },
  { 1445, 28, 44, 34, 3, -43 },
  { 1599, 17, 42, 34, 5, -42 },
  { 1689, 28, 43, 34, 3, -43 },
  { 1840, 28, 44, 34, 3, -43 },
  { 1994, 32, 42, 34, 1, -42 },
  { 2162, 28, 43, 34, 3, -42 },
  { 2313, 28, 44, 34, 3, -43 },
  { 2467, 29, 42, 34, 2, -42 },
  { 2620, 28, 44, 34, 3, -43 },
  { 2774, 28, 44, 34, 3, -43 },
  { 2928, 8, 34, 16, 4, -33 },
  { 2962, 10, 41, 16, 2, -33 },
  { 3014, 28, 29, 34, 3, -36 },
  { 3116, 28, 16, 34, 3, -29 },
  { 3172, 28, 29, 34, 3, -36 },
  { 3274, 24, 44, 26, 1, -43 },
  { 3406, 47, 47, 53, 3, -42 },
  { 3683, 39, 42, 39, 0, -42 },
  { 3888, 31, 42, 39, 5, -42 },
  { 4051, 33, 44, 37, 3, -43 },
  { 4233, 35, 42, 43, 5, -42 },
  { 4417, 23, 42, 33, 6, -42 },
  { 4538, 23, 42, 31, 6, -42 },
  { 4659, 34, 44, 43, 4, -43 },
  { 4846, 32, 42, 44, 6, -42 },
  { 5014, 17, 42, 21, 2, -42 },
  { 5104, 17, 54, 17, -5, -42 },
  { 5219, 31, 42, 37, 6, -42 },
  { 5382, 25, 42, 32, 5, -42 },
  { 5514, 43, 42, 54, 6, -42 },
  { 5740, 34, 42, 46, 6, -42 },
  { 5919, 40, 44, 46, 3, -43 },
  { 6139, 28, 42, 36, 5, -42 },
  { 6286, 40, 53, 46, 3, -43 },
  { 6551, 32, 42, 37, 5, -42 },
  { 6719, 27, 44, 32, 3, -43 },
  { 6868, 31, 42, 33, 1, -42 },
  { 7031, 33, 43, 44, 5, -42 },
  { 7209, 36, 42, 36, 0, -42 },
  { 7398, 55, 42, 56, 0, -42 },
  { 7687, 36, 42, 36, 0, -42 },
  { 7876, 34, 42, 34, 0, -42 },
  { 8055, 30, 42, 34, 2, -42 },
  { 8213, 13, 51, 19, 5, -42 },
  { 8296, 21, 42, 23, 1, -42 },
  { 8407, 14, 51, 19, 1, -42 },
  { 8497, 30, 26, 34, 2, -42 },
  { 8595, 26, 4, 26, 0, 5 },
  { 8608, 14, 9, 18, 2, -45 },
  { 8624, 26, 33, 34, 3, -32 },
  { 8732, 28, 46, 37, 5, -45 },
  { 8893, 24, 33, 29, 3, -32 },
  { 8992, 29, 46, 37, 3, -45 },
  { 9159, 28, 33, 34, 3, -32 },
  { 9275, 23, 45, 21, 1, -45 },
  { 9405, 29, 46, 37, 3, -32 },
  { 9572, 27, 45, 37, 5, -45 },
  { 9724, 8, 44, 16, 4, -44 },
  { 9768, 15, 58, 16, -3, -44 },
  { 9877, 28, 45, 33, 5, -45 },
  { 10035, 6, 45, 16, 5, -45 },
  { 10069, 46, 32, 56, 5, -32 },
  { 10253, 27, 32, 37, 5, -32 },
  { 10361, 30, 33, 36, 3, -32 },
  { 10485, 28, 46, 37, 5, -32 },
  { 10646, 29, 46, 37, 3, -32 },
  { 10813, 19, 32, 25, 5, -32 },
  { 10889, 23, 33, 29, 3, -32 },
  { 10984, 20, 40, 23, 1, -39 },
  { 11084, 28, 33, 37, 4, -32 },
  { 11200, 31, 32, 31, 0, -32 },
  { 11324, 46, 32, 48, 1, -32 },
  { 11508, 30, 32, 32, 1, -32 },
  { 11628, 31, 46, 31, 0, -32 },
  { 11807, 24, 32, 28, 2, -32 },
  { 11903, 20, 51, 23, 1, -42 },
  { 12031, 5, 59, 33, 14, -45 },
  { 12068, 19, 51, 23, 2, -42 },
  { 12190, 28, 8, 34, 3, -25 },
};

const GFXfont NotoSans_Medium59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium59pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_MEDIUM59PT7B_H_
