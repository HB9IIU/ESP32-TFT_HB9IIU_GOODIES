#ifndef _NOTOSANS_MEDIUM21PT7B_H_
#define _NOTOSANS_MEDIUM21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0x87, 0xD8, 0xEF, 0xDD, 0x12, 0x24, 0x40,
  0x06, 0x20, 0x33, 0x01, 0x18, 0x18, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x01,
  0x18, 0x08, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x01, 0x18, 0x08, 0xC0, 0xC4,
  0x00, 0x0C, 0x03, 0x03, 0xFD, 0xFE, 0xEC, 0x33, 0x0E, 0xC1, 0xF0, 0x3F,
  0x03, 0xE0, 0xDC, 0x33, 0x8D, 0xFF, 0xE7, 0xF0, 0x30, 0x0C, 0x00, 0x78,
  0x18, 0xCC, 0x30, 0xCC, 0x30, 0xC4, 0x60, 0xC4, 0x60, 0xC4, 0xC0, 0xCC,
  0x9E, 0xED, 0xB6, 0x7B, 0x33, 0x03, 0x23, 0x06, 0x63, 0x06, 0x23, 0x0C,
  0x33, 0x0C, 0x36, 0x18, 0x1E, 0x1F, 0x00, 0xFE, 0x07, 0x18, 0x1C, 0x60,
  0x31, 0x80, 0xFC, 0x01, 0xE0, 0x0F, 0x87, 0x77, 0x1B, 0x8E, 0x6C, 0x1F,
  0x30, 0x3C, 0xE0, 0xF1, 0xFF, 0xE3, 0xF1, 0xC0, 0xFD, 0x24, 0x19, 0x98,
  0xC6, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x71, 0x8C, 0x31, 0xC0, 0xC3, 0x18,
  0x63, 0x18, 0xE7, 0x18, 0xC6, 0x73, 0x18, 0xCC, 0x66, 0x00, 0x0C, 0x03,
  0x00, 0xC3, 0x26, 0xFF, 0xC7, 0x01, 0x60, 0xDC, 0x73, 0x04, 0x80, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x6F, 0x6C, 0xFF, 0xC0, 0x7D, 0x80, 0x03, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x3F, 0x1F,
  0xE6, 0x1B, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x87, 0x61, 0x9F, 0xE3, 0xF0, 0x1C, 0xF7, 0xF3, 0x8C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x3F, 0x3F, 0xE4, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC,
  0x7F, 0x3F, 0xE4, 0x18, 0x06, 0x01, 0x80, 0x63, 0xF0, 0xFC, 0x03, 0x80,
  0x70, 0x0C, 0x07, 0x81, 0xFF, 0xEF, 0xF0, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x0D, 0xC1, 0x9C, 0x19, 0xC3, 0x1C, 0x61, 0xC6, 0x1C, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60,
  0x18, 0x07, 0xF1, 0xFE, 0x01, 0xC0, 0x30, 0x0C, 0x07, 0x81, 0xBF, 0xEF,
  0xE0, 0x0F, 0x8F, 0xE7, 0x01, 0x80, 0x60, 0x30, 0x0D, 0xFB, 0xC7, 0xE0,
  0xF0, 0x3C, 0x0F, 0x83, 0x61, 0xDF, 0xE1, 0xF0, 0xFF, 0xFF, 0xF0, 0x1C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x00, 0x3F, 0x1F, 0xE6, 0x1B, 0x87, 0x61, 0x9C, 0xE3, 0xF0,
  0xFC, 0x73, 0xB8, 0x7C, 0x0F, 0x03, 0xE1, 0xDF, 0xE3, 0xF0, 0x3E, 0x1F,
  0xEE, 0x1B, 0x07, 0xC0, 0xF0, 0x3C, 0x1D, 0x8F, 0x7E, 0xC2, 0x30, 0x18,
  0x06, 0x03, 0x9F, 0xC7, 0xC0, 0x5F, 0x80, 0x00, 0x0F, 0xB0, 0x5F, 0x80,
  0x00, 0x01, 0xFD, 0xA0, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x70, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x38, 0x78,
  0x78, 0x38, 0x08, 0x00, 0x7E, 0x7F, 0x90, 0xE0, 0x30, 0x18, 0x18, 0x1C,
  0x18, 0x18, 0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x60, 0x03, 0xF0, 0x07,
  0xFE, 0x06, 0x01, 0x86, 0x00, 0x66, 0x1F, 0x33, 0x3F, 0x8F, 0x18, 0xC7,
  0x98, 0x63, 0xCC, 0x31, 0xE6, 0x18, 0xB1, 0x8C, 0xD8, 0xFB, 0xC6, 0x18,
  0xC3, 0x00, 0x00, 0xE0, 0x20, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x03, 0x60, 0x0C, 0xC0, 0x33, 0x01, 0x8E, 0x06, 0x18,
  0x38, 0x60, 0xFF, 0xC3, 0xFF, 0x1C, 0x0C, 0x60, 0x39, 0x80, 0x6E, 0x01,
  0xC0, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x83, 0xBF, 0xE7, 0xFC,
  0xC1, 0xD8, 0x1B, 0x03, 0xE0, 0x7C, 0x1D, 0xFF, 0xBF, 0xC0, 0x0F, 0xF1,
  0xFE, 0x38, 0x27, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x78, 0x03, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFC,
  0xC1, 0xEC, 0x06, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x0E, 0xC1, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x0F, 0xF8, 0xFF, 0x8E, 0x04, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x3F, 0xE1, 0xFF, 0x01, 0xD8, 0x0E, 0xE0, 0x73, 0x83, 0x9F,
  0xFC, 0x3F, 0xC0, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x70, 0xFF, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33,
  0xEF, 0xC0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x1F, 0xEF, 0x00, 0xC0, 0xF8, 0x3B, 0x0E, 0x63, 0x8C, 0x61,
  0x98, 0x36, 0x07, 0xE0, 0xEE, 0x18, 0xC3, 0x1C, 0x61, 0xCC, 0x1D, 0x81,
  0xB0, 0x38, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFD, 0x83, 0x7B, 0x06, 0xF7, 0x0D, 0xE6, 0x33, 0xCC, 0x67,
  0x8C, 0x8F, 0x1B, 0x1E, 0x36, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE1, 0x80,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xDC, 0x3C, 0xC3, 0xCE, 0x3C, 0x63,
  0xC7, 0x3C, 0x3B, 0xC1, 0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x70, 0x0F,
  0xE0, 0xFF, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x1F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x36, 0x01, 0xDC, 0x06, 0x38, 0x38, 0xFF, 0xC0,
  0xFE, 0x00, 0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1B, 0xFE,
  0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0xE0, 0xFF,
  0xC3, 0x83, 0x9C, 0x06, 0x60, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x36, 0x01, 0xDC, 0x06, 0x38, 0x38, 0xFF, 0xC0, 0xFE, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0xFE, 0x1F, 0xF3, 0x07, 0x60,
  0xEC, 0x1D, 0x83, 0xB0, 0x67, 0xF8, 0xFE, 0x18, 0xE3, 0x0C, 0x61, 0xCC,
  0x1D, 0x81, 0xB0, 0x38, 0x3F, 0x9F, 0xEE, 0x0B, 0x00, 0xE0, 0x18, 0x07,
  0x80, 0xFC, 0x07, 0x80, 0x60, 0x1C, 0x07, 0x81, 0xBF, 0xEF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x06, 0xE0, 0xE7, 0xFC, 0x3F, 0x80, 0xC0, 0x3B, 0x01,
  0x98, 0x0C, 0xE0, 0xE3, 0x06, 0x18, 0x30, 0xE3, 0x83, 0x18, 0x18, 0xC0,
  0xEE, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x60,
  0x76, 0x0E, 0x06, 0x60, 0xF0, 0x66, 0x0F, 0x0E, 0x71, 0xB0, 0xC3, 0x1B,
  0x8C, 0x31, 0x98, 0xC3, 0x19, 0x9C, 0x3B, 0x19, 0x81, 0xB0, 0xD8, 0x1B,
  0x0D, 0x81, 0xB0, 0xF8, 0x1E, 0x0F, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00,
  0xE0, 0x33, 0x83, 0x0C, 0x38, 0x31, 0x81, 0xD8, 0x06, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x80, 0x6C, 0x06, 0x70, 0x71, 0x83, 0x06, 0x30, 0x3B, 0x80,
  0xE0, 0xE0, 0x36, 0x06, 0x70, 0xE3, 0x0C, 0x39, 0xC1, 0x98, 0x1F, 0x80,
  0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCF, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18, 0x18,
  0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x3F, 0x0C, 0x07, 0x01, 0xE0, 0x58, 0x33, 0x08, 0xC6,
  0x19, 0x06, 0xC0, 0xC0, 0xFF, 0x80, 0xE3, 0x0E, 0x04, 0x3F, 0x88, 0xE0,
  0x30, 0x18, 0xFD, 0xFF, 0xC3, 0xC1, 0xE0, 0xFF, 0xEF, 0x90, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC4, 0x37, 0xCF, 0x3B, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF8, 0x6F, 0xFB, 0x7C, 0x04, 0x1F, 0xDC, 0x4C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xE0, 0x30, 0x1F, 0xC7, 0xE0, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x08, 0xCF, 0xF7, 0x3D, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0,
  0xD8, 0x77, 0xFC, 0xFB, 0x04, 0x0F, 0xC7, 0x19, 0x87, 0xE0, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x18, 0x07, 0xF8, 0x7E, 0x0F, 0x1F, 0x38, 0x30, 0x30,
  0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x08,
  0x0F, 0xF7, 0x3D, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xD8, 0x77,
  0xFC, 0xFB, 0x00, 0xC0, 0x34, 0x1D, 0xFE, 0x7F, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC4, 0x37, 0xCF, 0x3B, 0x86, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xBC, 0x3F, 0xFF, 0xFF, 0x10, 0xC6, 0x00,
  0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xEC, 0x73, 0x38, 0xDC, 0x3E, 0x0F,
  0x83, 0xB0, 0xCE, 0x31, 0xCC, 0x33, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x04,
  0x08, 0xFF, 0x7E, 0xF3, 0xE7, 0xC1, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0x04,
  0x37, 0xEF, 0x3B, 0x86, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x04, 0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xE0, 0xCC, 0x19, 0xFE, 0x0F, 0x80, 0x04, 0x37, 0xCF, 0x3B, 0x07,
  0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF8, 0x6F, 0xFB, 0x7C, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x0F, 0xF7, 0x3D, 0x83, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xD8, 0x77, 0xFC, 0xFB, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x07, 0xBB, 0xF7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x00, 0x08, 0x7F, 0xE3, 0xC0, 0xE0, 0x78, 0x3E, 0x07, 0x03, 0x03,
  0xFF, 0xFE, 0x10, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x3F, 0x1F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xFF, 0xDF, 0x20, 0xE0, 0xEC, 0x19, 0x83, 0x38, 0xE3, 0x18,
  0x63, 0x06, 0xC0, 0xD8, 0x1B, 0x01, 0xC0, 0x38, 0x00, 0xE1, 0xC3, 0xB0,
  0xE1, 0x98, 0xD8, 0xCC, 0x6C, 0xE3, 0x36, 0x61, 0x93, 0x30, 0xD8, 0xD8,
  0x6C, 0x7C, 0x1E, 0x3C, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0xF0, 0xE6, 0x38,
  0xE6, 0x0F, 0x80, 0xF0, 0x1C, 0x07, 0xC0, 0xDC, 0x31, 0x8E, 0x1B, 0x83,
  0x80, 0xE0, 0xEC, 0x19, 0x83, 0x18, 0xE3, 0x18, 0x73, 0x06, 0xE0, 0xD8,
  0x0B, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x3E, 0x07, 0x80, 0xFF,
  0x03, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x60, 0xFF, 0xFF, 0x06, 0x1C,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0xF1, 0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0C,
  0x1E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x1E, 0x3C, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0xF1, 0xC0,
  0x78, 0x7F, 0xF8, 0x78,
};

const GFXglyph NotoSans_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 15, 6, 1, -15 },
  { 7, 7, 5, 9, 1, -15 },
  { 12, 13, 15, 14, 0, -15 },
  { 37, 10, 17, 12, 1, -16 },
  { 59, 16, 15, 18, 1, -15 },
  { 89, 14, 15, 15, 1, -15 },
  { 116, 3, 5, 5, 1, -15 },
  { 118, 5, 18, 7, 1, -15 },
  { 130, 5, 18, 7, 1, -15 },
  { 142, 10, 10, 12, 1, -16 },
  { 155, 10, 11, 12, 1, -13 },
  { 169, 3, 5, 6, 1, -2 },
  { 171, 5, 2, 7, 1, -7 },
  { 173, 3, 3, 6, 1, -3 },
  { 175, 8, 15, 8, 0, -15 },
  { 190, 10, 15, 12, 1, -15 },
  { 209, 6, 15, 12, 2, -15 },
  { 221, 10, 15, 12, 1, -15 },
  { 240, 10, 15, 12, 1, -15 },
  { 259, 12, 15, 12, 0, -15 },
  { 282, 10, 15, 12, 1, -15 },
  { 301, 10, 15, 12, 1, -15 },
  { 320, 10, 15, 12, 1, -15 },
  { 339, 10, 15, 12, 1, -15 },
  { 358, 10, 15, 12, 1, -15 },
  { 377, 3, 12, 6, 1, -12 },
  { 382, 3, 15, 6, 1, -12 },
  { 388, 10, 11, 12, 1, -13 },
  { 402, 10, 6, 12, 1, -10 },
  { 410, 10, 11, 12, 1, -13 },
  { 424, 9, 15, 9, 0, -15 },
  { 441, 17, 17, 19, 1, -15 },
  { 478, 14, 15, 14, 0, -15 },
  { 505, 11, 15, 14, 2, -15 },
  { 526, 12, 15, 13, 1, -15 },
  { 549, 12, 15, 15, 2, -15 },
  { 572, 8, 15, 12, 2, -15 },
  { 587, 8, 15, 11, 2, -15 },
  { 602, 13, 15, 15, 1, -15 },
  { 627, 12, 15, 16, 2, -15 },
  { 650, 6, 15, 7, 1, -15 },
  { 662, 6, 19, 6, -2, -15 },
  { 677, 11, 15, 13, 2, -15 },
  { 698, 9, 15, 11, 2, -15 },
  { 715, 15, 15, 19, 2, -15 },
  { 744, 12, 15, 16, 2, -15 },
  { 767, 14, 15, 16, 1, -15 },
  { 794, 10, 15, 13, 2, -15 },
  { 813, 14, 19, 16, 1, -15 },
  { 847, 11, 15, 13, 2, -15 },
  { 868, 10, 15, 12, 1, -15 },
  { 887, 12, 15, 12, 0, -15 },
  { 910, 12, 15, 16, 2, -15 },
  { 933, 13, 15, 13, 0, -15 },
  { 958, 20, 15, 20, 0, -15 },
  { 996, 13, 15, 13, 0, -15 },
  { 1021, 12, 15, 12, 0, -15 },
  { 1044, 10, 15, 12, 1, -15 },
  { 1063, 4, 18, 7, 2, -15 },
  { 1072, 8, 15, 8, 0, -15 },
  { 1087, 4, 18, 7, 1, -15 },
  { 1096, 10, 9, 12, 1, -15 },
  { 1108, 9, 1, 9, 0, 2 },
  { 1110, 5, 3, 6, 1, -16 },
  { 1112, 9, 12, 12, 1, -12 },
  { 1126, 10, 16, 13, 2, -16 },
  { 1146, 9, 12, 10, 1, -12 },
  { 1160, 10, 16, 13, 1, -16 },
  { 1180, 10, 12, 12, 1, -12 },
  { 1195, 8, 16, 8, 0, -16 },
  { 1211, 10, 17, 13, 1, -12 },
  { 1233, 10, 16, 13, 2, -16 },
  { 1253, 2, 16, 6, 2, -16 },
  { 1257, 5, 21, 6, -1, -16 },
  { 1271, 10, 16, 12, 2, -16 },
  { 1291, 2, 16, 6, 2, -16 },
  { 1295, 16, 12, 20, 2, -12 },
  { 1319, 10, 12, 13, 2, -12 },
  { 1334, 11, 12, 13, 1, -12 },
  { 1351, 10, 17, 13, 2, -12 },
  { 1373, 10, 17, 13, 1, -12 },
  { 1395, 7, 12, 9, 2, -12 },
  { 1406, 8, 12, 10, 1, -12 },
  { 1418, 8, 14, 8, 0, -14 },
  { 1432, 9, 11, 13, 2, -11 },
  { 1445, 11, 11, 11, 0, -11 },
  { 1461, 17, 11, 17, 0, -11 },
  { 1485, 11, 11, 11, 0, -11 },
  { 1501, 11, 16, 11, 0, -11 },
  { 1523, 8, 11, 10, 1, -11 },
  { 1534, 7, 18, 8, 0, -15 },
  { 1550, 2, 21, 12, 5, -16 },
  { 1556, 7, 18, 8, 1, -15 },
  { 1572, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_Medium21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium21pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_MEDIUM21PT7B_H_
