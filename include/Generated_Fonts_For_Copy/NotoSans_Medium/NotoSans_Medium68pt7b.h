#ifndef _NOTOSANS_MEDIUM68PT7B_H_
#define _NOTOSANS_MEDIUM68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x1E, 0x00, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xE0, 0x3F, 0xBF,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFE, 0x7C, 0x7F, 0x9F, 0xF0, 0xF8, 0x0E, 0x3F, 0xC1, 0xF0,
  0x04, 0x7F, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x01, 0xFC, 0x0F, 0x80,
  0x03, 0xF8, 0x1F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xF0, 0x7C, 0x00,
  0x1F, 0xF0, 0xF8, 0x00, 0x1F, 0xFD, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xCF, 0xFE, 0x00,
  0x0F, 0x87, 0xFC, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0x3E, 0x07, 0xF0, 0x00,
  0x7C, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0x3F, 0x80, 0x03,
  0xE0, 0x7F, 0xC0, 0x07, 0xC1, 0xFF, 0xF0, 0x0F, 0x87, 0xFB, 0xFE, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x7E, 0x0F, 0xFC, 0x07, 0xC0, 0x3F, 0x07,
  0xE1, 0xFF, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xE0, 0x7F,
  0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF,
  0xFE, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0x07, 0xE0,
  0xFF, 0xF8, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xFF, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7F,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xC7, 0xFC, 0x00,
  0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xFD, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x80, 0x07, 0xC0, 0x02, 0xF0, 0x07, 0xC0, 0x1E, 0xFF, 0x07, 0xC0,
  0xFE, 0xFF, 0xE7, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0x7F, 0x7F, 0xE7, 0xFF, 0xFC, 0x7F,
  0x7F, 0x07, 0xF3, 0xE0, 0x7F, 0x1C, 0x07, 0xF0, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0x00, 0x0F, 0xF8, 0x1E, 0x00, 0x03, 0xFC, 0x0E, 0x00,
  0x00, 0xFF, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC,
  0x3F, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x03, 0xFC, 0x10, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0xC0, 0x00, 0x03, 0xFE, 0xF8, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x80, 0x00, 0x03, 0xFD, 0x80, 0x00, 0x1F, 0xF3, 0xE0, 0x00,
  0x7F, 0xE7, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x0F,
  0xE0, 0xFF, 0xF0, 0x07, 0xF1, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0x81,
  0xF9, 0xFF, 0xFF, 0xE1, 0xFD, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x07, 0xFE,
  0x7F, 0xF8, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x87, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x07,
  0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x9F, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFF,
  0xEF, 0xC1, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF,
  0xC3, 0xF8, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFA, 0x00, 0x00,
  0x00, 0x08, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0xF0, 0x01, 0x00, 0xFC,
  0x1F, 0xE1, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x7F, 0x00, 0x7F, 0xE3, 0x80, 0x01, 0xFE, 0x20, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x3F, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0xF1, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xCF, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x7E, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x0F,
  0x80, 0x1F, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0x80,
  0x07, 0xE0, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x07,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0xFC, 0x03, 0xF0, 0x01, 0xFC,
  0x01, 0xF7, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xBF, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xF9, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x0F, 0xCF, 0xC0, 0x1F,
  0xF1, 0xFF, 0xF1, 0xFC, 0x3E, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xC1, 0xF8,
  0x01, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00,
  0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x01, 0xFF,
  0x8F, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0xFE,
  0x00, 0x00, 0x20, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x01,
  0xFF, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF4, 0x0F, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xEF, 0xF8, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xBF, 0x00, 0x00, 0x03, 0xF7, 0xFF, 0xEF, 0xE0, 0x00, 0x00, 0xFD, 0xFF,
  0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0x9F,
  0xFF, 0x9F, 0xC0, 0x00, 0x07, 0xE7, 0xFF, 0xE7, 0xF0, 0x00, 0x03, 0xF9,
  0xFF, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0x1F, 0xFF, 0x8F, 0xE0, 0x00, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x00, 0x07,
  0xE1, 0xFF, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x00,
  0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xFF, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFF, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xF0,
  0x01, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0xFE,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFD, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3C, 0x3F, 0xC0, 0x00,
  0x10, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xFF, 0x00,
  0xF0, 0x01, 0xFF, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF3, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xBF, 0xF0, 0x3F, 0xFF, 0x7F, 0xFF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF9, 0xFC,
  0x7F, 0xFF, 0xE1, 0xF8, 0x7F, 0xFF, 0x83, 0xF0, 0x3F, 0xFC, 0x07, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0xFE, 0x1F,
  0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFF, 0x00,
  0x3F, 0xE3, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0xFF,
  0xFF, 0xF0, 0x7E, 0x3F, 0xFF, 0xF0, 0x3E, 0x0F, 0xFF, 0xF0, 0x1F, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xE1, 0xFF, 0x00, 0x04, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x4F, 0xFC, 0x00, 0x70, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x0B, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0x01, 0xFF,
  0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0xFF, 0xCF, 0xE1, 0xFF,
  0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x80, 0x3F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF,
  0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F,
  0xFE, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x1F, 0xF0, 0x00, 0x1C, 0x1F,
  0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x10, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0xFF, 0xFE, 0x1F,
  0xC0, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFB,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xC0, 0x07,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xFF, 0x9F,
  0xC1, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x07,
  0xF8, 0x00, 0x78, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE1, 0x80, 0x00,
  0x1F, 0xF0, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0xFE, 0x1F, 0xFF,
  0xC1, 0xFC, 0xFF, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x00, 0x04, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0xFE,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x07, 0xE1, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF1, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0xF8, 0x07, 0xFF, 0x01, 0xF8, 0x3F, 0xFF, 0x83, 0xF1,
  0xFF, 0xFF, 0xC7, 0xE7, 0xFF, 0xFF, 0xCF, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x07, 0xFE,
  0x00, 0x7E, 0x0F, 0xFF, 0xC0, 0x3F, 0x1F, 0xFF, 0xF8, 0x1F, 0x9F, 0xFF,
  0xFE, 0x0F, 0xDF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x1F,
  0xF3, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0xFC, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7E, 0x7F, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xF8, 0x1F, 0xC7, 0xFF,
  0xF8, 0x0F, 0xE0, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x1F, 0x80, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x8F,
  0xE0, 0xFF, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFF, 0x9F,
  0xE0, 0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x07, 0xF8, 0x00, 0x78, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xFE, 0xFC, 0xFF, 0xFB, 0xF7, 0xFF, 0xEF, 0xDF, 0xE1, 0xBF, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0x1F, 0xE0, 0x01, 0xE3, 0xF8, 0x00, 0x08,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x83, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0x7F,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x0F,
  0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0x01, 0xFF, 0xF0, 0x3F, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xDF, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xE7,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x3F, 0x03,
  0xF8, 0x01, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x07,
  0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7F,
  0x00, 0x03, 0xFB, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x8F, 0xFF, 0x00, 0x00, 0xCF, 0xFF, 0xF0, 0x00, 0xEF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFD, 0xC0, 0x03, 0xFF, 0xFC, 0xC0, 0x00, 0x7F, 0xFC, 0x40, 0x00, 0x03,
  0xF0, 0x00,
};

const GFXglyph NotoSans_Medium68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 50, 19, 5, -49 },
  { 58, 21, 18, 29, 4, -49 },
  { 106, 40, 49, 44, 2, -49 },
  { 351, 31, 56, 39, 4, -52 },
  { 568, 52, 50, 58, 3, -49 },
  { 893, 47, 50, 50, 3, -49 },
  { 1187, 8, 18, 16, 4, -49 },
  { 1205, 16, 60, 21, 3, -49 },
  { 1325, 17, 60, 21, 2, -49 },
  { 1453, 32, 31, 37, 3, -52 },
  { 1577, 33, 32, 39, 3, -40 },
  { 1709, 11, 17, 19, 3, -8 },
  { 1733, 16, 6, 22, 3, -21 },
  { 1745, 9, 10, 19, 5, -9 },
  { 1757, 25, 49, 26, 1, -49 },
  { 1911, 33, 50, 39, 3, -49 },
  { 2118, 20, 49, 39, 5, -49 },
  { 2241, 33, 49, 39, 3, -49 },
  { 2444, 32, 50, 39, 3, -49 },
  { 2644, 37, 49, 39, 1, -49 },
  { 2871, 31, 50, 39, 4, -49 },
  { 3065, 33, 50, 39, 3, -49 },
  { 3272, 33, 49, 39, 3, -49 },
  { 3475, 33, 50, 39, 3, -49 },
  { 3682, 33, 50, 39, 3, -49 },
  { 3889, 9, 39, 19, 5, -38 },
  { 3933, 12, 47, 19, 2, -38 },
  { 4004, 33, 34, 39, 3, -42 },
  { 4145, 31, 19, 39, 4, -33 },
  { 4219, 33, 34, 39, 3, -42 },
  { 4360, 28, 50, 30, 1, -49 },
  { 4535, 53, 55, 61, 4, -49 },
  { 4900, 44, 49, 45, 0, -49 },
  { 5170, 35, 49, 44, 6, -49 },
  { 5385, 37, 50, 43, 4, -49 },
  { 5617, 40, 49, 50, 6, -49 },
  { 5862, 28, 49, 38, 6, -49 },
  { 6034, 28, 49, 36, 6, -49 },
  { 6206, 40, 50, 49, 4, -49 },
  { 6456, 38, 49, 51, 6, -49 },
  { 6689, 18, 49, 24, 3, -49 },
  { 6800, 19, 62, 20, -5, -49 },
  { 6948, 37, 49, 43, 6, -49 },
  { 7175, 28, 49, 36, 6, -49 },
  { 7347, 50, 49, 62, 6, -49 },
  { 7654, 40, 49, 53, 6, -49 },
  { 7899, 45, 50, 53, 4, -49 },
  { 8181, 32, 49, 41, 6, -49 },
  { 8377, 45, 61, 53, 4, -49 },
  { 8721, 36, 49, 43, 6, -49 },
  { 8942, 31, 50, 37, 3, -49 },
  { 9136, 36, 49, 38, 1, -49 },
  { 9357, 38, 50, 50, 6, -49 },
  { 9595, 42, 49, 42, 0, -49 },
  { 9853, 62, 49, 64, 1, -49 },
  { 10233, 41, 49, 42, 0, -49 },
  { 10485, 40, 49, 40, 0, -49 },
  { 10730, 35, 49, 39, 2, -49 },
  { 10945, 16, 60, 22, 5, -49 },
  { 11065, 25, 49, 26, 1, -49 },
  { 11219, 15, 60, 22, 2, -49 },
  { 11332, 35, 31, 39, 2, -49 },
  { 11468, 30, 5, 30, 0, 6 },
  { 11487, 15, 11, 21, 3, -52 },
  { 11508, 31, 38, 39, 3, -37 },
  { 11656, 33, 53, 42, 6, -52 },
  { 11875, 27, 38, 33, 4, -37 },
  { 12004, 33, 53, 42, 4, -52 },
  { 12223, 32, 38, 39, 4, -37 },
  { 12375, 26, 52, 24, 1, -52 },
  { 12544, 33, 53, 42, 4, -37 },
  { 12763, 31, 52, 43, 6, -52 },
  { 12965, 8, 51, 18, 5, -51 },
  { 13016, 17, 67, 18, -4, -51 },
  { 13159, 32, 52, 38, 6, -52 },
  { 13367, 7, 52, 18, 6, -52 },
  { 13413, 53, 37, 64, 6, -37 },
  { 13659, 31, 37, 43, 6, -37 },
  { 13803, 34, 38, 42, 4, -37 },
  { 13965, 33, 53, 42, 6, -37 },
  { 14184, 33, 53, 42, 4, -37 },
  { 14403, 22, 37, 29, 6, -37 },
  { 14505, 27, 38, 33, 3, -37 },
  { 14634, 23, 46, 26, 1, -45 },
  { 14767, 32, 38, 43, 5, -37 },
  { 14919, 36, 37, 36, 0, -37 },
  { 15086, 53, 37, 55, 1, -37 },
  { 15332, 35, 37, 37, 1, -37 },
  { 15494, 36, 53, 36, 0, -37 },
  { 15733, 28, 37, 32, 2, -37 },
  { 15863, 22, 60, 26, 2, -49 },
  { 16028, 6, 68, 37, 16, -52 },
  { 16079, 22, 60, 26, 2, -49 },
  { 16244, 33, 10, 39, 3, -29 },
};

const GFXfont NotoSans_Medium68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium68pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_MEDIUM68PT7B_H_
