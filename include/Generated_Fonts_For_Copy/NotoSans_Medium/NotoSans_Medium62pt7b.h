#ifndef _NOTOSANS_MEDIUM62PT7B_H_
#define _NOTOSANS_MEDIUM62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xE3, 0xC0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x7E,
  0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF3, 0xE0, 0x7E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0x07, 0xC7, 0xF0, 0x78, 0x04, 0x3F, 0x03,
  0xC0, 0x03, 0xF8, 0x1E, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFE, 0x07, 0x80,
  0x03, 0xF0, 0x3C, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0xFF, 0x8F, 0x00, 0x03,
  0xFF, 0x78, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xC7, 0xFC,
  0x00, 0x1E, 0x1F, 0xE0, 0x00, 0xF0, 0x7F, 0x00, 0x07, 0x81, 0xF8, 0x00,
  0x3C, 0x0F, 0xC0, 0x01, 0xE0, 0x7E, 0x00, 0x0F, 0x07, 0xF4, 0x00, 0x78,
  0x3F, 0xBC, 0x03, 0xC7, 0xF9, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x3E, 0x1F, 0x87,
  0xFF, 0x0F, 0xC0, 0x7C, 0x3E, 0x1F, 0xFF, 0x0F, 0x81, 0xF8, 0xFC, 0x7F,
  0xFF, 0x1F, 0x87, 0xE1, 0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF0,
  0x7E, 0x3F, 0xFF, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0xFC, 0x3F, 0x0F, 0x80,
  0xF8, 0x3F, 0xF0, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x03, 0xF8,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xC1, 0xFE,
  0x00, 0x7F, 0xC3, 0xF8, 0x3F, 0x80, 0x07, 0xFC, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0xDF, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF,
  0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x40, 0x0F, 0x80, 0x09, 0xF0, 0x1E, 0x03, 0xE7, 0xF8,
  0x78, 0x7F, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE,
  0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xBF, 0x7F,
  0xCF, 0xFF, 0xE3, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0x38, 0x0F, 0xC4, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0x80,
  0x07, 0xF8, 0x3C, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0x87, 0x80,
  0x01, 0xFC, 0x10, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFB, 0x80, 0x00, 0x7F, 0xDF, 0x80, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x1F, 0xEE, 0x00, 0x03, 0xFC, 0xFC,
  0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xCF, 0x80, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x07, 0xE1, 0xFF, 0xF0, 0x3F,
  0x9F, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xC3, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF,
  0x83, 0xFF, 0x3F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x03, 0xFC, 0x03,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xF0,
  0x03, 0xFC, 0x3F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1D, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x3F, 0xF7,
  0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0xFD, 0xF8, 0x7F,
  0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0x1F, 0x80, 0xFF, 0xF8, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFD, 0xFC, 0xFE, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x8F, 0xEF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0x00, 0x0F, 0x83,
  0xF8, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF0, 0xFE, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF9, 0xF8, 0x03, 0xFC, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x7F, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x01,
  0xFF, 0xFF, 0xC0, 0x7C, 0x7E, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x3E, 0x01,
  0xFE, 0x03, 0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xDF, 0x80,
  0xFC, 0x00, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF7, 0xC0,
  0x7E, 0x00, 0x3F, 0x00, 0xFB, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7D, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0xFC,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xFE, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xFF,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x7C, 0x01, 0xFF,
  0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF3, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xF9,
  0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0xFC, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x7C,
  0x7C, 0x03, 0xFC, 0x3E, 0xF8, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0x7F, 0xFE,
  0x1F, 0x80, 0x3F, 0xFF, 0x1F, 0xFE, 0x07, 0xC0, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF, 0x3F, 0x80, 0x03, 0xFE, 0x7F, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0xFC, 0x1F, 0xF8, 0x00, 0x0C, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0C, 0x0F, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE,
  0x00, 0x0F, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xE0,
  0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x3F, 0x7F, 0x80, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0x3F,
  0xC0, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0xFF, 0x80, 0x00, 0x3F, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0xFC,
  0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03,
  0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xBF, 0xFD, 0xF8, 0x00, 0x00, 0xFD,
  0xFF, 0xEF, 0xC0, 0x00, 0x07, 0xEF, 0xFF, 0x7E, 0x00, 0x00, 0x3E, 0x7F,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xFF, 0xCF, 0xC0, 0x00, 0x1F, 0x1F, 0xFE,
  0x7E, 0x00, 0x01, 0xF8, 0xFF, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xFF, 0x8F,
  0xC0, 0x00, 0x7C, 0x3F, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xFF, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xFF, 0x0F, 0xC0, 0x01, 0xF0, 0x7F, 0xF8, 0x7F, 0x00,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xFF, 0x81, 0xF8, 0x03, 0xE0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xFF, 0x01, 0xF8, 0x0F, 0x80, 0x7F, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFF, 0xF0,
  0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0xFC, 0x01,
  0xF9, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x7C, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xDF,
  0xC0, 0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xE0, 0x00, 0x3F,
  0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xC7, 0xF8, 0x00, 0x3F, 0xFC, 0x3F, 0x80,
  0x03, 0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xC0,
  0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F,
  0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFC, 0x01, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0xC0, 0x03, 0xF8, 0x3F,
  0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0xC0, 0x01, 0xFE, 0x3F, 0xFC, 0x00, 0x0F,
  0xE3, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xFC, 0x00, 0x07, 0xFB, 0xFF, 0xC0,
  0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xF3, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x01,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFE,
  0x7F, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0,
  0x0F, 0xC7, 0xF8, 0x00, 0x1C, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x7F, 0x00,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x1F, 0xE0, 0x40, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF8, 0x07, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xF7, 0xFF, 0xFF, 0xBF, 0x7F, 0xFF, 0xF3, 0xF3, 0xFF, 0xFE, 0x3F,
  0x1F, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE3, 0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0xE0, 0xFC,
  0xFF, 0xFF, 0xC3, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x3F, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF, 0x80, 0x7F,
  0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0x7F, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0x83,
  0xE1, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC0, 0x1C, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x11, 0xFF, 0x80, 0x78, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x1F, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF,
  0x3F, 0x07, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xCF, 0xFF,
  0xC7, 0xF8, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xBF, 0x07, 0xFF,
  0xFC, 0x7C, 0x0F, 0xFF, 0xE1, 0xF0, 0x0F, 0xFE, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x21, 0xFF, 0x80, 0x1F, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFE, 0x04, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC1,
  0xF0, 0x3F, 0xFF, 0xC7, 0xC1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF3, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0x3F,
  0x80, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xEF, 0xC1, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0x83,
  0xF0, 0x00, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x40, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x03,
  0xF8, 0x7F, 0xFC, 0x1F, 0xCF, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0xC7, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0xFD, 0xFF, 0xC0, 0x1F, 0xEF, 0xF8, 0x00,
  0x7F, 0x7F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x7E, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xC0, 0x07,
  0xFC, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF1,
  0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7C, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xC1, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF,
  0xF1, 0xF9, 0xFF, 0xFF, 0xCF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFB,
  0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0xFF, 0xF8, 0x0F, 0xC7, 0xFF,
  0xF8, 0x3F, 0x3F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xF0, 0x03, 0xFC, 0xFF,
  0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFC, 0x3F, 0x3F,
  0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0x03, 0xF8, 0x7F, 0xF0, 0x0F, 0xE0, 0x1E,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0xC1, 0xF0, 0x3F, 0xFF, 0xC7, 0xC1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xE1, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0x01, 0xFF,
  0x3F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xCF,
  0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xEF, 0xC1, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xF8, 0xFC, 0x03, 0xFF,
  0x83, 0xF0, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0x80, 0xFC, 0xFE, 0x00, 0x0C, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x10, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x38, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFC,
  0x7F, 0xFF, 0xE7, 0xE1, 0xFF, 0xFE, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x01,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3E, 0x7C,
  0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7C, 0x3E,
  0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xF0, 0x0F, 0xE1, 0xF8, 0x1F,
  0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0xE0, 0x07, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x07,
  0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x01, 0xF7, 0xE0, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1D, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09,
  0xFF, 0xF0, 0x00, 0xDF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xD0, 0x00, 0x1F,
  0xF8, 0x80, 0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_Medium62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 45, 17, 4, -44 },
  { 52, 19, 16, 27, 4, -44 },
  { 90, 38, 44, 40, 1, -44 },
  { 299, 29, 51, 35, 3, -47 },
  { 484, 47, 46, 53, 3, -45 },
  { 755, 43, 46, 46, 3, -45 },
  { 1003, 7, 16, 15, 4, -44 },
  { 1017, 15, 54, 19, 2, -44 },
  { 1119, 15, 54, 19, 2, -44 },
  { 1221, 30, 28, 34, 2, -47 },
  { 1326, 29, 30, 35, 3, -37 },
  { 1435, 10, 15, 17, 2, -7 },
  { 1454, 16, 5, 20, 2, -19 },
  { 1464, 9, 9, 17, 4, -8 },
  { 1475, 22, 44, 24, 1, -44 },
  { 1596, 30, 46, 35, 3, -45 },
  { 1769, 18, 44, 35, 5, -44 },
  { 1868, 30, 45, 35, 3, -45 },
  { 2037, 29, 46, 35, 3, -45 },
  { 2204, 33, 44, 35, 1, -44 },
  { 2386, 28, 45, 35, 4, -44 },
  { 2544, 30, 46, 35, 3, -45 },
  { 2717, 31, 44, 35, 2, -44 },
  { 2888, 30, 46, 35, 3, -45 },
  { 3061, 30, 46, 35, 3, -45 },
  { 3234, 9, 35, 17, 4, -34 },
  { 3274, 11, 42, 17, 2, -34 },
  { 3332, 29, 31, 35, 3, -38 },
  { 3445, 29, 17, 35, 3, -30 },
  { 3507, 29, 31, 35, 3, -38 },
  { 3620, 25, 46, 28, 1, -45 },
  { 3764, 49, 49, 56, 3, -44 },
  { 4065, 41, 44, 41, 0, -44 },
  { 4291, 31, 44, 41, 6, -44 },
  { 4462, 33, 46, 39, 4, -45 },
  { 4652, 36, 44, 45, 6, -44 },
  { 4850, 25, 44, 35, 6, -44 },
  { 4988, 25, 44, 33, 6, -44 },
  { 5126, 36, 46, 45, 4, -45 },
  { 5333, 34, 44, 46, 6, -44 },
  { 5520, 18, 44, 22, 2, -44 },
  { 5619, 17, 56, 18, -5, -44 },
  { 5738, 33, 44, 39, 6, -44 },
  { 5920, 25, 44, 33, 6, -44 },
  { 6058, 45, 44, 57, 6, -44 },
  { 6306, 36, 44, 48, 6, -44 },
  { 6504, 41, 46, 49, 4, -45 },
  { 6740, 29, 44, 38, 6, -44 },
  { 6900, 41, 56, 49, 4, -45 },
  { 7187, 33, 44, 39, 6, -44 },
  { 7369, 28, 46, 34, 3, -45 },
  { 7530, 33, 44, 35, 1, -44 },
  { 7712, 34, 45, 46, 6, -44 },
  { 7904, 38, 44, 38, 0, -44 },
  { 8113, 58, 44, 58, 0, -44 },
  { 8432, 38, 44, 38, 0, -44 },
  { 8641, 36, 44, 36, 0, -44 },
  { 8839, 31, 44, 36, 2, -44 },
  { 9010, 14, 54, 20, 5, -44 },
  { 9105, 22, 44, 24, 1, -44 },
  { 9226, 14, 54, 20, 2, -44 },
  { 9321, 31, 29, 35, 2, -45 },
  { 9434, 27, 4, 27, 0, 6 },
  { 9448, 14, 9, 19, 2, -47 },
  { 9464, 28, 35, 35, 3, -34 },
  { 9587, 30, 48, 38, 5, -47 },
  { 9767, 25, 35, 30, 3, -34 },
  { 9877, 30, 48, 38, 3, -47 },
  { 10057, 29, 35, 36, 3, -34 },
  { 10184, 24, 47, 22, 1, -47 },
  { 10325, 30, 49, 38, 3, -34 },
  { 10509, 29, 47, 39, 5, -47 },
  { 10680, 7, 46, 17, 5, -46 },
  { 10721, 15, 61, 17, -3, -46 },
  { 10836, 29, 47, 35, 5, -47 },
  { 11007, 7, 47, 17, 5, -47 },
  { 11049, 49, 34, 59, 5, -34 },
  { 11258, 29, 34, 39, 5, -34 },
  { 11382, 32, 35, 38, 3, -34 },
  { 11522, 30, 49, 38, 5, -34 },
  { 11706, 30, 49, 38, 3, -34 },
  { 11890, 20, 34, 26, 5, -34 },
  { 11975, 24, 35, 30, 3, -34 },
  { 12080, 21, 42, 24, 1, -41 },
  { 12191, 29, 34, 39, 5, -33 },
  { 12315, 33, 33, 33, 0, -33 },
  { 12452, 48, 33, 50, 1, -33 },
  { 12650, 32, 33, 34, 1, -33 },
  { 12782, 33, 48, 33, 0, -33 },
  { 12980, 25, 33, 30, 2, -33 },
  { 13084, 21, 54, 24, 1, -44 },
  { 13226, 5, 62, 34, 15, -47 },
  { 13265, 20, 54, 24, 2, -44 },
  { 13400, 29, 9, 35, 3, -26 },
};

const GFXfont NotoSans_Medium62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium62pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_MEDIUM62PT7B_H_
