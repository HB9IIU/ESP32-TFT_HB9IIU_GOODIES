#ifndef _NOTOSANS_MEDIUM13PT7B_H_
#define _NOTOSANS_MEDIUM13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xA2, 0xC0, 0xBB, 0x90, 0x12, 0x12, 0x7F, 0x34, 0x24, 0xFF,
  0x24, 0x28, 0x68, 0x21, 0xFE, 0xA8, 0xE1, 0xE2, 0xCB, 0xF8, 0x82, 0x00,
  0xE3, 0x28, 0x8B, 0x42, 0xB4, 0xEA, 0x84, 0xA1, 0x6C, 0x8A, 0x63, 0x80,
  0x78, 0x64, 0x12, 0x0E, 0x07, 0x14, 0xDA, 0x39, 0x1C, 0x7B, 0x80, 0xE0,
  0x7A, 0x49, 0x24, 0x99, 0x80, 0xC6, 0x22, 0x23, 0x22, 0x26, 0xC0, 0x10,
  0x21, 0xFC, 0x82, 0x8D, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x69,
  0x60, 0xF0, 0xB0, 0x18, 0x84, 0x42, 0x31, 0x08, 0xC0, 0x7A, 0x28, 0xE3,
  0x8E, 0x38, 0xF2, 0x78, 0x3D, 0xB3, 0x33, 0x33, 0x30, 0xFA, 0x20, 0x82,
  0x18, 0xC6, 0x30, 0xFC, 0xF8, 0x20, 0x86, 0x78, 0x30, 0xE3, 0xF8, 0x0C,
  0x28, 0x51, 0x24, 0x48, 0xBF, 0x82, 0x04, 0xFA, 0x08, 0x3C, 0x98, 0x30,
  0xE2, 0xF8, 0x7B, 0x08, 0x2E, 0xCE, 0x38, 0xF3, 0x78, 0xFE, 0x0C, 0x10,
  0x60, 0x83, 0x04, 0x18, 0x20, 0xFA, 0x38, 0x9E, 0x7A, 0x38, 0x63, 0xF8,
  0xFA, 0x28, 0xE3, 0xDD, 0xB0, 0x86, 0xF0, 0xE0, 0x2C, 0x68, 0x00, 0xD2,
  0x80, 0x04, 0x66, 0x20, 0x70, 0x70, 0x40, 0xFC, 0x0F, 0xC0, 0x83, 0x83,
  0x83, 0x33, 0x08, 0x00, 0xF8, 0x42, 0x33, 0x10, 0x04, 0x20, 0x3F, 0x10,
  0x2C, 0xE6, 0x49, 0xB2, 0x68, 0x99, 0x6A, 0x24, 0x40, 0x0F, 0xC0, 0x18,
  0x0E, 0x0D, 0x04, 0x82, 0x63, 0xF1, 0x0C, 0x86, 0xC1, 0x80, 0xFD, 0x8B,
  0x1E, 0x6F, 0xD8, 0xF1, 0xE3, 0xFC, 0x7F, 0x83, 0x04, 0x08, 0x10, 0x30,
  0x30, 0x3C, 0xFC, 0xC6, 0xC2, 0xC3, 0xC3, 0xC3, 0xC2, 0xC6, 0xF8, 0xFE,
  0x31, 0x8F, 0xE3, 0x18, 0xF8, 0xFE, 0x31, 0x8F, 0xE3, 0x18, 0xC0, 0x7E,
  0x83, 0x04, 0x08, 0xF0, 0x70, 0xB1, 0x3E, 0xC3, 0x87, 0x0E, 0x1F, 0xF8,
  0x70, 0xE1, 0xC2, 0xF2, 0x22, 0x22, 0x22, 0xF0, 0x33, 0x33, 0x33, 0x33,
  0x33, 0xEC, 0xC7, 0x9B, 0x67, 0x8F, 0x1B, 0x32, 0x62, 0xC6, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xFC, 0xE1, 0xE8, 0x7A, 0x1F, 0xCF, 0xD2, 0xF4,
  0xBD, 0xCF, 0x33, 0xCC, 0xC0, 0xC1, 0xE1, 0xB1, 0xD1, 0xD9, 0xCD, 0xC5,
  0xC7, 0xC3, 0x7E, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0xC1, 0x63, 0x3E, 0xFF,
  0x1C, 0x71, 0xFF, 0x0C, 0x30, 0xC0, 0x7E, 0xC3, 0xC1, 0x81, 0x81, 0x81,
  0xC1, 0x63, 0x3E, 0x04, 0x03, 0xFD, 0x8B, 0x16, 0x2F, 0x9B, 0x33, 0x62,
  0xC6, 0xFA, 0x08, 0x30, 0x78, 0x20, 0xE2, 0xF8, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xA3, 0x7C,
  0xC3, 0x42, 0x42, 0x66, 0x24, 0x24, 0x3C, 0x18, 0x18, 0xC6, 0x34, 0x63,
  0x47, 0x24, 0xD2, 0x69, 0x22, 0x96, 0x29, 0xC3, 0x0C, 0x30, 0xC0, 0xC3,
  0x66, 0x3C, 0x18, 0x18, 0x3C, 0x24, 0x66, 0xC3, 0xC3, 0x46, 0x64, 0x2C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0x08, 0x30, 0xC1, 0x06, 0x18, 0x20,
  0xFE, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x10, 0x42, 0x18, 0x42, 0x18,
  0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0x50, 0xA3, 0x24, 0x58, 0x40, 0xFC,
  0x90, 0xF8, 0x43, 0xF8, 0xC7, 0xE0, 0x82, 0x08, 0x2E, 0xCF, 0x18, 0x71,
  0xCE, 0xE0, 0x7E, 0x21, 0x08, 0x61, 0xE0, 0x04, 0x10, 0x5D, 0xCE, 0x18,
  0x61, 0xCD, 0xD0, 0x7B, 0x38, 0xFF, 0x83, 0x07, 0x80, 0x39, 0x19, 0xF6,
  0x31, 0x8C, 0x63, 0x00, 0x77, 0x38, 0x61, 0x87, 0x37, 0x41, 0x8F, 0xE0,
  0x82, 0x08, 0x2F, 0xCF, 0x18, 0x61, 0x86, 0x10, 0xB2, 0xAA, 0xA0, 0x23,
  0x02, 0x22, 0x22, 0x22, 0x22, 0xE0, 0x82, 0x08, 0x23, 0x9A, 0xCF, 0x24,
  0x9A, 0x30, 0xFF, 0xC0, 0xBB, 0xF3, 0x1C, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC4, 0xBF, 0x3C, 0x61, 0x86, 0x18, 0x40, 0x7B, 0x38, 0x61, 0x87, 0x37,
  0x80, 0xBB, 0x3C, 0x61, 0xC7, 0x3B, 0xA0, 0x82, 0x00, 0x77, 0x38, 0x61,
  0x87, 0x37, 0x41, 0x04, 0x10, 0xBC, 0xC8, 0x88, 0x80, 0xFC, 0x30, 0xE1,
  0xCF, 0xC0, 0x23, 0x3E, 0xC6, 0x31, 0x8C, 0x38, 0x86, 0x18, 0x61, 0x87,
  0x37, 0x40, 0xC6, 0x89, 0x13, 0x62, 0x87, 0x0C, 0x00, 0xCC, 0x53, 0x14,
  0xAD, 0x6A, 0x72, 0x8C, 0xE3, 0x18, 0xC6, 0xD8, 0xE0, 0x82, 0x8D, 0xB1,
  0x80, 0xC6, 0x89, 0x13, 0x62, 0x85, 0x04, 0x08, 0x31, 0xC0, 0x7C, 0x21,
  0x8C, 0x21, 0x0F, 0xC0, 0x39, 0x08, 0x42, 0x60, 0x84, 0x21, 0x0E, 0xFF,
  0xF8, 0xE1, 0x08, 0x42, 0x0C, 0x84, 0x21, 0x30, 0x47, 0xF0,
};

const GFXglyph NotoSans_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 11, 7, 1, -10 },
  { 24, 10, 9, 11, 1, -9 },
  { 36, 9, 9, 10, 1, -9 },
  { 47, 1, 3, 3, 1, -9 },
  { 48, 3, 11, 4, 1, -9 },
  { 53, 4, 11, 4, 0, -9 },
  { 59, 7, 6, 7, 0, -10 },
  { 65, 6, 7, 7, 1, -8 },
  { 71, 3, 4, 4, 0, -2 },
  { 73, 4, 1, 4, 0, -4 },
  { 74, 2, 2, 4, 1, -2 },
  { 75, 5, 9, 5, 0, -9 },
  { 81, 6, 9, 7, 1, -9 },
  { 88, 4, 9, 7, 1, -9 },
  { 93, 6, 9, 7, 1, -9 },
  { 100, 6, 9, 7, 1, -9 },
  { 107, 7, 9, 7, 0, -9 },
  { 115, 6, 9, 7, 1, -9 },
  { 122, 6, 9, 7, 1, -9 },
  { 129, 7, 9, 7, 0, -9 },
  { 137, 6, 9, 7, 1, -9 },
  { 144, 6, 9, 7, 1, -9 },
  { 151, 2, 7, 4, 1, -7 },
  { 153, 3, 9, 4, 0, -7 },
  { 157, 6, 7, 7, 1, -8 },
  { 163, 6, 3, 7, 1, -6 },
  { 166, 6, 7, 7, 1, -8 },
  { 172, 5, 9, 6, 0, -9 },
  { 178, 10, 10, 12, 1, -9 },
  { 191, 9, 9, 9, 0, -9 },
  { 202, 7, 9, 9, 1, -9 },
  { 210, 7, 9, 8, 1, -9 },
  { 218, 8, 9, 10, 1, -9 },
  { 227, 5, 9, 7, 1, -9 },
  { 233, 5, 9, 7, 1, -9 },
  { 239, 7, 9, 9, 1, -9 },
  { 247, 7, 9, 10, 1, -9 },
  { 255, 4, 9, 5, 0, -9 },
  { 260, 4, 12, 4, -1, -9 },
  { 266, 7, 9, 8, 1, -9 },
  { 274, 6, 9, 7, 1, -9 },
  { 281, 10, 9, 12, 1, -9 },
  { 293, 8, 9, 10, 1, -9 },
  { 302, 8, 9, 10, 1, -9 },
  { 311, 6, 9, 8, 1, -9 },
  { 318, 8, 11, 10, 1, -9 },
  { 329, 7, 9, 8, 1, -9 },
  { 337, 6, 9, 7, 1, -9 },
  { 344, 7, 9, 7, 0, -9 },
  { 352, 7, 9, 10, 1, -9 },
  { 360, 8, 9, 8, 0, -9 },
  { 369, 12, 9, 12, 0, -9 },
  { 383, 8, 9, 8, 0, -9 },
  { 392, 8, 9, 8, 0, -9 },
  { 401, 7, 9, 7, 0, -9 },
  { 409, 3, 11, 4, 1, -9 },
  { 414, 5, 9, 5, 0, -9 },
  { 420, 3, 11, 4, 0, -9 },
  { 425, 7, 6, 7, 0, -9 },
  { 431, 6, 1, 6, 0, 1 },
  { 432, 2, 2, 4, 1, -10 },
  { 433, 5, 7, 7, 1, -7 },
  { 438, 6, 10, 8, 1, -10 },
  { 446, 5, 7, 6, 1, -7 },
  { 451, 6, 10, 8, 1, -10 },
  { 459, 6, 7, 7, 1, -7 },
  { 465, 5, 10, 5, 0, -10 },
  { 472, 6, 10, 8, 1, -7 },
  { 480, 6, 10, 8, 1, -10 },
  { 488, 2, 10, 4, 1, -10 },
  { 491, 4, 13, 4, -1, -10 },
  { 498, 6, 10, 7, 1, -10 },
  { 506, 1, 10, 4, 1, -10 },
  { 508, 10, 7, 12, 1, -7 },
  { 517, 6, 7, 8, 1, -7 },
  { 523, 6, 7, 8, 1, -7 },
  { 529, 6, 10, 8, 1, -7 },
  { 537, 6, 10, 8, 1, -7 },
  { 545, 4, 7, 6, 1, -7 },
  { 549, 5, 7, 6, 1, -7 },
  { 554, 5, 9, 5, 0, -9 },
  { 560, 6, 7, 8, 1, -7 },
  { 566, 7, 7, 7, 0, -7 },
  { 573, 10, 7, 10, 0, -7 },
  { 582, 7, 7, 7, 0, -7 },
  { 589, 7, 10, 7, 0, -7 },
  { 598, 6, 7, 6, 0, -7 },
  { 604, 5, 11, 5, 0, -9 },
  { 611, 1, 13, 7, 3, -10 },
  { 613, 5, 11, 5, 0, -9 },
  { 620, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Medium13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium13pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_MEDIUM13PT7B_H_
