#ifndef _NOTOSANS_MEDIUM50PT7B_H_
#define _NOTOSANS_MEDIUM50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0x00, 0x00, 0x02, 0x1F, 0x3F, 0xFF, 0xFD, 0xFB, 0xF3, 0x80, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0xBC,
  0x1F, 0x78, 0x3E, 0xF0, 0x3D, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFC, 0x70, 0x73, 0xF0, 0xE0, 0x07, 0xC1, 0xC0,
  0x0F, 0x83, 0x80, 0x1F, 0x07, 0x00, 0x3F, 0x0E, 0x00, 0x7F, 0x1C, 0x00,
  0x7F, 0xB8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1D, 0xFE, 0x00,
  0x38, 0xFE, 0x00, 0x70, 0xFC, 0x00, 0xE0, 0xF8, 0x01, 0xC1, 0xF0, 0x03,
  0x83, 0xF0, 0x07, 0x0F, 0xFC, 0x0E, 0x7F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x80,
  0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x3E, 0x07, 0x80,
  0x78, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x0F,
  0x81, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x1F, 0x0F,
  0x80, 0x03, 0xE0, 0x78, 0x3C, 0x00, 0x0F, 0x81, 0xE1, 0xF0, 0xF8, 0x1E,
  0x07, 0x87, 0x8F, 0xF8, 0x78, 0x3E, 0x3C, 0x7F, 0xF1, 0xF0, 0xF9, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0x8F, 0x8F, 0x8F, 0xFF, 0x3E, 0x3C, 0x1F, 0x1F,
  0xF8, 0xF1, 0xF0, 0x3C, 0x1F, 0x87, 0xC7, 0xC0, 0xF0, 0x00, 0x1E, 0x1E,
  0x03, 0xC0, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x00, 0xFC,
  0xF8, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x0F, 0xFF, 0xE0, 0x0F, 0x83,
  0xF8, 0xFE, 0x01, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFE, 0x0F,
  0x83, 0xF0, 0x0F, 0xE3, 0xF0, 0x7C, 0x00, 0xFE, 0x7C, 0x1F, 0x80, 0x0F,
  0xFF, 0x83, 0xF0, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0xFC, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xFE, 0x01,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x8F,
  0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x30, 0x1E, 0x07, 0xFE, 0x38, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x0F,
  0x80, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xE0, 0x38, 0x00, 0x40, 0x40,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xF9, 0xFF,
  0xFF, 0xEF, 0xDF, 0x9C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xE3, 0xF8, 0x3F, 0x80, 0xFC,
  0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x1F, 0x00, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0xBF, 0xBF,
  0xFE, 0x7E, 0xF0, 0xFC, 0xC1, 0xF9, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFC, 0x3E, 0x00, 0xFC, 0x38,
  0x00, 0x7E, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x3C, 0x00, 0xFC, 0x30,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0xC0,
  0x00, 0xFE, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xB0, 0x00, 0x7F, 0x7C, 0x03, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x04,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x06, 0x00, 0x7C, 0x7F, 0xE0, 0x7C, 0xFF, 0xF8, 0x7D, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3F, 0x00, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xC3, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0xFE,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0xC3, 0xFF,
  0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x07, 0xFF, 0x1F, 0x01, 0xFC, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF,
  0x8C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x1F, 0x3F, 0xFF, 0xFD, 0xFB, 0xF3, 0x80, 0x08, 0x3E, 0x7F, 0x7F,
  0x7F, 0x7F, 0x3E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE7, 0xF0, 0xFF, 0x1C, 0x00, 0xFC, 0x80, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x03, 0xFF, 0x81,
  0xF1, 0xE0, 0x1F, 0xFF, 0x81, 0xE7, 0xC0, 0x7F, 0xFF, 0x03, 0xCF, 0x01,
  0xFE, 0x3E, 0x03, 0xDE, 0x07, 0xE0, 0x3C, 0x07, 0xFC, 0x0F, 0x80, 0x78,
  0x0F, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0xE0, 0x7C, 0x01, 0xE0, 0x3F, 0xC0,
  0xF0, 0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x0F,
  0x01, 0xFE, 0x07, 0x80, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0x7C, 0x07, 0xF8,
  0x1E, 0x00, 0xF8, 0x1E, 0xF0, 0x3E, 0x01, 0xF0, 0x3D, 0xE0, 0x7C, 0x07,
  0xE0, 0xFB, 0xC0, 0x7C, 0x1F, 0xE3, 0xE7, 0xC0, 0xFF, 0xFB, 0xFF, 0x87,
  0x80, 0xFF, 0xE3, 0xFE, 0x0F, 0x00, 0x7F, 0x83, 0xF8, 0x1F, 0x00, 0x10,
  0x00, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x80,
  0x01, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x03, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xC0, 0x07, 0xF3, 0xE0, 0x01,
  0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0,
  0x03, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0x80, 0x0F, 0xF7, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFB, 0xE0, 0x01, 0xFD, 0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFB,
  0xFC, 0x1F, 0xE0, 0x03, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x10, 0x7F, 0xE0, 0x3E, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xFF, 0xC3, 0xE0,
  0x00, 0xFE, 0x1F, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xE7, 0xC0, 0x00,
  0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F,
  0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x3E,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xFC, 0x7C, 0x00,
  0x1F, 0xC3, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xF0, 0x3F, 0xE0, 0x01, 0xC1, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x0F, 0xC3, 0xFF, 0x00, 0x7F,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7F, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC1, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xE1, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x87, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0xF8, 0x0F,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xFC, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x03,
  0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7F, 0x7C,
  0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF7, 0xC0, 0x00, 0x3F, 0xFF, 0x7C, 0x00, 0x03, 0xDF, 0xF3, 0xC0, 0x00,
  0x7D, 0xFF, 0x3E, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x79, 0xFF, 0x9E,
  0x00, 0x0F, 0x9F, 0xF9, 0xF0, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x0F, 0x1F,
  0xF8, 0xF8, 0x01, 0xF1, 0xFF, 0x8F, 0x80, 0x1E, 0x1F, 0xF8, 0xF8, 0x03,
  0xE1, 0xFF, 0x87, 0xC0, 0x3E, 0x1F, 0xF8, 0x7C, 0x03, 0xC1, 0xFF, 0x87,
  0xC0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x78, 0x1F,
  0xF8, 0x3E, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F,
  0x01, 0xFF, 0x80, 0xF1, 0xF0, 0x1F, 0xF8, 0x0F, 0x9E, 0x01, 0xFF, 0x80,
  0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFE, 0xFC, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0xFF,
  0x9F, 0x80, 0x07, 0xFC, 0x7E, 0x00, 0x3F, 0xE3, 0xF0, 0x01, 0xFF, 0x8F,
  0xC0, 0x0F, 0xFC, 0x7F, 0x00, 0x7F, 0xE1, 0xF8, 0x03, 0xFF, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0x00, 0xFF, 0xC0, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x3F,
  0xF0, 0x1F, 0x81, 0xFF, 0x80, 0x7E, 0x0F, 0xFC, 0x03, 0xF8, 0x7F, 0xE0,
  0x0F, 0xC3, 0xFF, 0x00, 0x3F, 0x1F, 0xF8, 0x01, 0xF8, 0xFF, 0xC0, 0x07,
  0xE7, 0xFE, 0x00, 0x1F, 0xBF, 0xF0, 0x00, 0xFD, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0x00, 0x7F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xFD,
  0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0B, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xC3,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F,
  0x3E, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F,
  0xC7, 0xE0, 0x07, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x7F, 0x01, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF9,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE3,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x78, 0x00, 0xFC, 0x1F,
  0x00, 0x3E, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7D, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xE7, 0xC0, 0x1F, 0x80, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xC0, 0xF8, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0xF8, 0x7E, 0x00, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x03, 0xE7, 0x80, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00,
  0x1E, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF0,
  0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xC7, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF0, 0x0F,
  0xC1, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xCF, 0xF8, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xDF, 0x80, 0xFF, 0xBF, 0xFF, 0xDF, 0x3F, 0xFF, 0xBE, 0x3F, 0xFC,
  0x7C, 0x3F, 0xF0, 0x78, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0x7E, 0xFF, 0x81,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFB, 0xFF, 0xF8, 0xF1, 0xFF, 0xF0, 0xF0, 0x7F,
  0xC0, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xC0, 0xE7, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0x3F,
  0x80, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x03,
  0xFE, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0xFF, 0xFF, 0x3F,
  0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFE, 0x0F, 0x00, 0x20, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x8F, 0xF0, 0x07, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x04, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF,
  0x3F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x81, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFE, 0x1F,
  0x00, 0x20, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x30, 0x00, 0xFE, 0x3F, 0x87, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xFF, 0x0F, 0x9F,
  0xFF, 0x1F, 0x7F, 0xFF, 0x3E, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xC0, 0x7B, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x0F, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xEC, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8,
  0x7F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xFE, 0xF8, 0x01, 0xFC, 0xF8, 0x03, 0xF8, 0xF8, 0x03, 0xF0, 0xF8,
  0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0xFB,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0xF8, 0x3F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0xE0, 0xF8, 0x07, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE1, 0xF3, 0xFF, 0xE1, 0xFF, 0xF3, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xF0, 0x7F, 0xE1, 0xF3,
  0xFF, 0xF3, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0xF9, 0xFF, 0xF0,
  0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFE,
  0xFF, 0x81, 0xFC, 0xFF, 0xFF, 0xFC, 0xFB, 0xFF, 0xF8, 0xF9, 0xFF, 0xF0,
  0xF8, 0x7F, 0xC0, 0xF8, 0x04, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF,
  0x3F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x81, 0xFF,
  0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFE, 0x1F,
  0x00, 0x60, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7E, 0x01, 0xC7, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x08, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0xFF, 0xBF,
  0xFF, 0xFF, 0x3F, 0xFF, 0x9E, 0x3F, 0xFE, 0x3C, 0x3F, 0xF0, 0x78, 0x02,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0xE0, 0x1F, 0x1F,
  0x80, 0xFB, 0xC0, 0x3E, 0x1F, 0x01, 0xE7, 0x80, 0xFC, 0x3E, 0x03, 0xCF,
  0x81, 0xF0, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0xFC, 0x1F, 0x1E, 0x07, 0xC0,
  0xF8, 0x3E, 0x3C, 0x1F, 0x81, 0xF0, 0x78, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0xF0, 0xF8, 0x07, 0xC7, 0x81, 0xF3, 0xE0,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x07, 0xCF, 0x80, 0x1F, 0x78,
  0x07, 0x9F, 0x00, 0x3E, 0xF0, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0x8F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xF7, 0xE0, 0x00, 0xFB,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3E,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x7F, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF0,
  0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_Medium50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 37, 14, 3, -36 },
  { 34, 15, 13, 21, 3, -36 },
  { 59, 30, 36, 32, 1, -36 },
  { 194, 23, 41, 29, 3, -38 },
  { 312, 38, 37, 43, 2, -36 },
  { 488, 35, 37, 37, 2, -36 },
  { 650, 6, 13, 12, 3, -36 },
  { 660, 12, 44, 16, 2, -36 },
  { 726, 13, 44, 16, 1, -36 },
  { 798, 23, 23, 27, 2, -38 },
  { 865, 24, 24, 29, 2, -30 },
  { 937, 8, 12, 14, 2, -6 },
  { 949, 12, 5, 16, 2, -16 },
  { 957, 7, 8, 14, 3, -7 },
  { 964, 19, 36, 19, 0, -36 },
  { 1050, 24, 37, 29, 2, -36 },
  { 1161, 15, 36, 29, 4, -36 },
  { 1229, 24, 36, 29, 2, -36 },
  { 1337, 24, 37, 29, 2, -36 },
  { 1448, 27, 36, 29, 1, -36 },
  { 1570, 23, 37, 29, 3, -36 },
  { 1677, 24, 37, 29, 2, -36 },
  { 1788, 24, 36, 29, 2, -36 },
  { 1896, 24, 37, 29, 2, -36 },
  { 2007, 24, 37, 29, 2, -36 },
  { 2118, 7, 29, 14, 3, -28 },
  { 2144, 8, 34, 14, 2, -28 },
  { 2178, 24, 25, 29, 2, -31 },
  { 2253, 23, 14, 29, 3, -25 },
  { 2294, 24, 25, 29, 2, -31 },
  { 2369, 21, 37, 22, 0, -36 },
  { 2467, 39, 40, 45, 3, -36 },
  { 2662, 33, 36, 33, 0, -36 },
  { 2811, 25, 36, 33, 5, -36 },
  { 2924, 27, 37, 32, 3, -36 },
  { 3049, 29, 36, 37, 5, -36 },
  { 3180, 20, 36, 28, 5, -36 },
  { 3270, 20, 36, 26, 5, -36 },
  { 3360, 30, 37, 36, 3, -36 },
  { 3499, 28, 36, 37, 5, -36 },
  { 3625, 14, 36, 18, 2, -36 },
  { 3688, 14, 46, 15, -4, -36 },
  { 3769, 27, 36, 32, 5, -36 },
  { 3891, 20, 36, 27, 5, -36 },
  { 3981, 36, 36, 46, 5, -36 },
  { 4143, 29, 36, 39, 5, -36 },
  { 4274, 33, 37, 39, 3, -36 },
  { 4427, 23, 36, 31, 5, -36 },
  { 4531, 33, 45, 39, 3, -36 },
  { 4717, 26, 36, 32, 5, -36 },
  { 4834, 23, 37, 28, 2, -36 },
  { 4941, 26, 36, 28, 1, -36 },
  { 5058, 28, 37, 37, 4, -36 },
  { 5188, 31, 36, 31, 0, -36 },
  { 5328, 47, 36, 47, 0, -36 },
  { 5540, 30, 36, 31, 0, -36 },
  { 5675, 29, 36, 29, 0, -36 },
  { 5806, 25, 36, 29, 2, -36 },
  { 5919, 11, 44, 17, 4, -36 },
  { 5980, 19, 36, 19, 0, -36 },
  { 6066, 12, 44, 17, 1, -36 },
  { 6132, 25, 23, 29, 2, -36 },
  { 6204, 22, 4, 22, 0, 4 },
  { 6215, 11, 8, 15, 2, -38 },
  { 6226, 23, 28, 29, 2, -27 },
  { 6307, 24, 39, 31, 4, -38 },
  { 6424, 20, 28, 25, 3, -27 },
  { 6494, 24, 39, 31, 3, -38 },
  { 6611, 23, 28, 29, 3, -27 },
  { 6692, 19, 38, 18, 1, -38 },
  { 6783, 24, 39, 31, 3, -27 },
  { 6900, 23, 38, 31, 4, -38 },
  { 7010, 6, 37, 14, 4, -37 },
  { 7038, 13, 49, 14, -3, -37 },
  { 7118, 24, 38, 28, 4, -38 },
  { 7232, 5, 38, 14, 4, -38 },
  { 7256, 39, 27, 47, 4, -27 },
  { 7388, 23, 27, 31, 4, -27 },
  { 7466, 25, 28, 31, 3, -27 },
  { 7554, 24, 39, 31, 4, -27 },
  { 7671, 24, 39, 31, 3, -27 },
  { 7788, 16, 27, 21, 4, -27 },
  { 7842, 20, 28, 24, 2, -27 },
  { 7912, 17, 34, 19, 1, -33 },
  { 7985, 23, 28, 31, 4, -27 },
  { 8066, 26, 27, 26, 0, -27 },
  { 8154, 39, 27, 40, 1, -27 },
  { 8286, 25, 27, 27, 1, -27 },
  { 8371, 26, 39, 26, 0, -27 },
  { 8498, 20, 27, 24, 2, -27 },
  { 8566, 17, 44, 19, 1, -36 },
  { 8660, 4, 50, 28, 12, -38 },
  { 8685, 16, 44, 19, 2, -36 },
  { 8773, 24, 7, 29, 2, -21 },
};

const GFXfont NotoSans_Medium50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium50pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_MEDIUM50PT7B_H_
