#ifndef _NOTOSANS_MEDIUM57PT7B_H_
#define _NOTOSANS_MEDIUM57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xCF, 0x03, 0xE7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFC, 0x78, 0x3C, 0x7F,
  0x0F, 0x00, 0x8F, 0xC1, 0xE0, 0x01, 0xF8, 0x3C, 0x00, 0x3F, 0x07, 0x80,
  0x07, 0xE0, 0xF0, 0x00, 0xFE, 0x1E, 0x00, 0x0F, 0xE3, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x79, 0xFF, 0x00, 0x0F, 0x0F, 0xE0, 0x01, 0xE0, 0xFE,
  0x00, 0x3C, 0x0F, 0xC0, 0x07, 0x81, 0xF8, 0x00, 0xF0, 0x3F, 0x00, 0x1E,
  0x0F, 0xD8, 0x03, 0xC1, 0xFB, 0xF0, 0x78, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0x00, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0xFC, 0x07, 0xC0, 0x7C, 0x7E, 0x3F,
  0xF0, 0x7C, 0x0F, 0x87, 0xC7, 0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0xFF, 0xFC,
  0x3E, 0x1F, 0x8F, 0x8F, 0xCF, 0xC3, 0xFF, 0xF1, 0xF1, 0xF8, 0x3E, 0x1F,
  0xFE, 0x1F, 0x1F, 0x03, 0xE0, 0xFF, 0xC3, 0xE1, 0xF0, 0x1F, 0x03, 0xF8,
  0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x00, 0xFC,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x01,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x81, 0xFF, 0xFC, 0x00, 0x7E,
  0x07, 0xFB, 0xFC, 0x00, 0xFC, 0x1F, 0xE3, 0xFC, 0x01, 0xF8, 0x7F, 0x83,
  0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x7E, 0x0F, 0xC0, 0x03, 0xFD, 0xFC, 0x1F, 0x80,
  0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xFF,
  0x80, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79,
  0xE7, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x00, 0xF8,
  0x02, 0x78, 0x1F, 0x03, 0xCF, 0xF1, 0xE3, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F,
  0x1F, 0x0F, 0x87, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x81,
  0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0x78, 0x3F, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0x80, 0x0F,
  0xE1, 0xC0, 0x01, 0xFC, 0x10, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x3C, 0x00, 0x1F, 0xC1, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0x1F, 0xEF, 0x80,
  0x03, 0xFC, 0xFF, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x10, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFB, 0x00, 0x00, 0xFE,
  0x78, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x3F, 0xF8, 0x1F, 0x9F, 0xFF,
  0xC3, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xF9, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x07, 0xFD, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0x80, 0x7F, 0x8F, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7,
  0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xBF, 0x00, 0x1F, 0xF7, 0xF8, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFD, 0xF8, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xC7, 0xC0, 0x3F, 0xE0, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0x83, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x38, 0x1F, 0x8F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0x9C, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xFF,
  0xF8, 0x1F, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0xF8, 0xF8, 0x07, 0xFF, 0xFE,
  0x03, 0xC7, 0xC0, 0x7F, 0x83, 0xF0, 0x1F, 0x7C, 0x07, 0xF0, 0x0F, 0x80,
  0xFB, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xDF, 0x03, 0xF0, 0x03, 0xE0, 0x3E,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0xFC,
  0x07, 0xC0, 0x07, 0x80, 0x7F, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xFF, 0x03,
  0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0xC0, 0x7C,
  0x00, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x07, 0xC0, 0x3D, 0xF0, 0x1F, 0x00,
  0x7E, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x7C, 0x07, 0xE0, 0x3F,
  0xC1, 0xF1, 0xF0, 0x1F, 0xC7, 0xDF, 0x3F, 0x0F, 0x80, 0x7F, 0xFE, 0x7F,
  0xF8, 0x7C, 0x03, 0xFF, 0xE3, 0xFF, 0x83, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0x01, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0x9F, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFD, 0xFC, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0x81, 0xFF,
  0x00, 0x07, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x10, 0x3F, 0xF0, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xE1, 0xFC,
  0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xFE, 0x3F, 0x80, 0x07, 0xFE, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F, 0xC0, 0x00, 0x70, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFD, 0xF8, 0x00, 0x7F, 0xFF, 0x7E, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x0F,
  0xC3, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0x80, 0x00, 0xFC, 0x1F, 0xF8, 0x00,
  0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xF8, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xF7, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFD,
  0xF0, 0x00, 0x03, 0xEF, 0xFF, 0x7C, 0x00, 0x00, 0xFB, 0xFF, 0xDF, 0x80,
  0x00, 0x7E, 0xFF, 0xF3, 0xE0, 0x00, 0x1F, 0x3F, 0xFC, 0xFC, 0x00, 0x07,
  0xCF, 0xFF, 0x3F, 0x00, 0x03, 0xF3, 0xFF, 0xC7, 0xC0, 0x00, 0xF8, 0xFF,
  0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xFF, 0x0F,
  0x80, 0x07, 0xC3, 0xFF, 0xC3, 0xF0, 0x03, 0xF0, 0xFF, 0xF0, 0xFC, 0x00,
  0xF8, 0x3F, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0xFF, 0x07, 0xE0, 0x1F, 0x83,
  0xFF, 0xC0, 0xF8, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0xFF, 0x01, 0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0x7E,
  0x1F, 0x80, 0xFF, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0xFC, 0x03, 0xE1, 0xF0,
  0x0F, 0xFF, 0x00, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x3E, 0x00, 0xFF,
  0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0x00, 0x03, 0xFF,
  0xDF, 0xC0, 0x00, 0xFF, 0xF3, 0xF8, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x0F,
  0xFF, 0x1F, 0xC0, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0xFF, 0xF0, 0xFE, 0x00,
  0x3F, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0x00,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xFC,
  0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0xC0, 0x07, 0xF0, 0xFF,
  0xF0, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xCF, 0xFF, 0x00, 0x07, 0xF3,
  0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFC, 0x3F, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF,
  0x7F, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x83, 0xF8, 0x1F, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F,
  0x80, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x83, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xF0, 0x0F, 0xC7,
  0xF0, 0x00, 0x61, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xEC, 0x00, 0x03, 0xFB, 0xE0, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF7, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xBF,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xC7, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC0, 0x0F, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xF0, 0x78, 0x03, 0xF8, 0x20,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xBF, 0xC0, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0xFD, 0xF7, 0xFF, 0xFC, 0xF9, 0xFF,
  0xFC, 0x7C, 0x3F, 0xF8, 0x1E, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC3, 0xFE, 0x01, 0xF8, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xF3, 0xFC, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x01,
  0xFD, 0xFF, 0x00, 0xFF, 0x3F, 0xFE, 0xFF, 0xE7, 0xDF, 0xFF, 0xF8, 0xF9,
  0xFF, 0xFE, 0x1F, 0x1F, 0xFF, 0x83, 0xC0, 0xFF, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0x03, 0x8F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x02, 0x7F, 0x80, 0x1C, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x05, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0x83, 0xF0, 0x3F, 0xFE, 0x3F, 0x07, 0xFF,
  0xF3, 0xF0, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFC, 0x03, 0xFF,
  0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x03, 0xFF, 0x1F, 0xF9,
  0xFF, 0xF1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFE, 0x1F,
  0x01, 0xFF, 0x81, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x9F, 0xF0,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x47, 0xF8, 0x00, 0x30, 0x7F,
  0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0xC0,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xF0,
  0x3F, 0xFE, 0x3F, 0x07, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF,
  0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF3,
  0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0xFF, 0xF1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF,
  0xF3, 0xF0, 0x7F, 0xFE, 0x3F, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0x80, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE2, 0x00, 0x00, 0xFE, 0x38, 0x00, 0x3F,
  0xC3, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x1F, 0xF0, 0x3F, 0x1F, 0xFF, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0x1F, 0xEF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x84,
  0x00, 0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE8, 0x7F,
  0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xFD, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC7,
  0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0,
  0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0,
  0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0xF0, 0x03,
  0xFE, 0x07, 0xC7, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xDF,
  0xC0, 0x07, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF7, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0xF8, 0x1F, 0xF0, 0x3E, 0x1F, 0xFF, 0x0F, 0x9F, 0xFF,
  0xF3, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0x1F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFC, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0xF8, 0x3F, 0xF0, 0x1F, 0x0F, 0xFF, 0x03, 0xE7,
  0xFF, 0xF8, 0x7D, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0x80, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x0F, 0xF3, 0xFF, 0xEF, 0xFE, 0x7D,
  0xFF, 0xFF, 0x8F, 0x9F, 0xFF, 0xE1, 0xF9, 0xFF, 0xF8, 0x3F, 0x0F, 0xFC,
  0x07, 0xE0, 0x10, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x81, 0xF0, 0x3F, 0xFE, 0x3F, 0x07, 0xFF, 0xF3, 0xF0, 0xFF,
  0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F,
  0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x1F, 0xF1, 0xFF, 0xF1, 0xFF,
  0xFF, 0xBF, 0x0F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFE, 0x3F, 0x01, 0xFF, 0x83,
  0xF0, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F,
  0xC7, 0xFB, 0xF8, 0x01, 0xCF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x7F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x8C, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xEF, 0xF0, 0x0F, 0xFD, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0xFD, 0xF1,
  0xFF, 0xFF, 0x3E, 0x1F, 0xFF, 0xC7, 0xC0, 0xFF, 0xE0, 0xF8, 0x00, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xE0, 0x07,
  0xE3, 0xF0, 0x07, 0xBE, 0x00, 0xFC, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC1, 0xF8,
  0x1F, 0x9F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x07, 0xC3,
  0xF0, 0x07, 0xC7, 0xE0, 0x7E, 0x3E, 0x00, 0x7E, 0x7C, 0x03, 0xE7, 0xE0,
  0x07, 0xE7, 0xC0, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x03,
  0xEF, 0x80, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0x80, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x7C,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xA0, 0x01, 0xFF, 0xE4, 0x00,
  0x07, 0xF0,
};

const GFXglyph NotoSans_Medium57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 42, 16, 4, -41 },
  { 43, 17, 15, 24, 4, -41 },
  { 75, 34, 41, 37, 1, -41 },
  { 250, 27, 46, 33, 3, -43 },
  { 406, 44, 42, 49, 2, -41 },
  { 637, 39, 42, 42, 3, -41 },
  { 842, 6, 15, 14, 4, -41 },
  { 854, 14, 50, 18, 2, -41 },
  { 942, 14, 50, 18, 2, -41 },
  { 1030, 27, 26, 31, 2, -43 },
  { 1118, 27, 28, 33, 3, -34 },
  { 1213, 9, 14, 16, 2, -7 },
  { 1229, 14, 5, 18, 2, -18 },
  { 1238, 8, 8, 16, 4, -7 },
  { 1246, 20, 41, 22, 1, -41 },
  { 1349, 27, 42, 33, 3, -41 },
  { 1491, 16, 41, 33, 5, -41 },
  { 1573, 27, 41, 33, 3, -41 },
  { 1712, 28, 42, 33, 2, -41 },
  { 1859, 31, 41, 33, 1, -41 },
  { 2018, 27, 42, 33, 3, -41 },
  { 2160, 27, 42, 33, 3, -41 },
  { 2302, 28, 41, 33, 2, -41 },
  { 2446, 27, 42, 33, 3, -41 },
  { 2588, 27, 42, 33, 3, -41 },
  { 2730, 8, 32, 16, 4, -31 },
  { 2762, 10, 38, 16, 2, -31 },
  { 2810, 27, 29, 33, 3, -35 },
  { 2908, 27, 16, 33, 3, -28 },
  { 2962, 27, 29, 33, 3, -35 },
  { 3060, 23, 42, 25, 1, -41 },
  { 3181, 45, 46, 51, 3, -41 },
  { 3440, 37, 41, 37, 0, -41 },
  { 3630, 29, 41, 37, 5, -41 },
  { 3779, 31, 42, 36, 3, -41 },
  { 3942, 33, 41, 42, 5, -41 },
  { 4112, 23, 41, 32, 5, -41 },
  { 4230, 23, 41, 30, 5, -41 },
  { 4348, 34, 42, 41, 3, -41 },
  { 4527, 32, 41, 43, 5, -41 },
  { 4691, 16, 41, 20, 2, -41 },
  { 4773, 15, 52, 17, -4, -41 },
  { 4871, 31, 41, 36, 5, -41 },
  { 5030, 24, 41, 30, 5, -41 },
  { 5153, 42, 41, 52, 5, -41 },
  { 5369, 34, 41, 44, 5, -41 },
  { 5544, 38, 42, 45, 3, -41 },
  { 5744, 27, 41, 35, 5, -41 },
  { 5883, 38, 51, 45, 3, -41 },
  { 6126, 30, 41, 36, 5, -41 },
  { 6280, 26, 42, 31, 3, -41 },
  { 6417, 30, 41, 32, 1, -41 },
  { 6571, 32, 42, 42, 5, -41 },
  { 6739, 35, 41, 35, 0, -41 },
  { 6919, 53, 41, 54, 0, -41 },
  { 7191, 35, 41, 35, 0, -41 },
  { 7371, 33, 41, 33, 0, -41 },
  { 7541, 29, 41, 33, 2, -41 },
  { 7690, 13, 50, 19, 4, -41 },
  { 7772, 20, 41, 22, 1, -41 },
  { 7875, 13, 50, 19, 1, -41 },
  { 7957, 29, 26, 33, 2, -41 },
  { 8052, 25, 4, 25, 0, 5 },
  { 8065, 13, 9, 17, 2, -44 },
  { 8080, 25, 32, 33, 3, -31 },
  { 8180, 27, 44, 35, 5, -43 },
  { 8329, 23, 32, 28, 3, -31 },
  { 8421, 28, 44, 35, 3, -43 },
  { 8575, 27, 32, 33, 3, -31 },
  { 8683, 22, 44, 20, 1, -44 },
  { 8804, 28, 45, 35, 3, -31 },
  { 8962, 26, 43, 36, 5, -43 },
  { 9102, 7, 42, 15, 4, -42 },
  { 9139, 14, 56, 15, -3, -42 },
  { 9237, 27, 43, 32, 5, -43 },
  { 9383, 6, 43, 15, 5, -43 },
  { 9416, 45, 31, 54, 5, -31 },
  { 9591, 26, 31, 36, 5, -31 },
  { 9692, 29, 32, 35, 3, -31 },
  { 9808, 27, 45, 35, 5, -31 },
  { 9960, 28, 45, 35, 3, -31 },
  { 10118, 18, 31, 24, 5, -31 },
  { 10188, 22, 32, 28, 3, -31 },
  { 10276, 19, 39, 22, 1, -38 },
  { 10369, 27, 32, 36, 4, -31 },
  { 10477, 30, 31, 30, 0, -31 },
  { 10594, 44, 31, 46, 1, -31 },
  { 10765, 29, 31, 31, 1, -31 },
  { 10878, 30, 45, 30, 0, -31 },
  { 11047, 23, 31, 27, 2, -31 },
  { 11137, 19, 50, 22, 1, -41 },
  { 11256, 5, 57, 31, 13, -43 },
  { 11292, 19, 50, 22, 2, -41 },
  { 11411, 27, 8, 33, 3, -24 },
};

const GFXfont NotoSans_Medium57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium57pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_MEDIUM57PT7B_H_
