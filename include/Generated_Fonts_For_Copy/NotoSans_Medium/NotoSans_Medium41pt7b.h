#ifndef _NOTOSANS_MEDIUM41PT7B_H_
#define _NOTOSANS_MEDIUM41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xCE, 0x73,
  0x9C, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x90, 0xF1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x00,
  0x70, 0x38, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0xC1, 0xE0, 0x01,
  0xC1, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x83, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xE7, 0x1E, 0xF8, 0xE0, 0x1F,
  0x1C, 0x03, 0xE3, 0x80, 0x7C, 0x70, 0x07, 0xCE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x73, 0xF0, 0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0xE0,
  0xE3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x81, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0x01, 0xFF, 0x80, 0x1C, 0x03, 0xCF, 0x00, 0x78,
  0x0F, 0x0F, 0x00, 0xE0, 0x1E, 0x1E, 0x03, 0xC0, 0x3C, 0x1C, 0x07, 0x00,
  0x70, 0x38, 0x1E, 0x00, 0xE0, 0x70, 0x78, 0x01, 0xC0, 0xE0, 0xF0, 0x03,
  0x81, 0xC3, 0xC0, 0x07, 0x03, 0x87, 0x00, 0x0F, 0x07, 0x1E, 0x3E, 0x1E,
  0x1E, 0x38, 0xFF, 0x3C, 0x3C, 0xF3, 0xFF, 0x3C, 0xF1, 0xCF, 0x1E, 0x3F,
  0xE7, 0x9E, 0x1C, 0x3F, 0x9E, 0x38, 0x3C, 0x3C, 0x3C, 0x70, 0x78, 0x00,
  0xF1, 0xE0, 0x70, 0x01, 0xC3, 0xC0, 0xE0, 0x07, 0x87, 0x81, 0xC0, 0x0E,
  0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x0F, 0x00, 0x70, 0x1C, 0x1E, 0x01, 0xE0,
  0x3C, 0x3C, 0x07, 0x80, 0x78, 0x70, 0x0F, 0x00, 0x7F, 0xE0, 0x3C, 0x00,
  0xFF, 0x80, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xFB, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x3E, 0x3F, 0xFC, 0x03, 0xC7, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x07,
  0x8F, 0x80, 0xF8, 0x78, 0xF8, 0x07, 0xCF, 0x8F, 0x80, 0x3F, 0xF0, 0xF8,
  0x01, 0xFE, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x1F,
  0xF0, 0x7F, 0x8F, 0xFF, 0x83, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x87, 0xE0,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0x07, 0xC3, 0xC0, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0x7C, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0x01, 0xC0, 0x7C, 0x38, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80,
  0xF0, 0xF8, 0x3E, 0x1F, 0x01, 0xC1, 0x80, 0x08, 0x20, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x3D, 0xF7, 0xDE, 0x79,
  0xEF, 0x3C, 0xF3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x90, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0x7C, 0x7C,
  0x03, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF8, 0x01,
  0xEF, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xC3, 0xC0,
  0x7C, 0x3F, 0x1F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF7, 0xEF, 0xFC, 0xF7, 0x0F, 0x20,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFC, 0x0F, 0xC7, 0x00, 0x7C, 0x20, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC0, 0xFC, 0xC0, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFB,
  0xE0, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0x7C, 0x00, 0x3D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F,
  0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1F,
  0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F,
  0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xBF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xDF, 0x07, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x83, 0x00, 0xF1, 0xFF, 0x0F,
  0x3F, 0xF8, 0xF7, 0xFF, 0xCF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01,
  0xF7, 0x80, 0x1E, 0x7C, 0x01, 0xE3, 0xE0, 0x3E, 0x3F, 0x0F, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03,
  0xE7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x7C, 0x07, 0xC3, 0xE0,
  0xF8, 0x1F, 0xBF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xE1, 0xFC, 0x7C, 0x07, 0xCF, 0x80, 0x3E, 0xF0, 0x01, 0xEF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x80, 0x3E,
  0x7E, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7E, 0x0F, 0x87, 0xC0,
  0x7C, 0xF8, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0x78, 0x07, 0xF7,
  0xE0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xDE, 0x0F, 0xF1, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x20, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x27, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE4, 0x08, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xC7, 0x8F,
  0x3C, 0x78, 0xF1, 0xC7, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0x81, 0xF9, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C, 0x3C,
  0x07, 0xFF, 0x0F, 0x1C, 0x0F, 0xFF, 0x87, 0x9E, 0x0F, 0xEF, 0xC1, 0xCF,
  0x07, 0x81, 0xE0, 0xE7, 0x07, 0x80, 0xF0, 0x7B, 0x83, 0xC0, 0x78, 0x3F,
  0xC1, 0xC0, 0x3C, 0x1F, 0xE1, 0xE0, 0x1C, 0x0F, 0xF0, 0xF0, 0x0E, 0x07,
  0x78, 0x78, 0x07, 0x03, 0xBC, 0x1C, 0x07, 0x81, 0xDE, 0x0E, 0x03, 0xC1,
  0xEF, 0x07, 0x83, 0xF0, 0xE3, 0x83, 0xF7, 0xFD, 0xF1, 0xC0, 0xFF, 0xCF,
  0xF0, 0xF0, 0x3F, 0xC3, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x38, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xC1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xF0,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x7F, 0xCF, 0x00, 0x3E, 0x78, 0x00,
  0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x3C,
  0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0xF0, 0x03, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3E,
  0xF0, 0x03, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0x07, 0xC3, 0xF0, 0x01, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x08, 0x3F, 0xF7, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xF0, 0x7F, 0xF0, 0xF0, 0x03, 0xF8, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0xFC, 0xF0, 0x01, 0xF8, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x01, 0xE0, 0xFE, 0x00, 0x10, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xBC, 0x01, 0xFF,
  0xDE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0xE0,
  0x07, 0xC3, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0x07, 0xDF, 0xFB, 0xFE, 0x7F, 0x8F, 0xC0, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xCF, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0,
  0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x03, 0xC3, 0xE0,
  0x0F, 0x1F, 0x00, 0x3C, 0xF8, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x07,
  0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x7E, 0x0F, 0x00, 0xF8,
  0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C,
  0x00, 0x3E, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xBF, 0xFC, 0x00, 0x1E, 0xFF, 0x78, 0x00, 0x7B, 0xFD, 0xE0, 0x01,
  0xCF, 0xF7, 0x80, 0x0F, 0x3F, 0xCF, 0x00, 0x3D, 0xFF, 0x3C, 0x01, 0xE7,
  0xFC, 0xF0, 0x07, 0x9F, 0xF1, 0xE0, 0x1E, 0x7F, 0xC7, 0x80, 0xF1, 0xFF,
  0x1E, 0x03, 0xC7, 0xFC, 0x3C, 0x0E, 0x1F, 0xF0, 0xF0, 0x78, 0x7F, 0xC1,
  0xE1, 0xE1, 0xFF, 0x07, 0x87, 0x07, 0xFC, 0x1E, 0x3C, 0x1F, 0xF0, 0x3C,
  0xF0, 0x7F, 0xC0, 0xF7, 0x81, 0xFF, 0x03, 0xDE, 0x07, 0xFC, 0x07, 0xF0,
  0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x00, 0xF8, 0x07,
  0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x7C, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xF7, 0xC0, 0x0F, 0xF3, 0xE0, 0x0F, 0xF3,
  0xE0, 0x0F, 0xF1, 0xF0, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0,
  0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0,
  0x1F, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x07, 0xCF, 0xF0, 0x07, 0xCF, 0xF0,
  0x03, 0xEF, 0xF0, 0x03, 0xEF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x78, 0x7F, 0xEF, 0x00, 0xFD, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x7D, 0xE0, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C,
  0x1F, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00,
  0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0,
  0xF0, 0x07, 0xC3, 0xC1, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F,
  0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xE3,
  0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7E, 0xF0, 0x00, 0xFC, 0x00,
  0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xE0, 0x78, 0xF8,
  0x01, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xD8, 0x00,
  0xFB, 0xF0, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xBC, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F,
  0x80, 0x3E, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0x3C, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7D, 0xE0, 0x03, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x80, 0x1E, 0x3C, 0x00, 0xFE,
  0x00, 0xF8, 0xF0, 0x07, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xE0, 0x0F, 0x0F,
  0x80, 0x7B, 0xC0, 0x3C, 0x1E, 0x03, 0xCF, 0x01, 0xF0, 0x78, 0x0F, 0x3C,
  0x07, 0xC1, 0xF0, 0x3C, 0xF8, 0x1E, 0x07, 0xC0, 0xF1, 0xE0, 0x78, 0x0F,
  0x07, 0x87, 0x83, 0xE0, 0x3C, 0x1E, 0x1E, 0x0F, 0x80, 0xF8, 0x78, 0x3C,
  0x3C, 0x03, 0xE1, 0xE0, 0xF0, 0xF0, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0x1E,
  0x3C, 0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x79,
  0xE0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x03, 0xBC, 0x00, 0x3D,
  0xE0, 0x0F, 0xF0, 0x00, 0x77, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3C,
  0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x03, 0xEF,
  0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x38,
  0x00, 0xF1, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x3C, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xF0, 0xF0, 0x03, 0x87, 0x00, 0x1E,
  0x78, 0x00, 0x77, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x70, 0x3F, 0x10, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC1, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0x8F, 0x7C, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC1,
  0xFD, 0xFF, 0xFF, 0x7F, 0xF9, 0xC7, 0xF8, 0x70, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x9F, 0xE0, 0xFB, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0, 0x3E, 0xFC, 0x01, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1E, 0xFE, 0x03, 0xEF, 0xF0, 0xFE, 0xF7, 0xFF, 0xCF, 0x3F, 0xF8, 0xF1,
  0xFE, 0x00, 0x00, 0x30, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE3, 0xF8,
  0x71, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x27, 0xF1, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x40, 0xF0, 0x7F, 0x8F, 0x1F, 0xFE, 0xF1, 0xFF, 0xFF, 0x3F, 0x0F, 0xF7,
  0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF3, 0xF0,
  0xFF, 0x1F, 0xFE, 0xF1, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x00, 0x20, 0x00,
  0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0x7C, 0x78, 0x07, 0xDF,
  0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x9F, 0xC0, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7C, 0x20,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x8F, 0x0F, 0xFE, 0xF1, 0xFF,
  0xFF, 0x3F, 0x0F, 0xF7, 0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1F,
  0x7E, 0x03, 0xF3, 0xF0, 0x7F, 0x1F, 0xFE, 0xF0, 0xFF, 0xEF, 0x07, 0xF8,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x30, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0x07, 0xEF, 0xC0,
  0x3E, 0xFC, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x27, 0xFF, 0xFF, 0x90,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x40,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xBF, 0xEF, 0xFB, 0xFC, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8, 0x07, 0xCF,
  0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80,
  0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x10,
  0x00, 0x40, 0x78, 0xFF, 0x83, 0xFE, 0x3C, 0xFF, 0xE7, 0xFF, 0x9E, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xC3, 0xF7, 0xE0, 0x3F, 0x80, 0xFB, 0xF0,
  0x0F, 0xC0, 0x3D, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC,
  0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F,
  0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07,
  0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00,
  0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x10, 0x0F,
  0x1F, 0xF0, 0xF3, 0xFF, 0xCF, 0x7F, 0xFC, 0xFF, 0x07, 0xEF, 0xC0, 0x3E,
  0xFC, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00,
  0x1F, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x10, 0x0F, 0x1F,
  0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0, 0x3E, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0xFE, 0x03, 0xEF, 0xF0, 0xFE, 0xF7, 0xFF,
  0xCF, 0xBF, 0xF8, 0xF9, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x8F,
  0x1F, 0xFE, 0xF1, 0xFF, 0xFF, 0x3F, 0x07, 0xF7, 0xE0, 0x3F, 0x7C, 0x01,
  0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78,
  0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF3, 0xF0, 0x7F, 0x1F, 0xFE, 0xF0,
  0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x13, 0xC3, 0xFF, 0x3F, 0xFD,
  0xFE, 0xF7, 0xFB, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x80, 0x1F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0xF8, 0x0E, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xE1, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0xFD, 0xF8, 0x7F, 0xBF, 0xFF, 0xF3, 0xFF, 0xCE, 0x1F,
  0xE1, 0xC0, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3C, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0xF8,
  0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xDE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xBC, 0x01, 0xF0, 0x07, 0x9F,
  0x01, 0xFC, 0x03, 0xCF, 0x80, 0xFE, 0x03, 0xE3, 0xC0, 0x77, 0x01, 0xE1,
  0xE0, 0x3B, 0xC0, 0xF0, 0xF8, 0x3D, 0xE0, 0xF8, 0x3C, 0x1E, 0xF0, 0x7C,
  0x1E, 0x0E, 0x38, 0x3C, 0x0F, 0x0F, 0x1E, 0x1E, 0x07, 0xC7, 0x8F, 0x1F,
  0x01, 0xE3, 0xC7, 0x8F, 0x00, 0xF3, 0xC1, 0xE7, 0x80, 0x79, 0xE0, 0xF3,
  0xC0, 0x1E, 0xF0, 0x7B, 0xE0, 0x0F, 0x70, 0x1D, 0xE0, 0x07, 0xB8, 0x0F,
  0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01,
  0xF3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0xF8, 0x07,
  0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0x7D, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF8, 0x07,
  0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x3E, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x07,
  0xE0, 0xFE, 0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x03, 0xFC,
};

const GFXglyph NotoSans_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 30, 11, 3, -29 },
  { 20, 12, 10, 18, 3, -29 },
  { 35, 24, 29, 26, 1, -29 },
  { 122, 19, 33, 23, 2, -31 },
  { 201, 31, 30, 35, 2, -30 },
  { 318, 28, 30, 30, 2, -30 },
  { 423, 4, 10, 10, 3, -29 },
  { 428, 10, 35, 13, 2, -29 },
  { 472, 10, 35, 13, 1, -29 },
  { 516, 19, 19, 22, 2, -31 },
  { 562, 19, 19, 23, 2, -24 },
  { 608, 6, 10, 11, 2, -5 },
  { 616, 10, 4, 13, 2, -13 },
  { 621, 5, 6, 11, 3, -5 },
  { 625, 15, 29, 16, 0, -29 },
  { 680, 20, 30, 23, 2, -30 },
  { 755, 12, 29, 23, 3, -29 },
  { 799, 20, 30, 23, 2, -30 },
  { 874, 19, 30, 23, 2, -30 },
  { 946, 22, 29, 23, 1, -29 },
  { 1026, 19, 29, 23, 2, -29 },
  { 1095, 20, 30, 23, 2, -30 },
  { 1170, 20, 29, 23, 2, -29 },
  { 1243, 20, 30, 23, 2, -30 },
  { 1318, 20, 30, 23, 2, -30 },
  { 1393, 5, 24, 11, 3, -23 },
  { 1408, 7, 28, 11, 1, -23 },
  { 1433, 19, 20, 23, 2, -25 },
  { 1481, 19, 11, 23, 2, -20 },
  { 1508, 19, 20, 23, 2, -25 },
  { 1556, 17, 31, 18, 0, -30 },
  { 1622, 33, 33, 37, 2, -29 },
  { 1759, 27, 29, 27, 0, -29 },
  { 1857, 21, 29, 27, 4, -29 },
  { 1934, 23, 30, 26, 2, -30 },
  { 2021, 24, 29, 30, 4, -29 },
  { 2108, 16, 29, 23, 4, -29 },
  { 2166, 16, 29, 22, 4, -29 },
  { 2224, 25, 30, 30, 2, -30 },
  { 2318, 23, 29, 31, 4, -29 },
  { 2402, 11, 29, 15, 2, -29 },
  { 2442, 11, 37, 12, -3, -29 },
  { 2493, 22, 29, 26, 4, -29 },
  { 2573, 17, 29, 22, 4, -29 },
  { 2635, 30, 29, 38, 4, -29 },
  { 2744, 24, 29, 32, 4, -29 },
  { 2831, 28, 30, 32, 2, -30 },
  { 2936, 19, 29, 25, 4, -29 },
  { 3005, 28, 37, 32, 2, -30 },
  { 3135, 22, 29, 26, 4, -29 },
  { 3215, 19, 30, 23, 2, -30 },
  { 3287, 22, 29, 23, 1, -29 },
  { 3367, 23, 29, 30, 4, -29 },
  { 3451, 25, 29, 25, 0, -29 },
  { 3542, 38, 29, 39, 0, -29 },
  { 3680, 25, 29, 25, 0, -29 },
  { 3771, 24, 29, 24, 0, -29 },
  { 3858, 21, 29, 24, 1, -29 },
  { 3935, 10, 35, 14, 3, -29 },
  { 3979, 15, 29, 16, 0, -29 },
  { 4034, 9, 35, 14, 1, -29 },
  { 4074, 21, 18, 23, 1, -29 },
  { 4122, 18, 2, 18, 0, 4 },
  { 4127, 9, 6, 13, 2, -31 },
  { 4134, 18, 22, 23, 2, -22 },
  { 4184, 20, 31, 25, 3, -31 },
  { 4262, 17, 23, 20, 2, -23 },
  { 4311, 20, 31, 25, 2, -31 },
  { 4389, 19, 23, 24, 2, -23 },
  { 4444, 15, 31, 15, 1, -31 },
  { 4503, 20, 33, 25, 2, -23 },
  { 4586, 20, 31, 26, 3, -31 },
  { 4664, 5, 31, 11, 3, -31 },
  { 4684, 10, 41, 11, -2, -31 },
  { 4736, 20, 31, 23, 3, -31 },
  { 4814, 5, 31, 11, 3, -31 },
  { 4834, 33, 23, 39, 3, -23 },
  { 4929, 20, 23, 26, 3, -23 },
  { 4987, 21, 23, 25, 2, -23 },
  { 5048, 20, 33, 25, 3, -23 },
  { 5131, 20, 33, 25, 2, -23 },
  { 5214, 14, 23, 17, 3, -23 },
  { 5255, 16, 23, 20, 2, -23 },
  { 5301, 14, 27, 16, 1, -27 },
  { 5349, 19, 22, 26, 3, -22 },
  { 5402, 22, 22, 22, 0, -22 },
  { 5463, 33, 22, 33, 0, -22 },
  { 5554, 21, 22, 22, 1, -22 },
  { 5612, 22, 32, 22, 0, -22 },
  { 5700, 17, 22, 20, 1, -22 },
  { 5747, 13, 35, 16, 1, -29 },
  { 5804, 3, 41, 23, 10, -31 },
  { 5820, 14, 35, 16, 1, -29 },
  { 5882, 19, 5, 23, 2, -17 },
};

const GFXfont NotoSans_Medium41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium41pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_MEDIUM41PT7B_H_
