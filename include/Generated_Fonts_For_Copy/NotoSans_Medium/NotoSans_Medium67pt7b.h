#ifndef _NOTOSANS_MEDIUM67PT7B_H_
#define _NOTOSANS_MEDIUM67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x3F, 0x9F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF9,
  0xFE, 0x1E, 0x00, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x78, 0x3F,
  0x1F, 0xE0, 0xF0, 0x06, 0x3F, 0x81, 0xE0, 0x00, 0x7F, 0x03, 0xC0, 0x00,
  0xFE, 0x07, 0x80, 0x01, 0xFC, 0x0F, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x07,
  0xF8, 0x3C, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xCF, 0xFE, 0x00, 0x07, 0x87, 0xFC, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x1E,
  0x07, 0xF8, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x78, 0x0F, 0xE0, 0x00, 0xF0,
  0x1F, 0xC0, 0x01, 0xE0, 0x3F, 0xC0, 0x03, 0xC0, 0xFE, 0xF0, 0x07, 0x83,
  0xFD, 0xFE, 0x0F, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0xFF, 0x81, 0xF8, 0x07,
  0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x0F, 0xFF, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0xFF, 0xFF, 0x87,
  0xF3, 0xFC, 0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xFF, 0xC3, 0xF0, 0xFC, 0x07, 0xE0, 0xFF, 0xF0, 0x7E, 0x1F, 0x80,
  0x7E, 0x07, 0xFC, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x08, 0x03, 0xE0, 0x7C,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE7, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x10, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF8, 0x7F,
  0x83, 0xFC, 0x00, 0x1F, 0xF1, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xEF, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x3C, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0x80, 0x0F, 0x80, 0x0B, 0xE0, 0x1F, 0x01, 0xF7, 0xFC,
  0x3E, 0x1F, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0xFF, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3,
  0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFD, 0xFE, 0x7F, 0x87, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xF7, 0xF3,
  0xFE, 0x7F, 0xFF, 0xC7, 0xF7, 0xF8, 0x7F, 0x3F, 0x07, 0xF3, 0xC0, 0x7F,
  0x18, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0x00, 0x07,
  0xFC, 0x1E, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xF8, 0x3F, 0x80, 0x0F,
  0xF8, 0x3E, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0xC0, 0x00, 0x03, 0xFE, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0xC0, 0x00, 0x0F, 0xF9, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x38, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x03, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0xC0, 0x7E, 0x3F, 0xFF, 0xE0, 0x7E,
  0x7F, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF,
  0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x07,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x3F,
  0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0x7F, 0x07,
  0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xE0, 0x7E, 0x00,
  0x0E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x18,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD,
  0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE,
  0x7F, 0x87, 0x80, 0x07, 0x81, 0xFE, 0x1F, 0xE1, 0xFF, 0x3F, 0xF3, 0xFF,
  0x1F, 0xF1, 0xFE, 0x0F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3,
  0xF0, 0x01, 0xFE, 0x30, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7C, 0x3F,
  0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xF1, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xF8, 0x01, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x7E, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFB, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7D,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x0F, 0x80,
  0x1F, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0x07,
  0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF0,
  0x03, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0x3F, 0x00,
  0xFE, 0x01, 0xFF, 0x03, 0xF1, 0xF8, 0x03, 0xFC, 0x3F, 0x7C, 0x3F, 0x8F,
  0xC0, 0x1F, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0x8F, 0xFF,
  0x81, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xF0, 0x01, 0xFF, 0xF3, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7E, 0x07,
  0xFF, 0x00, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x07, 0xFF, 0x80, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0xFF,
  0x00, 0x03, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0xC1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE8, 0x1F, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xF7, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x07,
  0xEF, 0xFF, 0xDF, 0xC0, 0x00, 0x03, 0xF7, 0xFF, 0xE7, 0xE0, 0x00, 0x03,
  0xF3, 0xFF, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xFF, 0xF9, 0xFC, 0x00, 0x00,
  0xFC, 0xFF, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x00,
  0x7E, 0x3F, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xFF, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xFF, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xFF, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xFF, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x80,
  0x07, 0xE0, 0xFF, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFF, 0xF8, 0x07,
  0xF0, 0x3F, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0xFE, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0x8F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFD, 0xFE, 0x00,
  0x00, 0x7F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x3F,
  0xC0, 0x00, 0x7F, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x70, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x03, 0xFD, 0xC0,
  0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xBE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F,
  0x9F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0x80,
  0xC0, 0x01, 0xFE, 0x02, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x01, 0xFD, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFC, 0xFF, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0x8F, 0xC3, 0xFF, 0xFC, 0x1F,
  0x07, 0xFF, 0xC0, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xE0, 0x01, 0xFE, 0x1F,
  0xFE, 0x00, 0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0xF8, 0x3F, 0xBF,
  0xFF, 0xFE, 0x1F, 0xDF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x7F, 0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xCF, 0xFF, 0x00,
  0x3F, 0xE7, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFD, 0xFF,
  0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0x87, 0xE1, 0xFF, 0x80, 0x0C, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x8F, 0xFC, 0x00, 0x70, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x7F,
  0x07, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x1F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x3F, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xFE, 0x3F, 0x03, 0xFF, 0xFC, 0x3F,
  0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x8F, 0xFC, 0x00, 0x0E, 0x0F, 0xFE, 0x01, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xFC, 0x3F, 0x07, 0xFF,
  0xFE, 0x3F, 0x0F, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8,
  0x1F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x7F, 0x07, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFC, 0x7F, 0x00, 0xFF,
  0xF0, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x20, 0x00, 0x01, 0xFE, 0x38, 0x00,
  0x03, 0xFE, 0x3F, 0x00, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x1F,
  0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xF8, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0,
  0x01, 0xFE, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xF9, 0xFC,
  0x00, 0x3F, 0xE3, 0xF8, 0x00, 0xFF, 0x87, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x01,
  0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x7E, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE1, 0xFC, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xDF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x07, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFE, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFE,
  0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0xFE,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0x87, 0xFF,
  0xF0, 0x1F, 0xC7, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF, 0x87, 0xF7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xC0,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x1F,
  0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xFC, 0x3F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF,
  0xF8, 0x1F, 0xC3, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0xF0, 0x07, 0xF8, 0x07,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x3F,
  0x03, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF, 0xFF, 0x3F,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFE, 0x7F,
  0x03, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x0F, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xE0, 0x07, 0xC3, 0xF8, 0x00, 0x18, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xBC,
  0x00, 0x0F, 0xF7, 0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF,
  0x7F, 0x1F, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x01, 0xFF, 0xE0,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x03, 0xF1, 0xFC,
  0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x9F, 0x80, 0x01, 0xFD, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0x3F, 0xFF, 0x80, 0x03, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_Medium67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 10, 49, 18, 4, -48 },
  { 63, 20, 17, 29, 4, -48 },
  { 106, 40, 48, 43, 2, -48 },
  { 346, 31, 55, 38, 4, -51 },
  { 560, 51, 50, 57, 3, -49 },
  { 879, 46, 50, 49, 3, -49 },
  { 1167, 8, 17, 16, 4, -48 },
  { 1184, 16, 59, 21, 3, -48 },
  { 1302, 16, 59, 21, 2, -48 },
  { 1420, 31, 31, 37, 3, -51 },
  { 1541, 32, 33, 38, 3, -40 },
  { 1673, 10, 17, 18, 3, -8 },
  { 1695, 17, 6, 22, 2, -21 },
  { 1708, 10, 10, 18, 4, -9 },
  { 1721, 24, 48, 26, 1, -48 },
  { 1865, 32, 50, 38, 3, -49 },
  { 2065, 20, 48, 38, 5, -48 },
  { 2185, 32, 49, 38, 3, -49 },
  { 2381, 32, 50, 38, 3, -49 },
  { 2581, 36, 48, 38, 1, -48 },
  { 2797, 31, 49, 38, 4, -48 },
  { 2987, 32, 49, 38, 3, -48 },
  { 3183, 32, 48, 38, 3, -48 },
  { 3375, 32, 50, 38, 3, -49 },
  { 3575, 32, 49, 38, 3, -48 },
  { 3771, 10, 38, 18, 4, -37 },
  { 3819, 12, 46, 18, 2, -37 },
  { 3888, 32, 34, 38, 3, -41 },
  { 4024, 32, 19, 38, 3, -33 },
  { 4100, 32, 34, 38, 3, -41 },
  { 4236, 27, 50, 30, 1, -49 },
  { 4405, 53, 54, 60, 4, -48 },
  { 4763, 44, 48, 44, 0, -48 },
  { 5027, 34, 48, 44, 6, -48 },
  { 5231, 36, 50, 43, 4, -49 },
  { 5456, 39, 48, 49, 6, -48 },
  { 5690, 27, 48, 37, 6, -48 },
  { 5852, 27, 48, 35, 6, -48 },
  { 6014, 40, 50, 49, 4, -49 },
  { 6264, 38, 48, 50, 6, -48 },
  { 6492, 18, 48, 24, 3, -48 },
  { 6600, 18, 61, 19, -5, -48 },
  { 6738, 36, 48, 42, 6, -48 },
  { 6954, 28, 48, 36, 6, -48 },
  { 7122, 49, 48, 62, 6, -48 },
  { 7416, 40, 48, 52, 6, -48 },
  { 7656, 45, 50, 53, 4, -49 },
  { 7938, 32, 48, 41, 6, -48 },
  { 8130, 45, 60, 53, 4, -49 },
  { 8468, 36, 48, 42, 6, -48 },
  { 8684, 31, 50, 37, 3, -49 },
  { 8878, 36, 48, 38, 1, -48 },
  { 9094, 37, 49, 49, 6, -48 },
  { 9321, 41, 48, 41, 0, -48 },
  { 9567, 61, 48, 63, 1, -48 },
  { 9933, 41, 48, 41, 0, -48 },
  { 10179, 39, 48, 39, 0, -48 },
  { 10413, 34, 48, 38, 2, -48 },
  { 10617, 15, 59, 22, 5, -48 },
  { 10728, 24, 48, 26, 1, -48 },
  { 10872, 15, 59, 22, 2, -48 },
  { 10983, 34, 30, 38, 2, -48 },
  { 11111, 29, 4, 29, 0, 6 },
  { 11126, 15, 10, 21, 3, -51 },
  { 11145, 30, 38, 38, 3, -37 },
  { 11288, 33, 52, 42, 5, -51 },
  { 11503, 27, 38, 33, 4, -37 },
  { 11632, 32, 52, 42, 4, -51 },
  { 11840, 31, 38, 38, 4, -37 },
  { 11988, 26, 51, 24, 1, -51 },
  { 12154, 32, 53, 42, 4, -37 },
  { 12366, 32, 51, 42, 5, -51 },
  { 12570, 8, 50, 18, 5, -50 },
  { 12620, 17, 66, 18, -4, -50 },
  { 12761, 31, 51, 37, 6, -51 },
  { 12959, 8, 51, 18, 5, -51 },
  { 13010, 53, 37, 63, 5, -37 },
  { 13256, 32, 37, 42, 5, -37 },
  { 13404, 33, 38, 41, 4, -37 },
  { 13561, 33, 53, 42, 5, -37 },
  { 13780, 32, 53, 42, 4, -37 },
  { 13992, 22, 37, 28, 5, -37 },
  { 14094, 27, 38, 33, 3, -37 },
  { 14223, 23, 45, 26, 1, -44 },
  { 14353, 32, 37, 42, 5, -36 },
  { 14501, 35, 36, 35, 0, -36 },
  { 14659, 52, 36, 54, 1, -36 },
  { 14893, 34, 36, 36, 1, -36 },
  { 15046, 35, 52, 35, 0, -36 },
  { 15274, 27, 36, 32, 2, -36 },
  { 15396, 21, 59, 26, 2, -48 },
  { 15551, 5, 67, 37, 16, -51 },
  { 15593, 22, 59, 26, 2, -48 },
  { 15756, 32, 9, 38, 3, -28 },
};

const GFXfont NotoSans_Medium67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium67pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_MEDIUM67PT7B_H_
