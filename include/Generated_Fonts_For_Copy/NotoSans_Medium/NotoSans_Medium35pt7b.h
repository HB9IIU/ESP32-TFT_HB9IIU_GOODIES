#ifndef _NOTOSANS_MEDIUM35PT7B_H_
#define _NOTOSANS_MEDIUM35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x02, 0x3F, 0xFF, 0x78, 0xF1, 0xFE, 0x3F, 0xC7, 0xB8, 0xF7, 0x1C,
  0xE3, 0x9C, 0x73, 0x86, 0x60, 0xC0, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x0E,
  0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x1F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0xF1, 0x82, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF9, 0x80,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0x9F,
  0x01, 0x8F, 0x01, 0x87, 0x01, 0x8F, 0xC1, 0x9F, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF8, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x80,
  0x1C, 0x07, 0xF8, 0x07, 0x81, 0xE7, 0x00, 0xE0, 0x38, 0x70, 0x38, 0x07,
  0x0E, 0x07, 0x00, 0xE1, 0xC1, 0xC0, 0x1C, 0x38, 0x38, 0x07, 0x87, 0x0E,
  0x00, 0x70, 0xE1, 0xC0, 0x0E, 0x1C, 0x70, 0x01, 0xC3, 0x9E, 0x7E, 0x38,
  0x73, 0x9F, 0xE7, 0x9C, 0xE7, 0x9C, 0x7F, 0x9C, 0xE1, 0xC7, 0xE7, 0x1C,
  0x38, 0x00, 0xE3, 0x87, 0x00, 0x38, 0xF0, 0xE0, 0x07, 0x1E, 0x1C, 0x01,
  0xC3, 0xC3, 0x80, 0x78, 0x38, 0x70, 0x0E, 0x07, 0x0E, 0x03, 0x80, 0xE1,
  0xC0, 0x70, 0x1E, 0x70, 0x1C, 0x01, 0xFE, 0x07, 0x80, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x3C, 0x3F, 0xF0, 0x3C, 0x7C, 0xF8, 0x3C, 0xF8, 0x7C, 0x78, 0xF0,
  0x3E, 0x78, 0xF0, 0x1F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x07, 0xE0, 0xF0,
  0x07, 0xE0, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFE, 0x7C, 0x1F,
  0xF8, 0x3F, 0xFF, 0xF7, 0x77, 0x77, 0x60, 0x07, 0x87, 0x83, 0x83, 0xC1,
  0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x83, 0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x02, 0x0E, 0x09, 0xF7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xF0, 0x00, 0xDC, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0xF8,
  0xF8, 0x18, 0x30, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x3C, 0xF3, 0x9E, 0x79, 0xC7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x23, 0xFF, 0xF7, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70,
  0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03,
  0xC1, 0xF0, 0xFC, 0xFF, 0x7F, 0xFE, 0xFF, 0x3D, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFC, 0xF8, 0x3E, 0x60, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFF, 0x87, 0x03, 0xE2, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC,
  0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1D, 0xE0, 0x0E, 0x78, 0x07, 0x9E, 0x01,
  0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x01,
  0xE3, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x71, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0xC0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x83, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0xF8, 0x39,
  0xFF, 0x1D, 0xFF, 0xCF, 0xC1, 0xE7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xE7, 0x80, 0xF3, 0xE0,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0x7C, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x3F, 0x7F, 0xF7, 0x3F, 0xE7, 0x0F, 0x8F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xFE, 0xF3, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x8F, 0xFF, 0xDE, 0x3D, 0xF7, 0xCF, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3D, 0xE7, 0x9C, 0x71, 0xCE, 0x38,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0xF1, 0xFF, 0xF3, 0x81, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xC3, 0x81, 0xFF, 0x0E, 0x70, 0x7F, 0xF0, 0xE7, 0x0F,
  0x87, 0x0E, 0xE0, 0xE0, 0x70, 0x6E, 0x1E, 0x07, 0x07, 0xE1, 0xC0, 0x70,
  0x7E, 0x1C, 0x07, 0x06, 0xE1, 0xC0, 0x70, 0x6E, 0x1C, 0x0F, 0x0E, 0xE1,
  0xC0, 0xF0, 0xEE, 0x1E, 0x0F, 0x1C, 0xE0, 0xF3, 0xBB, 0xCF, 0x0F, 0xFB,
  0xF8, 0x70, 0x3E, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x0E,
  0x00, 0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xF0, 0x03, 0xC1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xC0, 0x7E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x03, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xFE, 0x3C, 0x3F,
  0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xC0, 0x63,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xE0, 0x3F,
  0x8F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x07,
  0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x0F, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x1F, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x80, 0xE3, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0xC0, 0x3C, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xF7,
  0xF8, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x87, 0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0xDF, 0xBF, 0xEF, 0xF1, 0xF0, 0xF0, 0x03, 0xFE,
  0x00, 0xFB, 0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x78, 0x3C,
  0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x7B,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0x87, 0x80, 0xF0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0,
  0x1F, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x70, 0x03, 0xBF, 0xDC, 0x00, 0xEF, 0xF7, 0x80,
  0x7B, 0xFC, 0xE0, 0x1C, 0xFF, 0x38, 0x07, 0x3F, 0xCF, 0x03, 0x8F, 0xF1,
  0xC0, 0xE3, 0xFC, 0x78, 0x78, 0xFF, 0x1E, 0x1C, 0x3F, 0xC3, 0x87, 0x0F,
  0xF0, 0xF3, 0xC3, 0xFC, 0x1C, 0xE0, 0xFF, 0x07, 0x38, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xE0, 0x3F, 0xC0,
  0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xDE, 0x01,
  0xFE, 0xF8, 0x0F, 0xF3, 0xC0, 0x7F, 0x8F, 0x03, 0xFC, 0x78, 0x1F, 0xE1,
  0xE0, 0xFF, 0x0F, 0x87, 0xF8, 0x3C, 0x3F, 0xC0, 0xF1, 0xFE, 0x07, 0xCF,
  0xF0, 0x1E, 0x7F, 0x80, 0x7B, 0xFC, 0x03, 0xDF, 0xE0, 0x0F, 0x7F, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC3,
  0xE0, 0x07, 0x8F, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xE3, 0xE0, 0x07,
  0x83, 0xE0, 0x3F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE,
  0x03, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x07, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0xF3, 0xE0, 0x01, 0xE3, 0xE0, 0x07, 0x83, 0xE0, 0x3F, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x1F, 0x8F, 0x00, 0xF1,
  0xE0, 0x1F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x00, 0xF1, 0xE0, 0x1F, 0x3C, 0x01, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xE0,
  0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x0C, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1E, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xE0, 0x7C, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x7D, 0xC0, 0x01, 0xE7, 0x80,
  0x07, 0x9E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E,
  0x07, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xE0, 0x3C, 0x03,
  0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x38, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xBC, 0x01, 0xF0, 0x07, 0x9E, 0x00,
  0xF8, 0x03, 0xCF, 0x00, 0xFC, 0x01, 0xE7, 0x80, 0x7F, 0x00, 0xE1, 0xE0,
  0x3B, 0x80, 0xF0, 0xF0, 0x1D, 0xC0, 0x78, 0x78, 0x1E, 0xE0, 0x3C, 0x3C,
  0x0F, 0x78, 0x1C, 0x0F, 0x07, 0x1C, 0x1E, 0x07, 0x83, 0x8E, 0x0F, 0x03,
  0xC3, 0xC7, 0x87, 0x80, 0xE1, 0xC3, 0xC3, 0x80, 0x78, 0xE0, 0xE3, 0xC0,
  0x3C, 0xF0, 0x71, 0xE0, 0x1E, 0x78, 0x3C, 0xF0, 0x07, 0x38, 0x0E, 0x70,
  0x03, 0x9C, 0x07, 0x78, 0x01, 0xFE, 0x03, 0xBC, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x03, 0xC1, 0xE0,
  0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0xCF, 0x00,
  0x1E, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xE3,
  0xC0, 0x3E, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0xF0,
  0x07, 0x8F, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x01, 0xCE,
  0x00, 0xE3, 0x80, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x0F, 0xF0, 0x7F,
  0xF8, 0xFF, 0xF1, 0x80, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x1F, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0xFF, 0xDC, 0xFE, 0x38, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF3, 0xF8, 0x73, 0xFE, 0x3B, 0xFF, 0x9F, 0x83, 0xEF, 0x80,
  0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xE0, 0x3D, 0xF8, 0x3E,
  0xFF, 0xFE, 0x77, 0xFE, 0x38, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF,
  0x9F, 0x02, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x01, 0x3F,
  0xFC, 0x7F, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0xE7,
  0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0x83, 0xF7, 0x80, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3E, 0xF8, 0x3F, 0x3F, 0xFF, 0x9F, 0xF9,
  0xC3, 0xF8, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x02, 0x3F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x01, 0xF0, 0x3F, 0xC3, 0xFC, 0x3E, 0x21,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xE7, 0xFF, 0x3F, 0xF8, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x0F, 0xE3, 0x8F, 0xF9, 0xCF, 0xFF, 0xEF, 0x83, 0xF7, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3E, 0xF8, 0x3F, 0x3F,
  0xFF, 0x9F, 0xFB, 0xC3, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0xC0, 0x3E, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF3, 0xF8, 0xF7, 0xFE, 0xEF, 0xFE, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x3D, 0xFE, 0xFF, 0x7E, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1,
  0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xEF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFB,
  0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0,
  0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xF8, 0x3F, 0x9D, 0xFF, 0x9F, 0xFB,
  0xBF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0x81, 0xF8, 0x1F, 0xE0, 0x1E,
  0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x78, 0x07, 0xF0, 0x0F, 0x00, 0xFE,
  0x01, 0xC0, 0x1F, 0xC0, 0x38, 0x03, 0xF8, 0x07, 0x00, 0x7F, 0x00, 0xE0,
  0x0F, 0xE0, 0x1C, 0x01, 0xFC, 0x03, 0x80, 0x3F, 0x80, 0x70, 0x07, 0xF0,
  0x0E, 0x00, 0xFE, 0x01, 0xC0, 0x1F, 0xC0, 0x38, 0x03, 0x80, 0xE3, 0xF8,
  0xE7, 0xFE, 0xEF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x0F, 0xBC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0E, 0xF0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3C,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0xE3, 0xF8, 0x73, 0xFE, 0x3B,
  0xFF, 0x9F, 0x83, 0xEF, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7B, 0xE0, 0x3D, 0xF8, 0x3E, 0xFF, 0xFE, 0x77, 0xFE, 0x3C, 0xFE, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE3, 0x8F, 0xF9, 0xCF, 0xFF, 0xEF,
  0x83, 0xF7, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xE0,
  0x3E, 0xF8, 0x3F, 0x3F, 0xFF, 0x9F, 0xFB, 0xC3, 0xF9, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0xE3, 0xFC, 0xFF, 0xBF, 0xFF, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0,
  0x2E, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC,
  0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xEF, 0xFE, 0xFF, 0xE3,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xFF, 0x7F, 0xF7,
  0x3F, 0xC7, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x38,
  0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x03, 0x87,
  0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x07, 0x3C, 0x01, 0xEE, 0x00, 0x7B, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF7, 0x80, 0xF8, 0x0E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x38,
  0x1F, 0x81, 0xE3, 0xC3, 0xDC, 0x1C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9C,
  0x3C, 0x1C, 0x39, 0xE3, 0xC1, 0xE7, 0x8E, 0x38, 0x1E, 0x70, 0xE7, 0x80,
  0xE7, 0x0E, 0x78, 0x0E, 0x70, 0xF7, 0x00, 0xEE, 0x07, 0x70, 0x0F, 0xE0,
  0x77, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0xF8, 0x3E, 0x0F,
  0x07, 0x80, 0xF1, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0xF3, 0xE0,
  0x0F, 0x80, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x3C,
  0x07, 0x8F, 0x01, 0xC1, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x03, 0x87,
  0x80, 0xF1, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xEE, 0x00, 0x3B, 0x80,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x7C, 0x3F, 0x07, 0x80, 0xFC,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x0F,
  0xC0, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x07, 0xF0,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0x80, 0x00, 0x3C, 0x01, 0xFF,
  0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x7E,
};

const GFXglyph NotoSans_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 25, 10, 2, -25 },
  { 17, 11, 9, 15, 2, -25 },
  { 30, 21, 25, 23, 1, -25 },
  { 96, 16, 29, 20, 2, -27 },
  { 154, 27, 25, 30, 1, -25 },
  { 239, 24, 25, 26, 2, -25 },
  { 314, 4, 9, 8, 2, -25 },
  { 319, 9, 31, 11, 1, -25 },
  { 354, 9, 31, 11, 1, -25 },
  { 389, 17, 16, 19, 1, -27 },
  { 423, 16, 17, 20, 2, -21 },
  { 457, 6, 9, 10, 1, -4 },
  { 464, 9, 3, 11, 1, -11 },
  { 468, 5, 5, 10, 2, -5 },
  { 472, 13, 25, 13, 0, -25 },
  { 513, 16, 25, 20, 2, -25 },
  { 563, 10, 25, 20, 3, -25 },
  { 595, 16, 25, 20, 2, -25 },
  { 645, 17, 25, 20, 1, -25 },
  { 699, 18, 25, 20, 1, -25 },
  { 756, 16, 25, 20, 2, -25 },
  { 806, 17, 25, 20, 2, -25 },
  { 860, 17, 25, 20, 1, -25 },
  { 914, 16, 25, 20, 2, -25 },
  { 964, 16, 25, 20, 2, -25 },
  { 1014, 5, 19, 10, 2, -19 },
  { 1026, 6, 24, 10, 1, -19 },
  { 1044, 16, 17, 20, 2, -21 },
  { 1078, 16, 10, 20, 2, -17 },
  { 1098, 16, 17, 20, 2, -21 },
  { 1132, 15, 25, 16, 0, -25 },
  { 1179, 28, 28, 31, 2, -25 },
  { 1277, 23, 25, 23, 0, -25 },
  { 1349, 18, 25, 23, 3, -25 },
  { 1406, 19, 25, 22, 2, -25 },
  { 1466, 21, 25, 26, 3, -25 },
  { 1532, 14, 25, 20, 3, -25 },
  { 1576, 14, 25, 18, 3, -25 },
  { 1620, 21, 25, 25, 2, -25 },
  { 1686, 20, 25, 26, 3, -25 },
  { 1749, 10, 25, 12, 1, -25 },
  { 1781, 10, 32, 10, -3, -25 },
  { 1821, 19, 25, 22, 3, -25 },
  { 1881, 15, 25, 19, 3, -25 },
  { 1928, 26, 25, 32, 3, -25 },
  { 2010, 21, 25, 27, 3, -25 },
  { 2076, 23, 25, 27, 2, -25 },
  { 2148, 17, 25, 21, 3, -25 },
  { 2202, 23, 31, 27, 2, -25 },
  { 2292, 19, 25, 22, 3, -25 },
  { 2352, 16, 25, 19, 2, -25 },
  { 2402, 19, 25, 20, 0, -25 },
  { 2462, 20, 25, 26, 3, -25 },
  { 2525, 22, 25, 22, 0, -25 },
  { 2594, 33, 25, 33, 0, -25 },
  { 2698, 21, 25, 21, 0, -25 },
  { 2764, 20, 25, 20, 0, -25 },
  { 2827, 18, 25, 20, 1, -25 },
  { 2884, 8, 31, 12, 3, -25 },
  { 2915, 13, 25, 13, 0, -25 },
  { 2956, 8, 31, 12, 1, -25 },
  { 2987, 18, 16, 20, 1, -25 },
  { 3023, 15, 2, 15, 0, 3 },
  { 3027, 8, 6, 11, 1, -27 },
  { 3033, 15, 19, 20, 2, -19 },
  { 3069, 17, 27, 22, 3, -27 },
  { 3127, 14, 19, 17, 2, -19 },
  { 3161, 17, 27, 22, 2, -27 },
  { 3219, 16, 19, 20, 2, -19 },
  { 3257, 13, 27, 13, 1, -27 },
  { 3301, 17, 27, 22, 2, -19 },
  { 3359, 16, 27, 22, 3, -27 },
  { 3413, 4, 26, 9, 3, -26 },
  { 3426, 9, 34, 9, -2, -26 },
  { 3465, 16, 27, 20, 3, -27 },
  { 3519, 4, 27, 9, 3, -27 },
  { 3533, 27, 19, 33, 3, -19 },
  { 3598, 16, 19, 22, 3, -19 },
  { 3636, 18, 19, 21, 2, -19 },
  { 3679, 17, 27, 22, 3, -19 },
  { 3737, 17, 27, 22, 2, -19 },
  { 3795, 11, 19, 15, 3, -19 },
  { 3822, 13, 19, 17, 2, -19 },
  { 3853, 12, 23, 13, 1, -23 },
  { 3888, 16, 19, 22, 3, -19 },
  { 3926, 18, 19, 18, 0, -19 },
  { 3969, 28, 19, 28, 0, -19 },
  { 4036, 19, 19, 19, 0, -19 },
  { 4082, 18, 27, 18, 0, -19 },
  { 4143, 14, 19, 17, 1, -19 },
  { 4177, 11, 31, 13, 1, -25 },
  { 4220, 3, 35, 19, 8, -27 },
  { 4234, 12, 31, 13, 1, -25 },
  { 4281, 16, 5, 20, 2, -15 },
};

const GFXfont NotoSans_Medium35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium35pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_MEDIUM35PT7B_H_
