#ifndef _NOTOSANS_MEDIUM64PT7B_H_
#define _NOTOSANS_MEDIUM64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium64pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFB, 0xF8, 0x78, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0,
  0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF0,
  0x3C, 0x7F, 0x07, 0x80, 0x23, 0xF8, 0x3C, 0x00, 0x1F, 0x81, 0xE0, 0x00,
  0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3F, 0x83, 0xC0, 0x01, 0xFE,
  0x1E, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x3F, 0xF7, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3C, 0xFF, 0xC0, 0x01, 0xE1, 0xFF, 0x00, 0x0F,
  0x03, 0xF8, 0x00, 0x78, 0x1F, 0xC0, 0x03, 0xC0, 0x7E, 0x00, 0x1E, 0x03,
  0xF0, 0x00, 0xF0, 0x3F, 0xC0, 0x07, 0x81, 0xFF, 0x00, 0x3C, 0x1F, 0xFF,
  0x81, 0xE3, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x3F, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x3F, 0x0F, 0xFE, 0x07, 0xC0, 0x7E, 0x1F, 0x8F, 0xFF, 0x83,
  0xE0, 0x3E, 0x1F, 0x8F, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0x87, 0xFF, 0xF8,
  0x7F, 0x3F, 0x8F, 0xC7, 0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xC3, 0xF0, 0x3F,
  0x0F, 0xFF, 0x87, 0xE1, 0xF0, 0x1F, 0x83, 0xFF, 0x83, 0xE1, 0xF8, 0x07,
  0xC0, 0x7F, 0x83, 0xF0, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x7F, 0xFF,
  0x80, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x81, 0xFF, 0xBF, 0xE0,
  0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x07, 0xF0, 0x03, 0xFE, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x9F, 0xC0, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x0F, 0x80, 0x19, 0xF8, 0x1F,
  0x03, 0xF3, 0xFE, 0x3E, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xEF, 0xEF, 0xF9, 0xFF, 0xFE, 0x3F, 0xBF,
  0x87, 0xF3, 0xE0, 0xFE, 0x70, 0x1F, 0xC4, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0xFC, 0x1F, 0xE0,
  0x07, 0xFC, 0x1F, 0x00, 0x07, 0xF8, 0x1C, 0x00, 0x07, 0xF8, 0x20, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xF0, 0x01, 0xFF,
  0x0F, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xB8, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFA, 0x00, 0x00, 0x3F, 0xDC, 0x00, 0x07, 0xFC,
  0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x04, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x01,
  0xF8, 0x7F, 0xFC, 0x03, 0xF1, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFE, 0x1F,
  0xDF, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xFE, 0x7F, 0xF0, 0x03, 0xFC, 0xFF,
  0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0xFC, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xEF, 0xE0, 0x00,
  0xFF, 0xDF, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0xFE,
  0xFC, 0x3F, 0xFF, 0xF9, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0x87,
  0xE0, 0x0F, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x10,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xDF, 0xC3, 0xC0, 0x0F, 0x83, 0xF8, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xF9, 0xFF, 0xE7, 0xC0, 0x07, 0xF8, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x70, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x07,
  0xC3, 0xF0, 0x03, 0xFF, 0xFF, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x9F, 0x80, 0x7F, 0x80, 0xFC,
  0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFD, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0x00,
  0x0F, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x03, 0xF0,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xBE, 0x03,
  0xF0, 0x01, 0xFC, 0x03, 0xEF, 0x80, 0x7C, 0x00, 0x7F, 0x00, 0xFB, 0xE0,
  0x1F, 0x80, 0x1F, 0xC0, 0x7C, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x3E,
  0x00, 0xFC, 0x07, 0xFE, 0x0F, 0x8F, 0xC0, 0x3F, 0xFF, 0xEF, 0xFF, 0xE3,
  0xF0, 0x07, 0xFF, 0xF1, 0xFF, 0xF0, 0x7C, 0x00, 0xFF, 0xF8, 0x7F, 0xF8,
  0x1F, 0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF8, 0x00, 0x7F, 0xF1, 0xFC, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x07, 0xFE, 0x3F,
  0x80, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x0F,
  0xFB, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x7F, 0xE0, 0x00, 0x18, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFF,
  0xE0, 0xFE, 0x00, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0x80,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x07, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0xC3, 0xF8, 0x00, 0x1F, 0xFC,
  0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x00, 0x7F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0xE3, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xF8, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xBF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x0F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFB, 0xF0, 0x00, 0x00,
  0xFD, 0xFF, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xFF, 0xE7, 0xE0, 0x00, 0x03,
  0xF7, 0xFF, 0xCF, 0xC0, 0x00, 0x0F, 0xCF, 0xFF, 0x9F, 0xC0, 0x00, 0x1F,
  0x9F, 0xFF, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x7F, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFF, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xFF, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xFF, 0x83, 0xF8, 0x00, 0xFC, 0x1F,
  0xFF, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xFF,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0xFF,
  0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xF3, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xDF, 0xE0,
  0x00, 0x1F, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0xFC, 0xFF, 0x00, 0x01, 0xFF,
  0xF1, 0xFE, 0x00, 0x07, 0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0x80, 0x07, 0xFF,
  0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xF8,
  0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFC,
  0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0x87, 0xFF, 0xC0, 0x01, 0xFE,
  0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0xF0,
  0x00, 0x1F, 0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0xFF, 0x00, 0x00, 0x7F,
  0x3F, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0x3F, 0x80,
  0x07, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x7F, 0xCF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F,
  0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0x8F, 0xF0, 0x00, 0x0C, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xDF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x03,
  0xF8, 0x7E, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xDF, 0x80,
  0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D,
  0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x1F, 0xF0, 0x1E, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFE, 0xFF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x3F, 0x3F, 0xFF, 0xF1, 0xF8, 0xFF, 0xFF, 0x0F, 0xC1, 0xFF, 0xE0, 0x3E,
  0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x81,
  0xFF, 0x00, 0x7F, 0x0F, 0xFF, 0x80, 0xFE, 0x7F, 0xFF, 0x81, 0xFD, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFE, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFB, 0xFF,
  0x00, 0x1F, 0xE7, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0x9F,
  0xFF, 0xFC, 0x3F, 0x1F, 0xFF, 0xF0, 0x7E, 0x1F, 0xFF, 0xC0, 0xF8, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFF, 0x00, 0x38, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xC7, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF8,
  0x1F, 0x80, 0x7F, 0xFC, 0x3F, 0x03, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xFE,
  0xFC, 0x3F, 0xFF, 0xFD, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0xFF,
  0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xEF, 0xC1, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xFE, 0x1F, 0x00, 0xFF, 0xF0,
  0x3E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0x81, 0xFF, 0x80,
  0x1F, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x17, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x3E, 0x01, 0xFF, 0xF0, 0x7C, 0x0F, 0xFF, 0xF1, 0xF8, 0x3F,
  0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xF7, 0xE3, 0xFF, 0xDF, 0xFF, 0xC7, 0xFC,
  0x01, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xFE, 0x7E, 0x03, 0xFF, 0xF8, 0xFC, 0x03,
  0xFF, 0xC1, 0xF8, 0x00, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x40, 0x00, 0x0F, 0xF0, 0xE0, 0x00,
  0x3F, 0xE1, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0x87, 0xFF,
  0xE0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x10, 0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x10, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x87,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xF1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x7F,
  0xFE, 0x0F, 0xC7, 0xFF, 0xFE, 0x3F, 0x3F, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC,
  0x07, 0xFC, 0x01, 0xF8, 0x3F, 0xFE, 0x03, 0xF1, 0xFF, 0xFF, 0x07, 0xE7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8,
  0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF,
  0xFC, 0x00, 0x7F, 0x9F, 0xFE, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0x7F, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xC1, 0xFC, 0x7F, 0xFF, 0x03, 0xF8,
  0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x3E, 0x01, 0xFF, 0xF0, 0x7C, 0x0F, 0xFF, 0xF1,
  0xF8, 0x3F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xF7, 0xE3, 0xFF, 0xCF, 0xFF,
  0xC7, 0xFC, 0x01, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFE,
  0x7F, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xFE, 0x7E, 0x03, 0xFF, 0xF8,
  0xFC, 0x03, 0xFF, 0xC1, 0xF8, 0x00, 0x30, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xF3, 0xFC, 0x00, 0x39, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x04, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x38, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xCF,
  0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xFC, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xE7, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7D, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xDF, 0x80,
  0x1F, 0x83, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x3E, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xF8,
  0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x3F,
  0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x80, 0x1F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xE0, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0x0F,
  0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xEF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x41, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x04, 0xFF, 0xF8, 0x00, 0x17, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xB0,
  0x00, 0x3F, 0xFC, 0x80, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_Medium64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 9, 47, 17, 4, -46 },
  { 54, 19, 17, 27, 4, -46 },
  { 95, 38, 46, 41, 2, -46 },
  { 314, 29, 53, 37, 4, -49 },
  { 507, 49, 47, 55, 3, -46 },
  { 795, 44, 47, 47, 3, -46 },
  { 1054, 7, 17, 15, 4, -46 },
  { 1069, 15, 56, 20, 3, -46 },
  { 1174, 15, 56, 20, 2, -46 },
  { 1279, 31, 29, 35, 2, -49 },
  { 1392, 30, 31, 37, 3, -38 },
  { 1509, 11, 15, 17, 2, -7 },
  { 1530, 16, 6, 21, 2, -20 },
  { 1542, 9, 9, 17, 4, -8 },
  { 1553, 23, 46, 25, 1, -46 },
  { 1686, 31, 47, 37, 3, -46 },
  { 1869, 19, 46, 37, 5, -46 },
  { 1979, 31, 46, 37, 3, -46 },
  { 2158, 30, 47, 37, 3, -46 },
  { 2335, 34, 46, 37, 1, -46 },
  { 2531, 29, 47, 37, 4, -46 },
  { 2702, 31, 47, 37, 3, -46 },
  { 2885, 32, 46, 37, 2, -46 },
  { 3069, 31, 47, 37, 3, -46 },
  { 3252, 31, 47, 37, 3, -46 },
  { 3435, 9, 36, 17, 4, -35 },
  { 3476, 11, 43, 17, 2, -35 },
  { 3536, 30, 32, 37, 3, -39 },
  { 3656, 30, 17, 37, 3, -31 },
  { 3720, 30, 32, 37, 3, -39 },
  { 3840, 26, 47, 29, 1, -46 },
  { 3993, 50, 52, 58, 4, -46 },
  { 4318, 42, 46, 42, 0, -46 },
  { 4560, 33, 46, 42, 6, -46 },
  { 4750, 35, 47, 41, 4, -46 },
  { 4956, 37, 46, 47, 6, -46 },
  { 5169, 26, 46, 36, 6, -46 },
  { 5319, 26, 46, 34, 6, -46 },
  { 5469, 38, 47, 47, 4, -46 },
  { 5693, 36, 46, 48, 6, -46 },
  { 5900, 18, 46, 23, 2, -46 },
  { 6004, 18, 59, 19, -5, -46 },
  { 6137, 34, 46, 40, 6, -46 },
  { 6333, 26, 46, 34, 6, -46 },
  { 6483, 47, 46, 59, 6, -46 },
  { 6754, 38, 46, 50, 6, -46 },
  { 6973, 42, 47, 50, 4, -46 },
  { 7220, 30, 46, 39, 6, -46 },
  { 7393, 42, 57, 50, 4, -46 },
  { 7693, 34, 46, 40, 6, -46 },
  { 7889, 29, 47, 35, 3, -46 },
  { 8060, 34, 46, 36, 1, -46 },
  { 8256, 36, 47, 47, 6, -46 },
  { 8468, 39, 46, 39, 0, -46 },
  { 8693, 59, 46, 60, 1, -46 },
  { 9033, 39, 46, 39, 0, -46 },
  { 9258, 37, 46, 37, 0, -46 },
  { 9471, 33, 46, 37, 2, -46 },
  { 9661, 15, 56, 21, 5, -46 },
  { 9766, 23, 46, 25, 1, -46 },
  { 9899, 14, 56, 21, 2, -46 },
  { 9997, 32, 29, 37, 2, -46 },
  { 10113, 28, 4, 28, 0, 6 },
  { 10127, 14, 10, 20, 3, -49 },
  { 10145, 29, 36, 37, 3, -35 },
  { 10276, 31, 50, 40, 5, -49 },
  { 10470, 26, 36, 31, 3, -35 },
  { 10587, 31, 50, 40, 3, -49 },
  { 10781, 31, 36, 37, 3, -35 },
  { 10921, 25, 49, 23, 1, -49 },
  { 11075, 31, 50, 40, 3, -35 },
  { 11269, 30, 49, 40, 5, -49 },
  { 11453, 8, 48, 17, 5, -48 },
  { 11501, 16, 63, 17, -3, -48 },
  { 11627, 30, 49, 36, 5, -49 },
  { 11811, 7, 49, 17, 5, -49 },
  { 11854, 51, 35, 61, 5, -35 },
  { 12078, 30, 35, 40, 5, -35 },
  { 12210, 33, 36, 39, 3, -35 },
  { 12359, 31, 50, 40, 5, -35 },
  { 12553, 31, 50, 40, 3, -35 },
  { 12747, 21, 35, 27, 5, -35 },
  { 12839, 25, 36, 31, 3, -35 },
  { 12952, 22, 43, 25, 1, -42 },
  { 13071, 30, 36, 40, 5, -35 },
  { 13206, 34, 35, 34, 0, -35 },
  { 13355, 50, 35, 52, 1, -35 },
  { 13574, 33, 35, 35, 1, -35 },
  { 13719, 34, 50, 34, 0, -35 },
  { 13932, 26, 35, 31, 2, -35 },
  { 14046, 20, 56, 25, 2, -46 },
  { 14186, 5, 64, 35, 15, -49 },
  { 14226, 21, 56, 25, 2, -46 },
  { 14373, 30, 9, 37, 3, -27 },
};

const GFXfont NotoSans_Medium64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium64pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_MEDIUM64PT7B_H_
