#ifndef _NOTOSANS_MEDIUM11PT7B_H_
#define _NOTOSANS_MEDIUM11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x14, 0x49, 0xF9, 0x42, 0x9F, 0x92, 0x2C, 0x27,
  0xE9, 0xC3, 0x17, 0xC4, 0x20, 0x62, 0x29, 0x25, 0x0B, 0x66, 0xA8, 0xA4,
  0x4A, 0x46, 0x71, 0x23, 0x43, 0x0E, 0x73, 0xA3, 0x7B, 0xE0, 0x29, 0x2D,
  0x92, 0x44, 0xC8, 0x92, 0x4B, 0x58, 0x33, 0xB3, 0x1E, 0x30, 0x21, 0x09,
  0xF2, 0x10, 0x70, 0xE0, 0x80, 0x11, 0x22, 0x64, 0x48, 0x39, 0x24, 0x51,
  0xC5, 0x14, 0x8E, 0x3E, 0x92, 0x49, 0x79, 0x20, 0x82, 0x10, 0x84, 0x3F,
  0xF9, 0x20, 0x8E, 0x18, 0x30, 0xFE, 0x08, 0x62, 0x9A, 0x4B, 0xF0, 0x82,
  0xF4, 0x21, 0xE1, 0x84, 0x7E, 0x76, 0x21, 0xE9, 0xC6, 0x6E, 0xFC, 0x30,
  0x86, 0x10, 0x42, 0x18, 0x79, 0x34, 0x8E, 0x79, 0x1C, 0x5E, 0x79, 0x2C,
  0x53, 0x74, 0x30, 0x9C, 0xC4, 0x50, 0x1C, 0x09, 0xB1, 0x83, 0x04, 0xF8,
  0x3E, 0x86, 0x0C, 0x3E, 0x40, 0xF4, 0xC6, 0x22, 0x10, 0x0C, 0x3C, 0x42,
  0x9D, 0xA5, 0xA5, 0xA5, 0x9A, 0xC0, 0x3C, 0x10, 0x70, 0xA1, 0x46, 0x4F,
  0x91, 0xC1, 0xF2, 0x28, 0xBE, 0x8A, 0x38, 0xFE, 0x7F, 0x18, 0x20, 0x82,
  0x0C, 0x1E, 0xF2, 0x38, 0x61, 0x86, 0x18, 0xFE, 0xF8, 0x8F, 0x88, 0x8F,
  0xF8, 0x88, 0xF8, 0x88, 0x3F, 0x18, 0x20, 0x9E, 0x1C, 0x5F, 0x86, 0x18,
  0x7F, 0x86, 0x18, 0x61, 0xED, 0xB6, 0xDF, 0x24, 0x92, 0x49, 0x3C, 0x8E,
  0x6B, 0x28, 0xF2, 0x48, 0xA3, 0x84, 0x21, 0x08, 0x42, 0x1F, 0xC3, 0xC3,
  0xA7, 0xA5, 0xA5, 0x99, 0x99, 0x99, 0xC7, 0x1A, 0x6D, 0x96, 0x78, 0xE1,
  0x79, 0x8A, 0x1C, 0x18, 0x30, 0x71, 0x3C, 0xF4, 0x63, 0x1F, 0x42, 0x10,
  0x79, 0x8A, 0x1C, 0x18, 0x30, 0x71, 0x3E, 0x08, 0x0C, 0xF2, 0x28, 0xA2,
  0xF2, 0x48, 0xA3, 0xF4, 0x21, 0x83, 0x0C, 0x5E, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x86, 0x18, 0x61, 0x86, 0x1C, 0x5E, 0x87, 0x89, 0x12, 0x62,
  0x85, 0x0E, 0x08, 0x8C, 0x73, 0x14, 0xCD, 0x2A, 0x52, 0x9C, 0xA3, 0x28,
  0xC4, 0xC4, 0x98, 0xA1, 0x83, 0x05, 0x13, 0x63, 0x85, 0x36, 0x8E, 0x30,
  0x41, 0x04, 0xFC, 0x20, 0x84, 0x21, 0x84, 0x3F, 0xEA, 0xAA, 0xB0, 0x84,
  0x44, 0x22, 0x31, 0xE4, 0x92, 0x49, 0x3C, 0x10, 0xC2, 0x92, 0xC4, 0xF8,
  0xE0, 0x78, 0x4E, 0x9C, 0xBC, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x78, 0x88,
  0x8F, 0x08, 0x7B, 0x38, 0xC6, 0x3F, 0x74, 0xFF, 0x08, 0x38, 0x74, 0xF4,
  0x44, 0x44, 0xEC, 0xE3, 0x18, 0xFC, 0x33, 0x60, 0x84, 0x3F, 0x18, 0xC6,
  0x31, 0xBF, 0x20, 0x92, 0x49, 0x27, 0x00, 0x84, 0x27, 0x6E, 0x72, 0x53,
  0xFF, 0xF7, 0x44, 0xE2, 0x71, 0x38, 0x9C, 0x4C, 0xFC, 0x63, 0x18, 0xC4,
  0x74, 0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x80, 0xEC, 0xE3,
  0x18, 0xFC, 0x21, 0x08, 0xBC, 0x88, 0x88, 0xF8, 0xC3, 0x1E, 0x4F, 0x44,
  0x44, 0x70, 0x8C, 0x63, 0x18, 0xFC, 0x8D, 0x24, 0x94, 0x30, 0xC0, 0x89,
  0xAA, 0x95, 0x4A, 0xA5, 0x71, 0x10, 0xCD, 0xE3, 0x0C, 0x5B, 0x30, 0x8D,
  0x24, 0x9E, 0x30, 0xC2, 0x08, 0xC0, 0x78, 0x8C, 0x44, 0x7C, 0x32, 0x22,
  0xC4, 0x22, 0x23, 0xFF, 0xE0, 0xC6, 0x22, 0x32, 0x22, 0x6C, 0xCD, 0xC0,
};

const GFXglyph NotoSans_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 5, 1, -8 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 5, 9, 6, 1, -8 },
  { 17, 9, 8, 9, 0, -8 },
  { 26, 7, 8, 8, 1, -8 },
  { 33, 1, 3, 3, 1, -8 },
  { 34, 3, 10, 3, 0, -8 },
  { 38, 3, 10, 3, 0, -8 },
  { 42, 6, 5, 6, 0, -8 },
  { 46, 5, 6, 6, 1, -7 },
  { 50, 2, 2, 3, 0, -1 },
  { 51, 3, 1, 4, 0, -3 },
  { 52, 1, 1, 3, 1, -1 },
  { 53, 4, 8, 4, 0, -8 },
  { 57, 6, 8, 6, 0, -8 },
  { 63, 3, 8, 6, 1, -8 },
  { 66, 6, 8, 6, 0, -8 },
  { 72, 6, 8, 6, 0, -8 },
  { 78, 6, 8, 6, 0, -8 },
  { 84, 5, 8, 6, 1, -8 },
  { 89, 5, 8, 6, 1, -8 },
  { 94, 6, 8, 6, 0, -8 },
  { 100, 6, 8, 6, 0, -8 },
  { 106, 6, 8, 6, 0, -8 },
  { 112, 1, 6, 3, 1, -6 },
  { 113, 2, 7, 3, 0, -6 },
  { 115, 5, 6, 6, 1, -7 },
  { 119, 5, 3, 6, 1, -5 },
  { 121, 5, 6, 6, 1, -7 },
  { 125, 5, 8, 5, 0, -8 },
  { 130, 8, 9, 10, 1, -8 },
  { 139, 7, 8, 7, 0, -8 },
  { 146, 6, 8, 7, 1, -8 },
  { 152, 6, 8, 7, 1, -8 },
  { 158, 6, 8, 8, 1, -8 },
  { 164, 4, 8, 6, 1, -8 },
  { 168, 4, 8, 6, 1, -8 },
  { 172, 6, 8, 8, 1, -8 },
  { 178, 6, 8, 8, 1, -8 },
  { 184, 3, 8, 4, 0, -8 },
  { 187, 3, 10, 3, -1, -8 },
  { 191, 6, 8, 7, 1, -8 },
  { 197, 5, 8, 6, 1, -8 },
  { 202, 8, 8, 10, 1, -8 },
  { 210, 6, 8, 9, 1, -8 },
  { 216, 7, 8, 9, 1, -8 },
  { 223, 5, 8, 7, 1, -8 },
  { 228, 7, 10, 9, 1, -8 },
  { 237, 6, 8, 7, 1, -8 },
  { 243, 5, 8, 6, 1, -8 },
  { 248, 6, 8, 6, 0, -8 },
  { 254, 6, 8, 8, 1, -8 },
  { 260, 7, 8, 7, 0, -8 },
  { 267, 10, 8, 10, 0, -8 },
  { 277, 7, 8, 7, 0, -8 },
  { 284, 6, 8, 6, 0, -8 },
  { 290, 6, 8, 6, 0, -8 },
  { 296, 2, 10, 4, 1, -8 },
  { 299, 4, 8, 4, 0, -8 },
  { 303, 3, 10, 4, 0, -8 },
  { 307, 6, 5, 6, 0, -8 },
  { 311, 5, 1, 5, 0, 1 },
  { 312, 3, 1, 3, 0, -8 },
  { 313, 5, 6, 6, 0, -6 },
  { 317, 5, 8, 7, 1, -8 },
  { 322, 4, 6, 5, 1, -6 },
  { 325, 5, 8, 7, 1, -8 },
  { 330, 5, 6, 6, 1, -6 },
  { 334, 4, 8, 4, 0, -8 },
  { 338, 5, 9, 7, 1, -6 },
  { 344, 5, 8, 7, 1, -8 },
  { 349, 1, 8, 3, 1, -8 },
  { 350, 3, 11, 3, -1, -8 },
  { 355, 5, 8, 6, 1, -8 },
  { 360, 1, 8, 3, 1, -8 },
  { 361, 9, 6, 10, 1, -6 },
  { 368, 5, 6, 7, 1, -6 },
  { 372, 5, 6, 7, 1, -6 },
  { 376, 5, 9, 7, 1, -6 },
  { 382, 5, 9, 7, 1, -6 },
  { 388, 4, 6, 5, 1, -6 },
  { 391, 4, 6, 5, 1, -6 },
  { 394, 4, 7, 4, 0, -7 },
  { 398, 5, 6, 7, 1, -6 },
  { 402, 6, 6, 6, 0, -6 },
  { 407, 9, 6, 9, 0, -6 },
  { 414, 6, 6, 6, 0, -6 },
  { 419, 6, 9, 6, 0, -6 },
  { 426, 5, 6, 5, 0, -6 },
  { 430, 4, 10, 4, 0, -8 },
  { 435, 1, 11, 6, 3, -8 },
  { 437, 4, 10, 4, 0, -8 },
  { 442, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_Medium11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium11pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_MEDIUM11PT7B_H_
