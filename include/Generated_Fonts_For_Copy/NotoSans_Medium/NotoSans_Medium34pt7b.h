#ifndef _NOTOSANS_MEDIUM34PT7B_H_
#define _NOTOSANS_MEDIUM34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0x07, 0xFF, 0xEF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0x71, 0xD8, 0x76,
  0x1D, 0x87, 0x61, 0xC0, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x18, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x87, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x60, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1,
  0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF8,
  0x3F, 0xFE, 0x7F, 0xFE, 0xF9, 0x8C, 0xF1, 0x80, 0xE1, 0x80, 0xF1, 0x80,
  0xF1, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x01, 0x9E, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8F, 0xC1, 0x9E, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x04, 0x0F, 0xE0, 0x0E, 0x03, 0xFC, 0x03, 0x81, 0xC7, 0x01,
  0xC0, 0x70, 0xE0, 0x70, 0x1C, 0x38, 0x38, 0x06, 0x0E, 0x1E, 0x03, 0x83,
  0x87, 0x00, 0xE0, 0xE3, 0x80, 0x18, 0x38, 0xE0, 0x07, 0x0E, 0x71, 0xE1,
  0xC3, 0x9C, 0xFE, 0x71, 0xCE, 0x7F, 0x8F, 0xF3, 0x9C, 0x71, 0xF9, 0xCE,
  0x1C, 0x18, 0xF3, 0x87, 0x00, 0x38, 0xE1, 0xC0, 0x1C, 0x38, 0x30, 0x07,
  0x0E, 0x0C, 0x03, 0x83, 0x87, 0x00, 0xE0, 0xE1, 0xC0, 0x70, 0x38, 0x70,
  0x1C, 0x07, 0x3C, 0x0E, 0x01, 0xFE, 0x07, 0x80, 0x3F, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x1C, 0x3C, 0x00,
  0x3D, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x47,
  0xFC, 0x07, 0x1F, 0x3C, 0x1E, 0x7C, 0x3C, 0x3C, 0xF0, 0x3C, 0x71, 0xE0,
  0x3D, 0xE3, 0x80, 0x3F, 0x87, 0x80, 0x3F, 0x0F, 0x00, 0x7C, 0x1F, 0x03,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0x3E, 0x1F, 0xF0, 0x3E, 0xFF, 0xFF,
  0x76, 0x66, 0x60, 0x07, 0x87, 0x07, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C,
  0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x78,
  0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x61, 0xC7, 0x7F, 0xBF, 0xFF, 0xFF, 0x0F, 0xF8, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x3E, 0x3C, 0x1C, 0x38, 0x04,
  0x10, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x3C, 0xF3, 0x9E,
  0x79, 0xC7, 0x38, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xF0, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x7E, 0xFC, 0x78, 0x3C, 0xF0,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xE0, 0x03, 0xC3, 0xF1, 0xFC, 0xFF, 0x7B, 0xFC, 0xF6, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x1F,
  0xF0, 0x7F, 0xF8, 0xFE, 0xFC, 0x70, 0x3E, 0x40, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x0F, 0xFC, 0x1F, 0xFF, 0x0F, 0xCF, 0xC3, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF6, 0x00, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x1E, 0x70, 0x07,
  0x1C, 0x03, 0x87, 0x01, 0xE1, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x1E, 0x07,
  0x07, 0x01, 0xC3, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0xC0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00,
  0x38, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0x84, 0x3E, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE7, 0xF8, 0xEF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7C, 0x7C,
  0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x7C, 0x3C,
  0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7C, 0x7C, 0xF0, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E,
  0x7E, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xF8,
  0x7E, 0xFC, 0xF0, 0x3C, 0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF,
  0x1F, 0xCE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xDE, 0x39, 0xF7, 0xDF, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x79, 0xE7, 0x9C, 0x73,
  0xCE, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x03, 0x00, 0xFF, 0xCF, 0xFF, 0x9F,
  0xBF, 0x60, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x81, 0xF8,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x0E, 0x03,
  0xE0, 0x73, 0x81, 0xFF, 0x0E, 0x70, 0xFF, 0xE1, 0xCC, 0x1C, 0x1C, 0x1F,
  0x87, 0x83, 0x83, 0xF0, 0xE0, 0x70, 0x7E, 0x1C, 0x0E, 0x0F, 0xC3, 0x81,
  0xC1, 0xF8, 0x70, 0x38, 0x37, 0x0E, 0x07, 0x0E, 0xE1, 0xC1, 0xE1, 0xDC,
  0x3C, 0x7E, 0x73, 0x83, 0xFC, 0xFE, 0x38, 0x3F, 0x1F, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xEE, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x87, 0x00, 0x1E,
  0x1E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDE, 0x03,
  0xEF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E, 0xF0, 0x0F, 0x78,
  0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0x80, 0x7B, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x01,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0x08, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0x87,
  0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0x01, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x3F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x00, 0x23, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0xF1,
  0xF0, 0x0F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xF3, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0xCF, 0xFF,
  0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7B, 0xFE,
  0xFF, 0x3F, 0x87, 0x80, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xC0,
  0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF3, 0xE0,
  0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3E, 0x78, 0x0F,
  0x1F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0,
  0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0x7E, 0xE0, 0x03, 0xBF, 0x78, 0x01, 0xDF, 0x9C,
  0x01, 0xDF, 0xEE, 0x00, 0xEF, 0xF7, 0x80, 0x77, 0xF9, 0xC0, 0x73, 0xFC,
  0xE0, 0x39, 0xFE, 0x78, 0x3C, 0xFF, 0x1C, 0x1C, 0x7F, 0x8E, 0x0E, 0x3F,
  0xC7, 0x8E, 0x1F, 0xE1, 0xC7, 0x0F, 0xF0, 0xE3, 0x87, 0xF8, 0x7B, 0x83,
  0xFC, 0x1D, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xE0, 0x7F, 0x81, 0xF0,
  0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x38, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0xF0, 0x07, 0xE7, 0x80,
  0x7E, 0x7C, 0x07, 0xE3, 0xC0, 0x7F, 0x1E, 0x07, 0xF1, 0xE0, 0x7F, 0x0F,
  0x07, 0xF0, 0xF8, 0x7F, 0x07, 0x87, 0xF0, 0x3C, 0x7F, 0x03, 0xE7, 0xF0,
  0x1E, 0x7F, 0x00, 0xF7, 0xF0, 0x0F, 0x7F, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0xE0, 0x3E, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF0, 0x3E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0xE0, 0x3E, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x0F,
  0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0x01, 0x80, 0x3F, 0xF8, 0xFF,
  0xFB, 0xFF, 0xEF, 0x80, 0x5E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xF8, 0x07,
  0xBF, 0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0xF0, 0x00, 0x7B, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0x80,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0x80, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x1C, 0x03, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x03, 0x87,
  0x80, 0x1E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0x9E, 0x00, 0x1E, 0xF0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x70, 0x03, 0xC0, 0x1E, 0x78,
  0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x38, 0x07, 0xE0, 0x1C, 0x38,
  0x0F, 0xE0, 0x3C, 0x3C, 0x0E, 0xF0, 0x3C, 0x3C, 0x0E, 0x70, 0x3C, 0x1C,
  0x0E, 0x70, 0x38, 0x1C, 0x1E, 0x78, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x1E,
  0x1C, 0x38, 0x78, 0x0E, 0x3C, 0x38, 0x70, 0x0E, 0x3C, 0x3C, 0x70, 0x0F,
  0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x07, 0x78, 0x1E, 0xE0, 0x07,
  0x70, 0x0E, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0x80, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x7B, 0xC0,
  0x03, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x8F, 0x00,
  0x78, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00,
  0xF1, 0xE0, 0x07, 0xDE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x1E, 0x78,
  0x03, 0xC3, 0xC0, 0x3C, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x77, 0x00, 0x33, 0x80, 0x38, 0xE0, 0x1C, 0x70,
  0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x00, 0x73, 0x80,
  0x3B, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x78, 0x3C, 0x1E, 0x07,
  0x00, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x10, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0x0F, 0x78, 0x0F,
  0x70, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x7F, 0xF7, 0x3F, 0xE7,
  0x1F, 0xC7, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xC0, 0xE7, 0xF8, 0xEF, 0xFC, 0xFE, 0x7E,
  0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E,
  0xFF, 0xFE, 0xEF, 0xFC, 0xE7, 0xF0, 0x01, 0xC0, 0x3F, 0xF3, 0xFF, 0x9F,
  0xDE, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x02, 0x3F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x03, 0x07, 0x1F, 0xE7, 0x3F, 0xF7,
  0x7E, 0x7F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1F, 0x7F, 0xFF, 0x3F, 0xF7, 0x0F, 0xE7, 0x01, 0xC0, 0x0F, 0xF8,
  0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x02, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x03, 0xF8,
  0x7F, 0x87, 0xFC, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xFF,
  0xE7, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1F, 0xE7, 0x3F, 0xF7, 0x7E,
  0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x1F, 0x7F, 0xFF, 0x3F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x60, 0x1E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0xC0, 0xE7, 0xF8, 0xEF, 0xFC, 0xFE, 0x7E, 0xF8, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xEF, 0xFE, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xE0, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x7B, 0xFD, 0xFC, 0xFC, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x3E,
  0xE0, 0x7C, 0xE0, 0xF8, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0x80,
  0xEF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFB, 0xC0, 0xE1, 0xE0, 0xE1, 0xF0,
  0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3E, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x1C,
  0xFF, 0x1F, 0xF3, 0xBF, 0xF7, 0xFE, 0x7F, 0x3F, 0xF7, 0xEF, 0x81, 0xF0,
  0x3D, 0xE0, 0x3E, 0x03, 0xBC, 0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F, 0xE0,
  0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x78, 0x07, 0xF0, 0x0F, 0x00,
  0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x3C, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0x00,
  0xF0, 0x0F, 0xE0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x78, 0x07,
  0x80, 0x01, 0xC0, 0xE7, 0xF8, 0xEF, 0xFC, 0xFE, 0x7E, 0xF8, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xC7, 0xC7,
  0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3C, 0xF0,
  0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0xE7, 0xF8,
  0xEF, 0xFC, 0xFE, 0x7E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1E, 0xFF, 0xFE, 0xEF, 0xFC, 0xE7, 0xF0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x1F, 0xE7, 0x3F, 0xF7, 0x7E, 0x7F, 0x78, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7F, 0xFF,
  0x3F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFC, 0xFF, 0xBF,
  0xF7, 0xFF, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x01, 0xFF, 0xDF, 0xFD, 0xE0, 0xEE, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x0F, 0xFB, 0xF7, 0xFF, 0xBF, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x0F,
  0xFF, 0xFF, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0xF1, 0xFE, 0x1F,
  0xC0, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x7F, 0xEF, 0x3F,
  0xC7, 0xF0, 0x03, 0xDC, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x3C, 0x0F,
  0x0F, 0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0x87, 0x00,
  0xF3, 0xC0, 0x3C, 0xE0, 0x07, 0x38, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x01, 0xEF, 0x03, 0xE0,
  0x3D, 0xE0, 0x7E, 0x07, 0x3C, 0x0F, 0xC1, 0xE3, 0x83, 0xB8, 0x3C, 0x78,
  0x77, 0x07, 0x0F, 0x0E, 0x70, 0xE0, 0xE3, 0xCE, 0x3C, 0x1C, 0x71, 0xC7,
  0x83, 0xCE, 0x3C, 0xE0, 0x79, 0xC3, 0x9C, 0x07, 0x70, 0x77, 0x80, 0xEE,
  0x0E, 0xE0, 0x1D, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xCF, 0x03, 0xC1,
  0xE0, 0xF0, 0x78, 0x78, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1E, 0xE0, 0x0F, 0x3C,
  0x03, 0xC7, 0x81, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C, 0x07, 0xBE, 0x00, 0xF0,
  0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x78, 0xE0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x78, 0x0E, 0x1E, 0x03, 0x87, 0x00, 0xF3,
  0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFD, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0xFC, 0x3F, 0x87,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE1, 0xF8, 0x3C, 0x07, 0xE0, 0x3E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3F, 0x83, 0xF0, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0xC0, 0x78, 0x3F, 0x0F, 0x81,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC3,
  0xF8, 0x7E, 0x0F, 0x80, 0x7F, 0x01, 0xFF, 0xE7, 0xEF, 0xFF, 0x81, 0xFE,
};

const GFXglyph NotoSans_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 10, 9, 15, 2, -24 },
  { 28, 20, 24, 22, 1, -24 },
  { 88, 16, 28, 19, 2, -26 },
  { 144, 26, 25, 29, 1, -25 },
  { 226, 23, 25, 25, 2, -25 },
  { 298, 4, 9, 8, 2, -24 },
  { 303, 9, 29, 11, 1, -24 },
  { 336, 8, 29, 11, 1, -24 },
  { 365, 16, 16, 19, 1, -26 },
  { 397, 16, 16, 19, 2, -20 },
  { 429, 6, 8, 9, 1, -4 },
  { 435, 9, 3, 11, 1, -11 },
  { 439, 5, 4, 9, 2, -4 },
  { 442, 13, 24, 13, 0, -24 },
  { 481, 16, 25, 19, 2, -25 },
  { 531, 10, 24, 19, 3, -24 },
  { 561, 16, 25, 19, 2, -25 },
  { 611, 17, 25, 19, 1, -25 },
  { 665, 18, 24, 19, 1, -24 },
  { 719, 16, 24, 19, 2, -24 },
  { 767, 16, 25, 19, 2, -25 },
  { 817, 17, 24, 19, 1, -24 },
  { 868, 16, 25, 19, 2, -25 },
  { 918, 16, 25, 19, 2, -25 },
  { 968, 5, 19, 9, 2, -19 },
  { 980, 6, 23, 9, 1, -19 },
  { 998, 16, 17, 19, 2, -21 },
  { 1032, 16, 10, 19, 2, -17 },
  { 1052, 16, 17, 19, 2, -21 },
  { 1086, 14, 25, 15, 0, -25 },
  { 1130, 27, 27, 31, 2, -24 },
  { 1222, 22, 24, 22, 0, -24 },
  { 1288, 17, 24, 22, 3, -24 },
  { 1339, 19, 25, 22, 2, -25 },
  { 1399, 20, 24, 25, 3, -24 },
  { 1459, 14, 24, 19, 3, -24 },
  { 1501, 14, 24, 18, 3, -24 },
  { 1543, 20, 25, 25, 2, -25 },
  { 1606, 19, 24, 25, 3, -24 },
  { 1663, 10, 24, 12, 1, -24 },
  { 1693, 10, 31, 10, -3, -24 },
  { 1732, 18, 24, 21, 3, -24 },
  { 1786, 14, 24, 18, 3, -24 },
  { 1828, 25, 24, 31, 3, -24 },
  { 1903, 20, 24, 26, 3, -24 },
  { 1963, 23, 25, 27, 2, -25 },
  { 2035, 16, 24, 21, 3, -24 },
  { 2083, 23, 31, 27, 2, -25 },
  { 2173, 18, 24, 21, 3, -24 },
  { 2227, 15, 25, 19, 2, -25 },
  { 2274, 19, 24, 19, 0, -24 },
  { 2331, 19, 24, 25, 3, -24 },
  { 2388, 21, 24, 21, 0, -24 },
  { 2451, 32, 24, 32, 0, -24 },
  { 2547, 21, 24, 21, 0, -24 },
  { 2610, 20, 24, 20, 0, -24 },
  { 2670, 17, 24, 20, 1, -24 },
  { 2721, 7, 29, 11, 3, -24 },
  { 2747, 13, 24, 13, 0, -24 },
  { 2786, 8, 29, 11, 1, -24 },
  { 2815, 17, 15, 19, 1, -24 },
  { 2847, 15, 2, 15, 0, 3 },
  { 2851, 8, 5, 10, 1, -26 },
  { 2856, 16, 19, 19, 1, -19 },
  { 2894, 16, 26, 21, 3, -26 },
  { 2946, 14, 19, 17, 2, -19 },
  { 2980, 16, 26, 21, 2, -26 },
  { 3032, 16, 19, 20, 2, -19 },
  { 3070, 13, 26, 12, 1, -26 },
  { 3113, 16, 27, 21, 2, -19 },
  { 3167, 16, 26, 21, 3, -26 },
  { 3219, 4, 25, 9, 3, -25 },
  { 3232, 9, 33, 9, -2, -25 },
  { 3270, 16, 26, 19, 3, -26 },
  { 3322, 3, 26, 9, 3, -26 },
  { 3332, 27, 19, 32, 3, -19 },
  { 3397, 16, 19, 21, 3, -19 },
  { 3435, 17, 19, 21, 2, -19 },
  { 3476, 16, 27, 21, 3, -19 },
  { 3530, 16, 27, 21, 2, -19 },
  { 3584, 11, 19, 14, 3, -19 },
  { 3611, 13, 19, 17, 2, -19 },
  { 3642, 11, 22, 13, 1, -22 },
  { 3673, 16, 18, 21, 3, -18 },
  { 3709, 18, 18, 18, 0, -18 },
  { 3750, 27, 18, 27, 0, -18 },
  { 3811, 18, 18, 18, 0, -18 },
  { 3852, 18, 26, 18, 0, -18 },
  { 3911, 14, 18, 16, 1, -18 },
  { 3943, 11, 29, 13, 1, -24 },
  { 3983, 3, 34, 19, 8, -26 },
  { 3996, 11, 29, 13, 1, -24 },
  { 4036, 16, 4, 19, 2, -14 },
};

const GFXfont NotoSans_Medium34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium34pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_MEDIUM34PT7B_H_
