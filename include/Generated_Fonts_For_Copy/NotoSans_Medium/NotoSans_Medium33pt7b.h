#ifndef _NOTOSANS_MEDIUM33PT7B_H_
#define _NOTOSANS_MEDIUM33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0x07, 0x7F, 0xEE, 0xF3, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x76,
  0x1D, 0x87, 0x61, 0x80, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x83, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0C,
  0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xC1,
  0x80, 0x0C, 0x18, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x30, 0x01, 0x87, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xC7,
  0xFF, 0xEF, 0xFF, 0xBC, 0xE1, 0x71, 0xC0, 0xE3, 0x81, 0xE7, 0x03, 0xEE,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xDF, 0x03, 0x9E,
  0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x0F, 0xE0,
  0x0C, 0x07, 0xFC, 0x07, 0x01, 0xC7, 0x03, 0x80, 0x71, 0xC0, 0xE0, 0x38,
  0x30, 0x70, 0x0E, 0x0E, 0x1C, 0x03, 0x83, 0x8E, 0x00, 0xE0, 0xE3, 0x80,
  0x18, 0x31, 0xC0, 0x07, 0x1C, 0x63, 0xE1, 0xC7, 0x39, 0xFC, 0x7F, 0xDC,
  0xE3, 0x8F, 0xE7, 0x38, 0xE0, 0xE3, 0x8E, 0x18, 0x00, 0xE7, 0x07, 0x00,
  0x71, 0xC1, 0xC0, 0x1C, 0x70, 0x70, 0x0E, 0x0C, 0x1C, 0x03, 0x03, 0x86,
  0x01, 0xC0, 0xE3, 0x80, 0xE0, 0x38, 0xE0, 0x38, 0x07, 0xF0, 0x1C, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x0F, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1C,
  0x78, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0,
  0x79, 0xF7, 0x81, 0xEF, 0x8F, 0x87, 0x3C, 0x1F, 0x3C, 0xE0, 0x3E, 0xE3,
  0x80, 0x7F, 0x8E, 0x00, 0xFC, 0x3C, 0x01, 0xF0, 0xF8, 0x1F, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xCF, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0xEE, 0x66, 0x60,
  0x07, 0x0F, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E,
  0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F,
  0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x70, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x81, 0x81, 0x79, 0x9E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x78,
  0x3C, 0x3C, 0x04, 0x20, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0xE7,
  0x9E, 0x71, 0xC7, 0x38, 0xFF, 0xFF, 0xFF, 0x77, 0xFE, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x03, 0xE0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0F,
  0x70, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0F,
  0x38, 0x0E, 0x3C, 0x1E, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0x83,
  0xC3, 0xE7, 0xF7, 0xFF, 0x9F, 0x8E, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE7, 0xC3, 0xE6, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3E, 0x20, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0xC0, 0x1E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0D, 0xC0, 0x0E, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0x83, 0x83,
  0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xEF, 0x01, 0xFF, 0xC7, 0xFF, 0xC3,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x03, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x01, 0xFC,
  0x0F, 0xF8, 0x7F, 0xF1, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC7, 0xC3, 0xBF, 0xE7, 0xFF, 0xEF, 0x83, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7,
  0x83, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFE, 0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x3C,
  0x1E, 0x1E, 0x3C, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x3E, 0x7C, 0x3C,
  0x1E, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78,
  0x0F, 0x7E, 0x7E, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x1F, 0x3E, 0x7F, 0x3F, 0xF7, 0x0F,
  0xE7, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x7C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x77, 0xFF, 0xE2, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xDF, 0xFB, 0x80, 0x39, 0xF7, 0xDE, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9E, 0x79, 0xE7, 0x1C, 0xE3, 0x80,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0x3C, 0x00, 0x60, 0x00, 0x0F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9C, 0x1E,
  0x40, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0xF0,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x39, 0xC0, 0xFF,
  0x8E, 0x70, 0x7F, 0xE1, 0x98, 0x3C, 0x38, 0x7E, 0x1C, 0x0E, 0x1F, 0x87,
  0x03, 0x87, 0xE3, 0x80, 0xE1, 0xF8, 0xE0, 0x30, 0x7E, 0x38, 0x1C, 0x1F,
  0x8E, 0x07, 0x06, 0xE1, 0xC1, 0xC3, 0xB8, 0x70, 0xF8, 0xEE, 0x0F, 0xF7,
  0xF1, 0x81, 0xF8, 0xF8, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0xF3,
  0x80, 0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xE0,
  0x0F, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x3F, 0xFF, 0x9E, 0x0F, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF,
  0xC7, 0x81, 0xFB, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0,
  0x00, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x0E, 0x3E, 0x00, 0x9F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x78, 0x7F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7B, 0xC0, 0x1F, 0x78, 0x07, 0xCF, 0x03, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xE0, 0xE3, 0xE0, 0x04, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0x9E, 0x00, 0x73, 0xF0, 0x0E, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xFB, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x7B, 0xFE, 0xFF, 0x3F, 0x80, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B,
  0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xEE,
  0x00, 0x77, 0xEE, 0x00, 0x77, 0xE7, 0x00, 0xF7, 0xE7, 0x00, 0xE7, 0xE7,
  0x00, 0xE7, 0xE3, 0x81, 0xC7, 0xE3, 0x81, 0xC7, 0xE3, 0xC1, 0xC7, 0xE1,
  0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xE3, 0x87, 0xE0, 0xE7, 0x07, 0xE0,
  0xE7, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xDE, 0x01, 0xFB, 0xC0,
  0x3F, 0x3C, 0x07, 0xE7, 0x80, 0xFC, 0x78, 0x1F, 0x87, 0x83, 0xF0, 0xF0,
  0x7E, 0x0F, 0x0F, 0xC0, 0xF1, 0xF8, 0x1E, 0x3F, 0x01, 0xE7, 0xE0, 0x3E,
  0xFC, 0x03, 0xDF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xC1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07,
  0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x39, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C,
  0x3E, 0x03, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xF1, 0xFC, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x7C, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x3E, 0x01,
  0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x39, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x3E, 0x03, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xC7, 0xF8, 0xF0, 0x1E, 0x3C, 0x03, 0x8F,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC7,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x78,
  0x3C, 0x0E, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x03, 0xCF,
  0x00, 0xFB, 0xC0, 0x1F, 0x07, 0xE0, 0x7F, 0xF9, 0xFF, 0xF3, 0xE1, 0xCF,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xEC, 0x03, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3D, 0xE0, 0x0F, 0x7C, 0x07, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF0, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x78,
  0x01, 0xE3, 0x80, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x1C, 0x03, 0x81,
  0xE0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xF0,
  0x07, 0x0E, 0x00, 0x79, 0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xDC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0xE0, 0x0F, 0x80, 0x39, 0xC0, 0x1F, 0x00,
  0x73, 0xC0, 0x3E, 0x01, 0xE7, 0x80, 0xFC, 0x03, 0xC7, 0x01, 0xDC, 0x07,
  0x0E, 0x03, 0xB8, 0x0E, 0x1E, 0x07, 0x70, 0x3C, 0x3C, 0x1E, 0xF0, 0x78,
  0x38, 0x38, 0xE0, 0xE0, 0x70, 0x71, 0xC1, 0xC0, 0xF0, 0xE3, 0x87, 0x81,
  0xE3, 0xC7, 0x8F, 0x01, 0xC7, 0x07, 0x1C, 0x03, 0x8E, 0x0E, 0x38, 0x07,
  0xBC, 0x1E, 0xF0, 0x0F, 0x70, 0x1D, 0xE0, 0x0E, 0xE0, 0x3B, 0x80, 0x1D,
  0xC0, 0x77, 0x00, 0x3B, 0x80, 0xEE, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0xF0,
  0xF0, 0x07, 0x0F, 0x00, 0x79, 0xE0, 0x03, 0xDC, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x39, 0xE0, 0x07, 0x9E, 0x00, 0xF0, 0xF0, 0x0E, 0x07, 0x01, 0xE0, 0x78,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x01,
  0xEE, 0x00, 0x3D, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0xC0, 0x78, 0x3C, 0x0F,
  0x07, 0x83, 0xC0, 0x78, 0x70, 0x0F, 0x1E, 0x00, 0xF3, 0x80, 0x1E, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xE0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x33, 0x80, 0x39, 0xC0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x0E, 0x0E,
  0x07, 0x07, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x1E, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xF0, 0x7F, 0xF8, 0x7F,
  0xF8, 0xC0, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81, 0xFF, 0x1F, 0xFE,
  0x7F, 0xDD, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xDC, 0x0F, 0xBE,
  0x7F, 0x3F, 0xEE, 0x3F, 0x8C, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xEF, 0xF8, 0xFF,
  0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF8,
  0x3E, 0xFF, 0xFC, 0xEF, 0xF8, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0xCF, 0xFE,
  0xF8, 0x27, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x2F, 0xFF, 0x3F, 0xF8, 0x7F,
  0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0x78, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7F, 0xFF, 0x3F,
  0xF7, 0x1F, 0xC7, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xE7, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xFC, 0xFF, 0xCF, 0xFC, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x0F, 0xC7, 0x3F, 0xE7, 0x3F, 0xFF, 0x78, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x60,
  0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x71, 0xF8, 0xEF, 0xF9,
  0xFF, 0xFB, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0x27, 0xF7, 0x00, 0x07, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x02, 0x07, 0x0F, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0xFF, 0xFE, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xE0, 0x3D, 0xC0, 0xF3, 0x83,
  0xC7, 0x0F, 0x0E, 0x3C, 0x1C, 0xF0, 0x3B, 0xC0, 0x7F, 0x80, 0xFF, 0x81,
  0xF7, 0x83, 0xCF, 0x07, 0x0F, 0x0E, 0x0F, 0x1C, 0x0F, 0x38, 0x1E, 0x70,
  0x1E, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE7, 0xF0, 0x7E, 0x3B, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF, 0xFB, 0xE0,
  0xFC, 0x1E, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F,
  0x80, 0x70, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x07, 0x00, 0xFE, 0x01, 0xC0,
  0x3F, 0x80, 0x70, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x07, 0x00, 0xFE, 0x01,
  0xC0, 0x3F, 0x80, 0x70, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x07, 0x00, 0xF0,
  0xE3, 0xF1, 0xDF, 0xFB, 0xFF, 0xF7, 0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0x70, 0x0F, 0x78, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xE3, 0xF0,
  0xEF, 0xF8, 0xFF, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF8, 0x3E, 0xFF, 0xFC, 0xEF, 0xF8, 0xE7, 0xF0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x0F, 0xC7, 0x3F, 0xE7, 0x3F, 0xFF, 0x78, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE3, 0xFC, 0xFB, 0xBF, 0x7E, 0x0F,
  0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xE3, 0xFF, 0xBF, 0xFD,
  0xC0, 0x4E, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xDF, 0x7E, 0xFF, 0xE7, 0xFE,
  0x00, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1F, 0xF1, 0xFE, 0x1F, 0xC0, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0x7F, 0xEE, 0x7F, 0x9C, 0xF0, 0x03, 0xF8, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0xE3, 0x80, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x38, 0x3C, 0x1E,
  0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xE7, 0x00, 0x77, 0x80, 0x3B, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x01,
  0xDC, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x3D, 0xE0, 0xFC, 0x0E, 0x38, 0x3B,
  0x03, 0x8E, 0x0E, 0xE1, 0xE3, 0xC3, 0xB8, 0x78, 0xF1, 0xCE, 0x1C, 0x1C,
  0x71, 0xC7, 0x07, 0x1C, 0x73, 0xC1, 0xEE, 0x1C, 0xE0, 0x7B, 0x87, 0x38,
  0x0E, 0xE0, 0xEE, 0x03, 0xB8, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x9E, 0x07,
  0x8F, 0x03, 0xC3, 0xC3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xF3, 0xC0,
  0x71, 0xE0, 0x78, 0x78, 0x78, 0x1E, 0x78, 0x0F, 0x7C, 0x03, 0xC0, 0xF0,
  0x03, 0xB8, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xE3, 0x80, 0xF1, 0xE0, 0x70,
  0x70, 0x78, 0x38, 0x3C, 0x1E, 0x1C, 0x07, 0x1E, 0x03, 0xCF, 0x00, 0xE7,
  0x00, 0x77, 0x80, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x7C, 0x1F, 0x87, 0xC0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE1, 0xF8, 0x3C, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x3F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1F, 0xC0,
  0xF8, 0x3F, 0x0F, 0x81, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC3, 0xF0, 0x7E, 0x0F, 0x00, 0x7C, 0x03, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xF8, 0x07, 0x00,
};

const GFXglyph NotoSans_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 10, 9, 14, 2, -24 },
  { 28, 20, 24, 21, 1, -24 },
  { 88, 15, 27, 19, 2, -25 },
  { 139, 26, 24, 28, 1, -24 },
  { 217, 22, 24, 24, 2, -24 },
  { 283, 4, 9, 8, 2, -24 },
  { 288, 8, 29, 10, 1, -24 },
  { 317, 8, 29, 10, 1, -24 },
  { 346, 16, 15, 18, 1, -25 },
  { 376, 15, 16, 19, 2, -20 },
  { 406, 6, 8, 9, 1, -4 },
  { 412, 8, 3, 11, 1, -10 },
  { 415, 5, 4, 9, 2, -4 },
  { 418, 12, 24, 13, 0, -24 },
  { 454, 16, 24, 19, 1, -24 },
  { 502, 9, 24, 19, 3, -24 },
  { 529, 15, 24, 19, 2, -24 },
  { 574, 16, 24, 19, 1, -24 },
  { 622, 17, 24, 19, 1, -24 },
  { 673, 15, 24, 19, 2, -24 },
  { 718, 15, 24, 19, 2, -24 },
  { 763, 16, 24, 19, 1, -24 },
  { 811, 16, 24, 19, 1, -24 },
  { 859, 16, 24, 19, 1, -24 },
  { 907, 5, 18, 9, 2, -18 },
  { 919, 6, 22, 9, 1, -18 },
  { 936, 15, 16, 19, 2, -20 },
  { 966, 15, 9, 19, 2, -16 },
  { 983, 15, 16, 19, 2, -20 },
  { 1013, 14, 24, 15, 0, -24 },
  { 1055, 26, 27, 30, 2, -24 },
  { 1143, 22, 24, 22, 0, -24 },
  { 1209, 17, 24, 22, 3, -24 },
  { 1260, 18, 24, 21, 2, -24 },
  { 1314, 19, 24, 24, 3, -24 },
  { 1371, 13, 24, 18, 3, -24 },
  { 1410, 13, 24, 17, 3, -24 },
  { 1449, 19, 24, 24, 2, -24 },
  { 1506, 19, 24, 25, 3, -24 },
  { 1563, 9, 24, 12, 1, -24 },
  { 1590, 10, 30, 10, -3, -24 },
  { 1628, 18, 24, 21, 3, -24 },
  { 1682, 14, 24, 18, 3, -24 },
  { 1724, 24, 24, 30, 3, -24 },
  { 1796, 19, 24, 26, 3, -24 },
  { 1853, 22, 24, 26, 2, -24 },
  { 1919, 16, 24, 20, 3, -24 },
  { 1967, 22, 30, 26, 2, -24 },
  { 2050, 18, 24, 21, 3, -24 },
  { 2104, 15, 24, 18, 2, -24 },
  { 2149, 18, 24, 19, 0, -24 },
  { 2203, 18, 24, 24, 3, -24 },
  { 2257, 20, 24, 20, 0, -24 },
  { 2317, 31, 24, 31, 0, -24 },
  { 2410, 20, 24, 20, 0, -24 },
  { 2470, 19, 24, 19, 0, -24 },
  { 2527, 17, 24, 19, 1, -24 },
  { 2578, 7, 29, 11, 3, -24 },
  { 2604, 12, 24, 13, 0, -24 },
  { 2640, 7, 29, 11, 1, -24 },
  { 2666, 17, 15, 19, 1, -24 },
  { 2698, 14, 2, 14, 0, 3 },
  { 2702, 8, 5, 10, 1, -25 },
  { 2707, 15, 18, 19, 1, -18 },
  { 2741, 16, 25, 20, 3, -25 },
  { 2791, 13, 18, 16, 2, -18 },
  { 2821, 16, 25, 20, 2, -25 },
  { 2871, 15, 18, 19, 2, -18 },
  { 2905, 12, 25, 12, 1, -25 },
  { 2943, 16, 26, 20, 2, -18 },
  { 2995, 15, 25, 21, 3, -25 },
  { 3042, 4, 25, 9, 2, -25 },
  { 3055, 8, 33, 9, -2, -25 },
  { 3088, 15, 25, 18, 3, -25 },
  { 3135, 3, 25, 9, 3, -25 },
  { 3145, 26, 18, 31, 3, -18 },
  { 3204, 15, 18, 21, 3, -18 },
  { 3238, 16, 18, 20, 2, -18 },
  { 3274, 16, 26, 20, 3, -18 },
  { 3326, 16, 26, 20, 2, -18 },
  { 3378, 11, 18, 14, 3, -18 },
  { 3403, 13, 18, 16, 2, -18 },
  { 3433, 11, 22, 13, 1, -22 },
  { 3464, 15, 18, 21, 3, -18 },
  { 3498, 17, 18, 17, 0, -18 },
  { 3537, 26, 18, 27, 0, -18 },
  { 3596, 17, 18, 18, 0, -18 },
  { 3635, 17, 26, 17, 0, -18 },
  { 3691, 14, 18, 16, 1, -18 },
  { 3723, 11, 29, 13, 1, -24 },
  { 3763, 2, 33, 18, 8, -25 },
  { 3772, 11, 29, 13, 1, -24 },
  { 3812, 15, 5, 19, 2, -14 },
};

const GFXfont NotoSans_Medium33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium33pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_MEDIUM33PT7B_H_
