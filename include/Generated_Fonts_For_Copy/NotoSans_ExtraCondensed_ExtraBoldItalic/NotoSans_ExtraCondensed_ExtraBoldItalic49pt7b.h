#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x80, 0x00, 0x7F, 0x9F, 0xDF,
  0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0xFE, 0x7E, 0x3F, 0x9F, 0x8F, 0xEF, 0xE3,
  0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE0, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFD, 0xF0, 0x1F, 0x98, 0xC0, 0x3F, 0x30, 0x80, 0x7E, 0xE0, 0x00, 0xFD,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x37, 0xF0, 0x00, 0x6F, 0xE0,
  0x81, 0xDF, 0xC3, 0x83, 0x3F, 0x07, 0xC6, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x03, 0xE0,
  0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xC0, 0x3F, 0x7C, 0x0F, 0xC0,
  0x3E, 0x7C, 0x0F, 0x80, 0x7C, 0x7C, 0x1F, 0x80, 0x7C, 0x7C, 0x1F, 0x00,
  0x7C, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7C, 0x00,
  0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9, 0xF8, 0x20,
  0xF8, 0xF9, 0xF1, 0xFC, 0xF9, 0xF3, 0xF3, 0xFE, 0xFB, 0xF3, 0xE7, 0xFF,
  0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xE7, 0xCF, 0xDF, 0x7F, 0xCF, 0x9F, 0x9F,
  0x3F, 0x0F, 0x9F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3F, 0x3F, 0x1F,
  0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x3F,
  0x00, 0xFC, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x3E, 0x01, 0xF8, 0x3E, 0x3E,
  0x01, 0xF0, 0x3E, 0x7C, 0x03, 0xE0, 0x3E, 0xFC, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x80,
  0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE7,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xE0, 0xFF, 0xE1,
  0xFC, 0x3F, 0xFE, 0x7F, 0x0F, 0xFF, 0xCF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0x7F, 0xFF, 0x1F, 0xC7, 0xFF, 0xC3, 0xF8, 0xFF, 0xF8, 0xFE, 0x0F, 0xFE,
  0x1F, 0xC1, 0xFF, 0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0xE0, 0x7F, 0xC3, 0xFC, 0x00, 0x7F,
  0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F,
  0x8F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x04, 0x1F, 0x80, 0xE3, 0xF0, 0x1F, 0x7C,
  0x13, 0xFF, 0xBE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0x7E,
  0x0F, 0xCF, 0xE0, 0xF8, 0xFE, 0x0E, 0x1F, 0x00, 0x81, 0x80, 0x00, 0x20,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F,
  0xFD, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xFF, 0xE0, 0x1E, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x3F, 0x9F,
  0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1,
  0xFC, 0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xBF, 0x9F, 0xBF, 0x87, 0x9F,
  0xC1, 0x8F, 0xE0, 0x87, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0xFF, 0x00, 0xE0, 0x7F,
  0x00, 0xC0, 0x7F, 0x00, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x70, 0x7F, 0x80, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x84, 0x00, 0xFF, 0x0C, 0x03, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3D, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFB, 0xF8, 0x00, 0xFB, 0xF8, 0x01, 0xF3, 0xF8, 0x03,
  0xE7, 0xF0, 0x03, 0xE7, 0xF0, 0x07, 0xC7, 0xF0, 0x0F, 0x87, 0xF0, 0x0F,
  0x87, 0xF0, 0x1F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x20, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x84, 0x00, 0xFF, 0x0E, 0x03, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF9, 0xF0, 0x0F, 0xEF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFE,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0x7F, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xF9, 0xFC,
  0x1F, 0xE3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFC, 0x7F,
  0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC7,
  0xFC, 0x7F, 0x9F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0x07, 0xF8, 0x40, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x1E, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC1, 0xFF, 0x1F, 0x0F, 0x87, 0xFF,
  0x9F, 0x0F, 0x8F, 0xFF, 0x9F, 0x1F, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x3E, 0x3E, 0x1F, 0x1F, 0x3E, 0x3E, 0x1F, 0x1F, 0x3C, 0x7C, 0x3E,
  0x1F, 0x7C, 0x7C, 0x3E, 0x1E, 0x7C, 0x7C, 0x3E, 0x1E, 0x78, 0x78, 0x3E,
  0x3E, 0x78, 0xF8, 0x7C, 0x3E, 0xF8, 0xF8, 0x7C, 0x3C, 0xF8, 0xF8, 0x7C,
  0x7C, 0xF8, 0xF8, 0xFC, 0x78, 0xF8, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF, 0xFF,
  0xF0, 0xF8, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0xBF, 0xC0, 0xF8, 0x3F, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x3F, 0xF3, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xBF, 0x00,
  0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x01,
  0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE,
  0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0x0E,
  0x07, 0xFC, 0x08, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x04,
  0x0F, 0xF8, 0x30, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xBF, 0xF8, 0x0F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFF,
  0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F,
  0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F,
  0xC1, 0xFE, 0x3F, 0xE0, 0x7F, 0x7F, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0xE0, 0x3F, 0xE0, 0x08, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xF8, 0x7F, 0x0F, 0xFE,
  0x3F, 0xC3, 0xFF, 0x8F, 0xF0, 0xFF, 0xE3, 0xFC, 0x3F, 0xF0, 0xFF, 0x1F,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0,
  0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF8,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F,
  0x81, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xF1, 0xFB, 0xF8, 0x0F, 0xDF, 0x8F, 0xFF,
  0x80, 0x7E, 0xFC, 0xFD, 0xFC, 0x07, 0xF7, 0xE7, 0xEF, 0xE0, 0x3F, 0xBF,
  0x3E, 0x7F, 0x01, 0xFD, 0xFB, 0xF3, 0xF8, 0x0F, 0xCF, 0xDF, 0xBF, 0x80,
  0xFE, 0x7F, 0xF9, 0xFC, 0x07, 0xF3, 0xFF, 0xCF, 0xE0, 0x3F, 0x9F, 0xFC,
  0x7F, 0x01, 0xFC, 0xFF, 0xE3, 0xF0, 0x0F, 0xC7, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0xF1, 0xFC, 0x07, 0xF1, 0xFF, 0x0F, 0xE0, 0x3F, 0x8F, 0xF8, 0x7F,
  0x01, 0xF8, 0x7F, 0xC7, 0xF0, 0x0F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xE1, 0xFC, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x7F, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x03, 0xFF, 0x01, 0xF8, 0x0F, 0xFC, 0x0F, 0xE0, 0x3F,
  0xF0, 0x3F, 0x80, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x83, 0xF0, 0x1F, 0xFE,
  0x0F, 0xC0, 0x7F, 0xF8, 0x7F, 0x01, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0x87,
  0xF0, 0x3F, 0xFF, 0x1F, 0x80, 0xFF, 0xFC, 0xFE, 0x03, 0xF3, 0xF3, 0xF8,
  0x0F, 0xCF, 0xCF, 0xE0, 0x3F, 0x3F, 0x3F, 0x81, 0xFC, 0xFC, 0xFC, 0x07,
  0xF3, 0xFB, 0xF0, 0x1F, 0xCF, 0xFF, 0xC0, 0x7E, 0x1F, 0xFF, 0x03, 0xF8,
  0x7F, 0xFC, 0x0F, 0xE1, 0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0x80, 0xFE, 0x1F,
  0xFE, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0x03, 0xFF,
  0x01, 0xFC, 0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0xFF, 0xC0,
  0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF8,
  0x07, 0xF3, 0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF,
  0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x03, 0xFD,
  0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFF,
  0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xE3, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE7, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF9,
  0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F,
  0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFC, 0xFE, 0x01,
  0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE3,
  0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xDF, 0xC0, 0x3F, 0x9F,
  0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0x7C, 0x07, 0xF8, 0x18, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x40, 0x0F, 0xE0, 0x70, 0x1F, 0xE0, 0x7E, 0x7F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x7F, 0x81,
  0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0xE0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xE0, 0x3F, 0x9F,
  0xC0, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFF, 0x83, 0xF8, 0x7F, 0x07, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xF8, 0xFE, 0x07, 0xF1, 0xFF,
  0xC7, 0xF0, 0x3F, 0x8F, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0xE3, 0xF8, 0x0F,
  0xE7, 0xFF, 0x1F, 0xC0, 0x7F, 0x3E, 0xF9, 0xFC, 0x03, 0xFB, 0xF7, 0xCF,
  0xE0, 0x1F, 0x9F, 0xBE, 0x7F, 0x00, 0xFD, 0xF9, 0xF7, 0xF0, 0x07, 0xEF,
  0xDF, 0xBF, 0x80, 0x3F, 0x7C, 0xFF, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0xC0,
  0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0x8F,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x03, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xE3,
  0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x8F, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07,
  0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0x87,
  0xE1, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x07, 0xF9, 0xF8, 0x1F, 0xFB, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F,
  0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE3, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xDF, 0xC0, 0xFF, 0xBF, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x3F, 0x01, 0xFF, 0xFE, 0x07, 0xEF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F,
  0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE0, 0xFE, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF7,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xDF, 0xF8, 0x3F, 0x7F, 0xC0,
  0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF8, 0x21, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0x0F, 0xF0, 0x41, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0xDF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC7,
  0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFB, 0xF0,
  0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFE, 0x7F, 0x1F, 0xC3, 0xF3, 0xF8, 0x3F,
  0x3F, 0x83, 0xF7, 0xF0, 0x7F, 0x7F, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0x0F, 0xF0, 0x70, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x0C, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0xDF, 0x80, 0x7F,
  0xEF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xC7, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x01, 0x00, 0x7F, 0x80, 0xF0, 0x7F, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x3F,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC0,
  0x00, 0x30, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x09, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0xFE,
  0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xCF, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xE7, 0xF0, 0x7E, 0x03, 0xF7, 0xFC, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xCF, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0xFE,
  0x0F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0x83, 0xF8, 0x7F, 0x1F, 0xC1, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xC7,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF1,
  0xFC, 0x1F, 0x83, 0xF8, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x1F, 0x3F, 0xE0, 0x7D,
  0xFF, 0xC1, 0xF7, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F,
  0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x3F,
  0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x7F, 0x80, 0x3F, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFB, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7E,
  0x07, 0xFD, 0xF8, 0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xBF, 0x00,
  0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE3, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xC4, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xCF, 0x07, 0xF0, 0x60,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x40, 0x7F, 0x8C, 0x0F, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF0, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xEF, 0x80,
  0xFF, 0xBF, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF,
  0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x7F, 0x0F, 0xF0,
  0x7F, 0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0x1F, 0xF0, 0xFE, 0x7F, 0x1F, 0xF0,
  0xFC, 0x7F, 0x1F, 0xF1, 0xFC, 0x7E, 0x3F, 0xF1, 0xFC, 0x7E, 0x3F, 0xF1,
  0xF8, 0x7E, 0x7F, 0xF3, 0xF8, 0x7E, 0x7D, 0xF3, 0xF0, 0x7E, 0x7D, 0xF7,
  0xF0, 0x7E, 0xFF, 0xF7, 0xF0, 0x7E, 0xFB, 0xF7, 0xE0, 0x7E, 0xFB, 0xFF,
  0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0x7F, 0xF3, 0xEF, 0xC0, 0x7F, 0xF3, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7,
  0xE0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x4F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xBF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x09, 0xFE, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x07,
  0xFE, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 15, 36, 12, 0, -35 },
  { 69, 18, 13, 21, 5, -35 },
  { 99, 26, 35, 25, 0, -35 },
  { 213, 23, 40, 22, 0, -37 },
  { 328, 32, 35, 36, 3, -35 },
  { 468, 27, 35, 27, 0, -35 },
  { 587, 9, 13, 12, 5, -35 },
  { 602, 17, 43, 14, 1, -35 },
  { 694, 17, 44, 14, -4, -36 },
  { 788, 19, 22, 21, 4, -38 },
  { 841, 21, 23, 24, 2, -29 },
  { 902, 12, 14, 12, -3, -7 },
  { 923, 14, 6, 15, 0, -16 },
  { 934, 8, 9, 12, 0, -8 },
  { 943, 26, 35, 19, -3, -35 },
  { 1057, 21, 35, 22, 1, -35 },
  { 1149, 17, 35, 22, 5, -35 },
  { 1224, 24, 35, 22, -2, -35 },
  { 1329, 23, 35, 22, 0, -35 },
  { 1430, 24, 35, 22, -1, -35 },
  { 1535, 23, 35, 22, 0, -35 },
  { 1636, 23, 36, 22, 1, -36 },
  { 1740, 24, 35, 22, 1, -35 },
  { 1845, 23, 35, 22, 0, -35 },
  { 1946, 22, 36, 22, 0, -36 },
  { 2045, 12, 28, 12, 0, -27 },
  { 2087, 15, 34, 12, -3, -27 },
  { 2151, 21, 24, 24, 2, -30 },
  { 2214, 21, 16, 24, 2, -25 },
  { 2256, 21, 24, 24, 2, -30 },
  { 2319, 19, 36, 17, 1, -35 },
  { 2405, 32, 39, 33, 1, -35 },
  { 2561, 24, 35, 24, -3, -35 },
  { 2666, 25, 35, 24, 0, -35 },
  { 2776, 23, 35, 22, 2, -35 },
  { 2877, 26, 35, 26, 0, -35 },
  { 2991, 22, 35, 20, 0, -35 },
  { 3088, 22, 35, 19, 0, -35 },
  { 3185, 26, 35, 26, 2, -35 },
  { 3299, 29, 35, 27, 0, -35 },
  { 3426, 22, 35, 17, -2, -35 },
  { 3523, 23, 46, 13, -8, -35 },
  { 3656, 29, 35, 24, 0, -35 },
  { 3783, 17, 35, 19, 0, -35 },
  { 3858, 37, 35, 35, 0, -35 },
  { 4020, 30, 35, 28, 0, -35 },
  { 4152, 25, 36, 27, 2, -36 },
  { 4265, 25, 35, 23, 0, -35 },
  { 4375, 25, 44, 27, 2, -36 },
  { 4513, 24, 35, 24, 0, -35 },
  { 4618, 24, 35, 21, -1, -35 },
  { 4723, 20, 35, 20, 4, -35 },
  { 4811, 26, 35, 26, 2, -35 },
  { 4925, 24, 35, 24, 4, -35 },
  { 5030, 37, 35, 35, 3, -35 },
  { 5192, 29, 35, 23, -3, -35 },
  { 5319, 23, 35, 22, 4, -35 },
  { 5420, 26, 35, 20, -2, -35 },
  { 5534, 20, 43, 14, -2, -35 },
  { 5642, 11, 35, 19, 5, -35 },
  { 5691, 20, 43, 14, -4, -35 },
  { 5799, 23, 22, 22, -1, -35 },
  { 5863, 19, 4, 17, -5, 4 },
  { 5873, 10, 8, 15, 7, -38 },
  { 5883, 23, 27, 23, 1, -27 },
  { 5961, 22, 37, 23, 0, -37 },
  { 6063, 19, 27, 19, 1, -27 },
  { 6128, 25, 37, 23, 1, -37 },
  { 6244, 20, 27, 22, 1, -27 },
  { 6312, 26, 49, 14, -6, -37 },
  { 6472, 25, 39, 23, -1, -27 },
  { 6594, 22, 37, 23, 0, -37 },
  { 6696, 14, 38, 12, 0, -38 },
  { 6763, 20, 50, 12, -6, -38 },
  { 6888, 25, 37, 22, 0, -37 },
  { 7004, 14, 37, 12, 0, -37 },
  { 7069, 33, 27, 34, 0, -27 },
  { 7181, 22, 27, 23, 0, -27 },
  { 7256, 21, 27, 23, 1, -27 },
  { 7327, 25, 39, 23, -3, -27 },
  { 7449, 23, 39, 23, 1, -27 },
  { 7562, 19, 27, 16, 0, -27 },
  { 7627, 19, 27, 18, 0, -27 },
  { 7692, 15, 32, 15, 2, -32 },
  { 7752, 23, 27, 23, 1, -27 },
  { 7830, 21, 27, 21, 3, -27 },
  { 7901, 32, 27, 32, 2, -27 },
  { 8009, 26, 27, 21, -3, -27 },
  { 8097, 27, 39, 21, -3, -27 },
  { 8229, 21, 27, 18, -2, -27 },
  { 8300, 20, 43, 17, 0, -35 },
  { 8408, 6, 49, 19, 6, -38 },
  { 8445, 19, 43, 17, -3, -35 },
  { 8548, 21, 9, 24, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC49PT7B_H_
