#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x3F, 0x7F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C,
  0xF8, 0xFC, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03,
  0xE3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x78,
  0xF8, 0x00, 0xF1, 0xF0, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x1E,
  0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7,
  0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFD, 0x9C, 0x0F, 0xD8, 0x40,
  0xF9, 0x80, 0x0F, 0xD8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x4F, 0x84, 0x0C, 0xF8, 0x60, 0xDF, 0x87, 0x8D,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x3F, 0x80, 0x7C, 0x03, 0xFE, 0x07,
  0xC0, 0x3F, 0xF0, 0x3E, 0x03, 0xE7, 0x83, 0xE0, 0x1E, 0x3C, 0x1F, 0x00,
  0xF1, 0xE1, 0xF0, 0x0F, 0x8F, 0x0F, 0x00, 0x78, 0xF8, 0xF8, 0x03, 0xC7,
  0xC7, 0x80, 0x3E, 0x3E, 0x7C, 0x01, 0xF1, 0xE3, 0xC0, 0x0F, 0x9F, 0x3E,
  0x3C, 0x7C, 0xFB, 0xE3, 0xFB, 0xEF, 0x9F, 0x3F, 0xDF, 0xFD, 0xF3, 0xFF,
  0x7F, 0xCF, 0x3E, 0xFB, 0xFC, 0xF9, 0xE7, 0xCF, 0xC7, 0x9F, 0x3E, 0x00,
  0x7C, 0xF1, 0xF0, 0x03, 0xC7, 0x8F, 0x80, 0x3E, 0x7C, 0x7C, 0x03, 0xE3,
  0xE3, 0xC0, 0x1F, 0x1F, 0x1E, 0x01, 0xF0, 0xF9, 0xF0, 0x0F, 0x87, 0x8F,
  0x80, 0xF8, 0x3E, 0xF8, 0x07, 0x81, 0xFF, 0xC0, 0x7C, 0x0F, 0xFC, 0x03,
  0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFB, 0xF0, 0x03, 0xF3,
  0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE7,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0x07, 0xFC, 0x7E, 0x0F, 0xFE, 0x7E, 0x1F, 0xFE,
  0x7E, 0x3F, 0x7F, 0xFC, 0x7F, 0x7F, 0xFC, 0x7E, 0x3F, 0xF8, 0xFE, 0x3F,
  0xF8, 0xFC, 0x3F, 0xF0, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFE, 0x3F,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xE3, 0xF8, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xFC, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x04,
  0x3E, 0x03, 0x1F, 0x03, 0xEF, 0x0D, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE1, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF9,
  0xF0, 0x7C, 0xFC, 0x1C, 0x7C, 0x04, 0x18, 0x00, 0x08, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83,
  0xE0, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFC, 0xFC, 0x7E, 0x1F,
  0x1F, 0x87, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xDF,
  0xC3, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0x87, 0xEF, 0xE1,
  0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0xBF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x7F, 0xF9, 0xFF, 0xF1, 0xF7,
  0xE1, 0xCF, 0xC2, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x03, 0xC3, 0xF0, 0x38, 0x3F, 0x01,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3C, 0xFF,
  0x03, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x80, 0x7F, 0x0E,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xDF, 0x80,
  0x79, 0xF8, 0x0F, 0x9F, 0x80, 0xF1, 0xF8, 0x1E, 0x3F, 0x03, 0xE3, 0xF0,
  0x3C, 0x3F, 0x07, 0x83, 0xF2, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x80, 0x7F, 0x0F,
  0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xC6, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x3F, 0x7F, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xBF, 0x87, 0xF1, 0xF8,
  0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F,
  0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xBF, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE7,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xBF, 0x07, 0xEF,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x10, 0x3F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83,
  0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0,
  0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x7F, 0x18, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x1F, 0x0F, 0x87, 0xF8, 0xF1, 0xF0, 0xFF, 0xCF, 0x1E, 0x1F,
  0xF8, 0xF3, 0xE3, 0xFF, 0x8F, 0x3C, 0x7C, 0x78, 0xF3, 0xC7, 0x8F, 0x8F,
  0x78, 0xF8, 0xF8, 0xF7, 0x8F, 0x0F, 0x1E, 0x78, 0xF0, 0xF1, 0xE7, 0x9F,
  0x1F, 0x1E, 0xF1, 0xF1, 0xF1, 0xEF, 0x1E, 0x1E, 0x3C, 0xF1, 0xE3, 0xE3,
  0xCF, 0x1E, 0x3E, 0x78, 0xF1, 0xFF, 0xFF, 0x8F, 0x1F, 0xEF, 0xF0, 0xF0,
  0xFC, 0xFE, 0x0F, 0x07, 0x87, 0xC0, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x06, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x00,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0x9F, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1,
  0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xCF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xFE, 0xF0, 0x3F, 0xC0, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x02, 0x03, 0xFC, 0x70, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0xFF, 0x03, 0xF0, 0xFE, 0x07,
  0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81,
  0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x87, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xF7, 0xC0, 0xFF,
  0x03, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0xCF, 0xE1, 0xFF, 0x3F,
  0x8F, 0xFC, 0xFE, 0x3F, 0xF3, 0xF0, 0xFF, 0x8F, 0xC3, 0xFE, 0x3F, 0x01,
  0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0,
  0xFE, 0x0F, 0xC3, 0xFC, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x47, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xF3, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xBE, 0x3F, 0xFC, 0x0F,
  0xBE, 0x3E, 0xFC, 0x1F, 0xBE, 0x3F, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F,
  0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0xF9, 0xF8, 0x1F, 0x3E, 0xFB, 0xF8, 0x3F,
  0x3F, 0xFB, 0xF0, 0x3F, 0x3F, 0xF3, 0xF0, 0x3F, 0x3F, 0xF3, 0xF0, 0x3F,
  0x3F, 0xE3, 0xF0, 0x7E, 0x3F, 0xE7, 0xE0, 0x7E, 0x3F, 0xC7, 0xE0, 0x7E,
  0x3F, 0xC7, 0xE0, 0x7E, 0x3F, 0x87, 0xE0, 0x7C, 0x3F, 0x87, 0xE0, 0xFC,
  0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x07,
  0xE0, 0x7F, 0xC0, 0xFC, 0x0F, 0xF8, 0x1F, 0x01, 0xFF, 0x07, 0xE0, 0x3F,
  0xF0, 0xFC, 0x07, 0xFE, 0x1F, 0x81, 0xFF, 0xC3, 0xF0, 0x3F, 0xF8, 0xFC,
  0x07, 0xFF, 0x1F, 0x80, 0xFB, 0xE3, 0xF0, 0x1F, 0x7E, 0x7E, 0x07, 0xEF,
  0xCF, 0xC0, 0xFD, 0xF9, 0xF0, 0x1F, 0x9F, 0x7E, 0x03, 0xF3, 0xEF, 0xC0,
  0x7C, 0x7D, 0xF8, 0x1F, 0x8F, 0xFE, 0x03, 0xF1, 0xFF, 0xC0, 0x7E, 0x3F,
  0xF8, 0x0F, 0x83, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x0F, 0xF8, 0x0F,
  0xC1, 0xFF, 0x01, 0xF8, 0x3F, 0xE0, 0x3E, 0x07, 0xFC, 0x0F, 0xC0, 0x7F,
  0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F,
  0xDF, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9,
  0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x1F,
  0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7F,
  0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x3F,
  0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0,
  0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x1F, 0x81, 0xFC, 0x3F, 0x03,
  0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x8F,
  0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F,
  0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x83,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7E, 0x0F,
  0xE3, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC1, 0x80, 0xFE,
  0x04, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x08, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0xBF, 0xFF, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x7F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF,
  0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0x80,
  0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x7F, 0x7E, 0x07, 0xE0, 0x7E,
  0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xE0, 0xFE, 0x7E, 0x0F, 0xE0, 0xFC,
  0x7E, 0x0F, 0xE0, 0xFC, 0x7E, 0x1F, 0xE1, 0xF8, 0x7E, 0x1F, 0xE1, 0xF8,
  0x7E, 0x3F, 0xE3, 0xF8, 0x7E, 0x3F, 0xE3, 0xF0, 0x7C, 0x3F, 0xE3, 0xF0,
  0x7C, 0x7F, 0xE7, 0xF0, 0xFC, 0x7F, 0xE7, 0xE0, 0xFC, 0xFF, 0xC7, 0xE0,
  0xFC, 0xFF, 0xCF, 0xC0, 0xFC, 0xFF, 0xCF, 0xC0, 0xFD, 0xF7, 0xDF, 0xC0,
  0xFD, 0xF7, 0xDF, 0x80, 0xFD, 0xF7, 0xDF, 0x80, 0xFF, 0xE7, 0xFF, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x7F, 0x0F, 0xEF, 0xE1,
  0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC,
  0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C,
  0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x3E, 0x0F, 0x83,
  0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0,
  0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F, 0x1F,
  0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x01, 0xE3, 0xF0, 0x7F, 0x3F, 0x0F, 0xFB,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFD, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0,
  0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F,
  0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFB, 0xE0,
  0x7F, 0x3E, 0x03, 0xE3, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0xF8, 0x0F, 0xDF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1,
  0xF8, 0x7F, 0x1F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF3, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xBF,
  0xC0, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xE1, 0xFE, 0x70, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x04, 0x3F, 0x8E, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0x8F, 0xC0, 0x7F,
  0xBF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF9, 0xFE,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF, 0x80, 0x3F,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xFF, 0x87, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x7E, 0x1F, 0x9F, 0x9F,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x43, 0xFD, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xF9, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0xFC, 0x07, 0xFB, 0xF0, 0x3F, 0xEF, 0x80, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xDF, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC,
  0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x20, 0x1F, 0xC0, 0xC0, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFD, 0xF0, 0x3F, 0x7F,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F,
  0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0xFE,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x1F,
  0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x80, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x00, 0x07, 0x8F, 0x83, 0xE0, 0x7C, 0xFE, 0x3F, 0x83,
  0xEF, 0xFB, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xF7,
  0xFD, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0xCF, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1,
  0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF8, 0x07, 0x8F, 0x81, 0xF3, 0xF8,
  0x3E, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xF1, 0xF8,
  0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xE7, 0xF3, 0xF0, 0xFD, 0xFC, 0x3F, 0x7E, 0x0F,
  0xDF, 0x83, 0xF7, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0xBF, 0x0F, 0xCF, 0xC7, 0xF3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xF0,
  0xF0, 0x03, 0xE7, 0xF0, 0x07, 0xDF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFE,
  0x07, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xEF, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF1, 0xF0, 0x7F, 0xBF, 0x0F, 0xFB, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xF9, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0xC1, 0xF7, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFC, 0x30, 0xFE, 0x08, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x40, 0xFE, 0x30, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFE, 0x7F, 0xF8, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0x83, 0xF1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xBE, 0x03, 0xF3, 0xE0, 0xFC, 0x1F, 0xFF, 0x07,
  0xEF, 0xC3, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x9F, 0x83, 0xE7, 0xE0, 0xFB,
  0xF0, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x7E, 0x1F, 0xC3, 0xF7, 0xE3, 0xFC, 0x3E, 0x7C, 0x3F, 0xC7,
  0xE7, 0xC3, 0xFC, 0x7E, 0x7C, 0x7F, 0x8F, 0xC7, 0xC7, 0xF8, 0xFC, 0x7C,
  0x7F, 0x8F, 0x87, 0xCF, 0xF9, 0xF8, 0x7C, 0xF7, 0x9F, 0x87, 0xDF, 0xF9,
  0xF0, 0xFD, 0xFF, 0xBF, 0x0F, 0xDE, 0xFB, 0xE0, 0xFF, 0xEF, 0xBE, 0x0F,
  0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F,
  0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x03,
  0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x03,
  0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x03,
  0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x07, 0xFA, 0x00, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 13, 31, 11, 0, -31 },
  { 52, 16, 11, 18, 4, -31 },
  { 74, 23, 31, 22, 0, -31 },
  { 164, 20, 36, 19, 0, -33 },
  { 254, 29, 31, 32, 2, -31 },
  { 367, 24, 31, 24, 0, -31 },
  { 460, 8, 11, 10, 4, -31 },
  { 471, 14, 38, 12, 1, -31 },
  { 538, 14, 38, 12, -3, -31 },
  { 605, 17, 19, 18, 3, -33 },
  { 646, 18, 21, 21, 2, -26 },
  { 694, 10, 12, 11, -2, -6 },
  { 709, 12, 5, 13, 0, -14 },
  { 717, 7, 7, 11, 0, -7 },
  { 724, 22, 31, 17, -2, -31 },
  { 810, 18, 31, 19, 1, -31 },
  { 880, 15, 31, 19, 4, -31 },
  { 939, 20, 31, 19, -1, -31 },
  { 1017, 20, 31, 19, 0, -31 },
  { 1095, 20, 31, 19, 0, -31 },
  { 1173, 20, 31, 19, 0, -31 },
  { 1251, 20, 31, 19, 1, -31 },
  { 1329, 21, 31, 19, 1, -31 },
  { 1411, 20, 31, 19, 0, -31 },
  { 1489, 19, 31, 19, 0, -31 },
  { 1563, 11, 24, 11, 0, -24 },
  { 1596, 13, 30, 11, -2, -24 },
  { 1645, 18, 21, 21, 2, -26 },
  { 1693, 18, 14, 21, 2, -22 },
  { 1725, 18, 21, 21, 2, -26 },
  { 1773, 16, 31, 15, 1, -31 },
  { 1835, 28, 34, 29, 1, -31 },
  { 1954, 22, 31, 21, -3, -31 },
  { 2040, 22, 31, 21, 0, -31 },
  { 2126, 21, 31, 19, 1, -31 },
  { 2208, 23, 31, 23, 0, -31 },
  { 2298, 20, 31, 18, 0, -31 },
  { 2376, 20, 31, 17, 0, -31 },
  { 2454, 22, 31, 23, 2, -31 },
  { 2540, 25, 31, 23, 0, -31 },
  { 2637, 20, 31, 15, -2, -31 },
  { 2715, 20, 40, 11, -7, -31 },
  { 2815, 25, 31, 21, 0, -31 },
  { 2912, 15, 31, 17, 0, -31 },
  { 2971, 32, 31, 31, 0, -31 },
  { 3095, 27, 31, 25, 0, -31 },
  { 3200, 23, 31, 24, 1, -31 },
  { 3290, 22, 31, 20, 0, -31 },
  { 3376, 23, 38, 24, 1, -31 },
  { 3486, 21, 31, 21, 0, -31 },
  { 3568, 21, 31, 18, -1, -31 },
  { 3650, 18, 31, 18, 3, -31 },
  { 3720, 23, 31, 23, 1, -31 },
  { 3810, 21, 31, 21, 4, -31 },
  { 3892, 32, 31, 31, 3, -31 },
  { 4016, 26, 31, 20, -3, -31 },
  { 4117, 19, 31, 20, 4, -31 },
  { 4191, 23, 31, 18, -2, -31 },
  { 4281, 18, 38, 12, -2, -31 },
  { 4367, 10, 31, 17, 4, -31 },
  { 4406, 17, 38, 12, -3, -31 },
  { 4487, 20, 20, 19, -1, -31 },
  { 4537, 16, 4, 15, -4, 3 },
  { 4545, 9, 7, 13, 6, -33 },
  { 4553, 20, 24, 20, 1, -24 },
  { 4613, 20, 33, 20, 0, -33 },
  { 4696, 17, 24, 16, 1, -24 },
  { 4747, 22, 33, 20, 1, -33 },
  { 4838, 18, 24, 19, 1, -24 },
  { 4892, 23, 43, 13, -5, -33 },
  { 5016, 22, 34, 20, -1, -24 },
  { 5110, 19, 33, 20, 0, -33 },
  { 5189, 12, 33, 10, 0, -33 },
  { 5239, 17, 43, 10, -5, -33 },
  { 5331, 22, 33, 19, 0, -33 },
  { 5422, 13, 33, 10, 0, -33 },
  { 5476, 29, 24, 30, 0, -24 },
  { 5563, 19, 24, 20, 0, -24 },
  { 5620, 18, 24, 20, 1, -24 },
  { 5674, 23, 34, 20, -3, -24 },
  { 5772, 20, 34, 20, 1, -24 },
  { 5857, 17, 24, 14, 0, -24 },
  { 5908, 17, 24, 16, 0, -24 },
  { 5959, 14, 28, 14, 1, -28 },
  { 6008, 20, 24, 20, 1, -24 },
  { 6068, 18, 24, 18, 3, -24 },
  { 6122, 28, 24, 28, 2, -24 },
  { 6206, 23, 24, 18, -2, -24 },
  { 6275, 24, 34, 18, -3, -24 },
  { 6377, 19, 24, 16, -2, -24 },
  { 6434, 18, 38, 15, 0, -31 },
  { 6520, 6, 43, 16, 5, -33 },
  { 6553, 17, 38, 15, -3, -31 },
  { 6634, 18, 8, 21, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC43PT7B_H_
