#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x10, 0x00, 0x3F,
  0x9F, 0x9F, 0x9F, 0xCF, 0xCF, 0xEF, 0xE7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9,
  0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3F, 0x3F, 0x1F, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03,
  0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0x80, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x67, 0x03, 0xF3, 0x08, 0x1F, 0xB0, 0x00, 0xFD, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xBF, 0x00,
  0x0D, 0xF8, 0x60, 0x6F, 0xC3, 0x86, 0x7E, 0x1F, 0xBF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x80, 0x7C,
  0x03, 0xFE, 0x03, 0xE0, 0x1F, 0xFC, 0x0F, 0x80, 0xF9, 0xF0, 0x7C, 0x03,
  0xE7, 0xC1, 0xF0, 0x0F, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x3C, 0x01, 0xF1,
  0xF1, 0xF0, 0x07, 0xC7, 0xCF, 0x80, 0x1E, 0x1E, 0x3E, 0x00, 0xF8, 0xF9,
  0xF0, 0x03, 0xE3, 0xE7, 0xC3, 0x8F, 0x8F, 0x3E, 0x3F, 0xBE, 0x7C, 0xF9,
  0xFF, 0x7F, 0xE7, 0xCF, 0xFD, 0xFF, 0x9F, 0x7F, 0xF7, 0xFC, 0xF9, 0xF3,
  0xCF, 0xE7, 0xCF, 0x8F, 0x04, 0x1F, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0xF0,
  0x03, 0xE7, 0xC7, 0xC0, 0x1F, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x7C, 0x03,
  0xE1, 0xF1, 0xE0, 0x0F, 0x87, 0xCF, 0x80, 0x7C, 0x1F, 0x3E, 0x01, 0xE0,
  0x7D, 0xF0, 0x0F, 0x81, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x0F,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xCF, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0x87, 0xFF,
  0x1F, 0x87, 0xFF, 0xDF, 0xC7, 0xFF, 0xEF, 0xC3, 0xF7, 0xF7, 0xE3, 0xF9,
  0xFF, 0xE1, 0xF8, 0xFF, 0xF1, 0xFC, 0x3F, 0xF0, 0xFE, 0x1F, 0xF8, 0x7F,
  0x0F, 0xF8, 0x3F, 0x87, 0xF8, 0x1F, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xF8, 0x1F, 0xE1, 0xFC,
  0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x21, 0xF8,
  0x0E, 0x7C, 0x07, 0xFF, 0x19, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFD,
  0xF8, 0x3E, 0x3E, 0x07, 0x8F, 0x80, 0xC3, 0xC0, 0x10, 0x40, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x3F, 0xFB, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xF8, 0x3E, 0x7E, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFC, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFD, 0xF8, 0x7F, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8,
  0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xDF, 0xC1,
  0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x7F, 0x0F,
  0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F,
  0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0x7F, 0x7F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xFC, 0xFE, 0xFC, 0x7D, 0xFC, 0x39, 0xFC, 0x11, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xCF, 0xE0, 0x78, 0x7F, 0x01, 0x83, 0xF8,
  0x08, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0x1F, 0xE0, 0x60, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x20,
  0x0F, 0xE1, 0xF3, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3D, 0xF8, 0x01, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x3C, 0xFE, 0x01,
  0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0x87,
  0xF0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xB8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x21, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x80, 0x3F, 0x86, 0x03, 0xFC, 0x3E, 0x3F, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xF0, 0x40, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF9, 0xF0, 0x1F, 0xBF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x8F, 0xE0,
  0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF,
  0xE0, 0x7E, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xF9, 0xFC,
  0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0,
  0x7E, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xF7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1,
  0xF8, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xEF,
  0xE0, 0x7C, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x0C, 0x1F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x0F, 0xF1,
  0xFE, 0x3F, 0x87, 0xF0, 0x7C, 0x02, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x78, 0xFE, 0x30, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0x78, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0x83, 0xFC, 0x78, 0x78, 0x7F,
  0xF3, 0xC7, 0xC7, 0xFF, 0x1E, 0x3C, 0x7F, 0xF8, 0xF3, 0xE3, 0xE3, 0xC7,
  0x9E, 0x3E, 0x3E, 0x3C, 0xF1, 0xE1, 0xF1, 0xEF, 0x9F, 0x0F, 0x0F, 0x78,
  0xF8, 0x78, 0xFB, 0xC7, 0x87, 0xC7, 0x9E, 0x3C, 0x3E, 0x3D, 0xF3, 0xE1,
  0xE1, 0xEF, 0x1F, 0x1F, 0x1E, 0x78, 0xF8, 0xF8, 0xF3, 0xC7, 0xCF, 0xCF,
  0x1E, 0x1F, 0xFF, 0xF8, 0xF0, 0xFF, 0xFF, 0x87, 0x87, 0xF3, 0xF8, 0x3E,
  0x0E, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00,
  0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xE7, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xEF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE,
  0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x7F, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xE7, 0x81, 0xFE,
  0x08, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x81, 0xFF, 0x7C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFF, 0x07, 0xE0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x1F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0x1E, 0x07, 0xF8, 0x04, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x8F, 0xFC, 0xFE, 0x1F, 0xF9, 0xFC, 0x3F, 0xF3, 0xF8,
  0x7F, 0xE7, 0xF1, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F,
  0x87, 0xFC, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x04, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF1,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF,
  0x1F, 0xFE, 0x03, 0xFF, 0xC7, 0xDF, 0x80, 0xFF, 0xF3, 0xFF, 0xE0, 0x7E,
  0xFC, 0xFB, 0xF8, 0x1F, 0xBF, 0x3E, 0xFC, 0x07, 0xEF, 0xDF, 0xBF, 0x01,
  0xFB, 0xF7, 0xCF, 0xC0, 0xFE, 0xFF, 0xF7, 0xF0, 0x3F, 0x3F, 0xF9, 0xFC,
  0x0F, 0xCF, 0xFE, 0x7E, 0x03, 0xF3, 0xFF, 0x1F, 0x80, 0xFC, 0xFF, 0xC7,
  0xE0, 0x7F, 0x3F, 0xE3, 0xF8, 0x1F, 0x8F, 0xF8, 0xFC, 0x07, 0xE3, 0xFE,
  0x3F, 0x01, 0xF8, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC7, 0xF0, 0x3F, 0x87,
  0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xF0, 0x7C, 0x1F, 0x80, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0xE0,
  0x7E, 0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xC0,
  0x7F, 0xE0, 0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x7F, 0xF0, 0xFC, 0x0F, 0xFF,
  0x1F, 0xC0, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0x1F, 0x80, 0xFD, 0xF1, 0xF8,
  0x0F, 0xDF, 0x1F, 0x81, 0xF9, 0xFB, 0xF0, 0x1F, 0x9F, 0xBF, 0x01, 0xF9,
  0xFB, 0xF0, 0x1F, 0x9F, 0xBF, 0x03, 0xF8, 0xFB, 0xF0, 0x3F, 0x0F, 0xFE,
  0x03, 0xF0, 0xFF, 0xE0, 0x3F, 0x0F, 0xFE, 0x03, 0xF0, 0xFF, 0xE0, 0x7F,
  0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x7F,
  0xC0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0x7F, 0xC0, 0xFC, 0x07, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC,
  0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F,
  0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x83, 0xF8,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x83, 0xF1, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE,
  0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F,
  0xE3, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xCF,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xF3, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0x87,
  0xF0, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFE, 0x0C, 0x07, 0xF0,
  0x10, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0x80, 0x7F, 0x07,
  0x83, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xBF, 0x01, 0xF8, 0x1F, 0xDF,
  0x81, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x07, 0xF3,
  0xF0, 0x7F, 0x83, 0xF1, 0xF8, 0x3F, 0xC3, 0xF8, 0xFC, 0x3F, 0xE1, 0xFC,
  0x7E, 0x1F, 0xF0, 0xFC, 0x3F, 0x0F, 0xF8, 0xFE, 0x1F, 0x8F, 0xFC, 0x7E,
  0x0F, 0xC7, 0xFE, 0x7F, 0x07, 0xE7, 0xFF, 0x3F, 0x83, 0xF3, 0xFF, 0x1F,
  0x81, 0xF9, 0xFF, 0x9F, 0xC0, 0xFD, 0xFF, 0xCF, 0xC0, 0x7E, 0xFB, 0xE7,
  0xE0, 0x7F, 0xFD, 0xF7, 0xF0, 0x3F, 0x7E, 0xFB, 0xF0, 0x1F, 0xBE, 0x7F,
  0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x8F,
  0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xF8, 0xFC,
  0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF1, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x3F,
  0xCF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83,
  0xF9, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F,
  0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xF7, 0xE0, 0x3F,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x3E, 0x01, 0xFB, 0xF8, 0x1F, 0xBF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xF9, 0xFE, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFB, 0x83, 0xF8, 0x20,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x83, 0xF8, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xE7, 0xF0, 0x1F, 0xEF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF7, 0xFC,
  0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1,
  0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE3, 0xF3, 0xF8, 0x7C, 0xFC,
  0x1F, 0x7F, 0x0F, 0xDF, 0x87, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFE, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x18, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x80, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x7E, 0x01, 0xFC, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF8, 0xFE, 0x07, 0xF1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xFC, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7, 0xE0, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x18, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x7C, 0x07,
  0xFF, 0xE0, 0xFD, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFE, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F,
  0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F,
  0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0x00,
  0x40, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x10,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF8, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F,
  0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xC7, 0xC1, 0xF0,
  0x1F, 0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xF7, 0xF1, 0xFE, 0x7F, 0x8F, 0xC7, 0xF1,
  0xFC, 0x3F, 0x1F, 0xC7, 0xF0, 0xFC, 0x7E, 0x1F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0xCF, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x87,
  0xE3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x3F, 0x0F, 0xC7, 0xE1, 0xFC, 0x3F, 0x1F, 0x87, 0xE0, 0xFC, 0xFE,
  0x1F, 0x87, 0xF3, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xE0, 0x07, 0xC7, 0xC0, 0x7D, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF1,
  0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xF3, 0xF8, 0x7E,
  0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xBF, 0xCF,
  0xE3, 0xF9, 0xF8, 0x7F, 0x7F, 0x07, 0xEF, 0xE1, 0xFD, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFE, 0xFC,
  0x1F, 0xDF, 0x83, 0xF3, 0xF0, 0xFE, 0x7F, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0xF9, 0xFC, 0x01, 0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFE, 0xFE, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE,
  0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xF3, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xBF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF1, 0xF8,
  0x1F, 0xCF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xEF,
  0xF8, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0x83, 0xF8, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xF7, 0xE0,
  0x3F, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC7, 0x83, 0xEF,
  0xC3, 0xF7, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF0, 0xFE, 0x38, 0x7E, 0x08, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x20, 0x3F, 0x9C, 0x3F, 0x8F, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0xF3, 0xFF, 0x9F, 0xFE, 0x7F, 0xFB,
  0xFF, 0xEF, 0xFF, 0x8F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x43, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE,
  0x00, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x0F, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xFC, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xF7, 0xE0, 0x3F, 0x3E, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB,
  0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xE1, 0xFB, 0xF0,
  0xFF, 0x0F, 0xDF, 0x87, 0xF0, 0xFC, 0xFC, 0x7F, 0x87, 0xE7, 0xE3, 0xFC,
  0x3F, 0x3F, 0x1F, 0xE3, 0xF1, 0xF9, 0xFF, 0x1F, 0x8F, 0xCF, 0xF9, 0xF8,
  0x7E, 0xFF, 0xCF, 0xC3, 0xF7, 0xFE, 0x7E, 0x1F, 0x3F, 0xF7, 0xE0, 0xFB,
  0xEF, 0xBF, 0x07, 0xDF, 0x7D, 0xF0, 0x3E, 0xF3, 0xFF, 0x81, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xE0,
  0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F,
  0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF4, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 33, 11, 0, -32 },
  { 59, 17, 11, 19, 4, -32 },
  { 83, 24, 32, 23, 0, -32 },
  { 179, 21, 37, 20, 0, -34 },
  { 277, 30, 33, 33, 2, -33 },
  { 401, 25, 33, 25, 0, -33 },
  { 505, 9, 11, 11, 4, -32 },
  { 518, 15, 40, 12, 1, -33 },
  { 593, 16, 40, 12, -4, -33 },
  { 673, 18, 20, 19, 3, -35 },
  { 718, 19, 22, 22, 2, -27 },
  { 771, 11, 12, 11, -3, -6 },
  { 788, 13, 6, 13, 0, -15 },
  { 798, 8, 8, 11, 0, -7 },
  { 806, 23, 33, 17, -2, -33 },
  { 901, 19, 33, 20, 1, -33 },
  { 980, 16, 32, 20, 4, -32 },
  { 1044, 21, 33, 20, -1, -33 },
  { 1131, 21, 33, 20, 0, -33 },
  { 1218, 22, 32, 20, -1, -32 },
  { 1306, 21, 32, 20, 0, -32 },
  { 1390, 21, 33, 20, 1, -33 },
  { 1477, 22, 32, 20, 1, -32 },
  { 1565, 21, 33, 20, 0, -33 },
  { 1652, 20, 33, 20, 0, -33 },
  { 1735, 11, 26, 11, 0, -25 },
  { 1771, 14, 31, 11, -3, -25 },
  { 1826, 19, 22, 22, 2, -27 },
  { 1879, 19, 15, 22, 2, -23 },
  { 1915, 19, 22, 22, 2, -27 },
  { 1968, 17, 34, 16, 1, -33 },
  { 2041, 29, 36, 30, 1, -32 },
  { 2172, 23, 32, 22, -3, -32 },
  { 2264, 23, 32, 22, 0, -32 },
  { 2356, 21, 33, 20, 2, -33 },
  { 2443, 24, 32, 24, 0, -32 },
  { 2539, 21, 32, 18, 0, -32 },
  { 2623, 21, 32, 18, 0, -32 },
  { 2707, 23, 33, 24, 2, -33 },
  { 2802, 26, 32, 25, 0, -32 },
  { 2906, 21, 32, 15, -2, -32 },
  { 2990, 20, 42, 12, -7, -32 },
  { 3095, 26, 32, 22, 0, -32 },
  { 3199, 15, 32, 18, 0, -32 },
  { 3259, 34, 32, 32, 0, -32 },
  { 3395, 28, 32, 26, 0, -32 },
  { 3507, 23, 33, 25, 2, -33 },
  { 3602, 23, 32, 21, 0, -32 },
  { 3694, 23, 41, 25, 2, -33 },
  { 3812, 22, 32, 22, 0, -32 },
  { 3900, 22, 33, 19, -1, -33 },
  { 3991, 19, 32, 19, 3, -32 },
  { 4067, 24, 32, 24, 2, -32 },
  { 4163, 22, 32, 22, 4, -32 },
  { 4251, 33, 32, 32, 3, -32 },
  { 4383, 27, 32, 21, -3, -32 },
  { 4491, 21, 32, 20, 4, -32 },
  { 4575, 24, 32, 19, -2, -32 },
  { 4671, 18, 40, 13, -2, -33 },
  { 4761, 10, 33, 17, 4, -33 },
  { 4803, 18, 40, 13, -3, -33 },
  { 4893, 21, 20, 20, -1, -32 },
  { 4946, 16, 5, 16, -4, 3 },
  { 4956, 9, 7, 14, 6, -34 },
  { 4964, 21, 25, 21, 1, -25 },
  { 5030, 21, 34, 21, 0, -34 },
  { 5120, 18, 25, 17, 1, -25 },
  { 5177, 23, 34, 21, 1, -34 },
  { 5275, 18, 25, 20, 1, -25 },
  { 5332, 23, 45, 13, -5, -34 },
  { 5462, 23, 36, 21, -1, -25 },
  { 5566, 20, 34, 21, 0, -34 },
  { 5651, 13, 35, 11, 0, -35 },
  { 5708, 19, 46, 11, -6, -35 },
  { 5818, 23, 34, 20, 0, -34 },
  { 5916, 13, 34, 11, 0, -34 },
  { 5972, 30, 25, 31, 0, -25 },
  { 6066, 20, 25, 21, 0, -25 },
  { 6129, 19, 25, 21, 1, -25 },
  { 6189, 24, 36, 21, -3, -25 },
  { 6297, 21, 36, 21, 1, -25 },
  { 6392, 17, 25, 15, 0, -25 },
  { 6446, 17, 25, 17, 0, -25 },
  { 6500, 14, 30, 14, 2, -30 },
  { 6553, 21, 25, 21, 1, -25 },
  { 6619, 19, 25, 19, 3, -25 },
  { 6679, 29, 25, 29, 2, -25 },
  { 6770, 23, 25, 19, -2, -25 },
  { 6842, 25, 36, 19, -3, -25 },
  { 6955, 20, 25, 16, -2, -25 },
  { 7018, 19, 39, 15, 0, -32 },
  { 7111, 5, 45, 17, 6, -35 },
  { 7140, 18, 39, 15, -3, -32 },
  { 7228, 19, 8, 22, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC45PT7B_H_
