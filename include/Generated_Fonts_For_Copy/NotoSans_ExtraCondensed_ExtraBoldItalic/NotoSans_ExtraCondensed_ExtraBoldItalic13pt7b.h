#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x64, 0x0C, 0xC0, 0x7E, 0xF4, 0x16, 0x29, 0xFB, 0xF2,
  0x9F, 0x96, 0x28, 0xF0, 0x08, 0xF7, 0xDC, 0x70, 0xE1, 0xAE, 0xF8, 0x82,
  0x00, 0x66, 0xB4, 0xBC, 0xAB, 0xFF, 0x15, 0x35, 0x2F, 0x46, 0x3C, 0x58,
  0xB1, 0xC7, 0x7B, 0xF7, 0x6E, 0xFC, 0x7B, 0x00, 0x39, 0x18, 0xC4, 0x63,
  0x18, 0xC6, 0x30, 0x31, 0x11, 0x11, 0x33, 0x36, 0x6C, 0x35, 0x3E, 0xED,
  0x28, 0x63, 0x19, 0xF6, 0x31, 0x80, 0x6D, 0x60, 0xF0, 0xF0, 0x06, 0x18,
  0x30, 0xC1, 0x06, 0x08, 0x30, 0xC0, 0x3C, 0xB6, 0xDB, 0x4F, 0x2D, 0xBE,
  0x70, 0x3B, 0xBC, 0xE3, 0x19, 0x8C, 0x60, 0x3D, 0xB0, 0xC6, 0x18, 0xC6,
  0x3E, 0xF8, 0x7C, 0xB0, 0xCE, 0x39, 0x61, 0xBE, 0xF0, 0x0C, 0x73, 0x8E,
  0x5B, 0x7F, 0x84, 0x30, 0x3C, 0x86, 0x1E, 0x78, 0x61, 0xBE, 0xF0, 0x1C,
  0xC6, 0x1E, 0x7F, 0x3D, 0xBE, 0x70, 0x7E, 0x18, 0x30, 0xC1, 0x86, 0x0C,
  0x30, 0xE0, 0x3D, 0xB6, 0xCE, 0x7B, 0x6D, 0xB6, 0x70, 0x3D, 0xB6, 0xDB,
  0x7D, 0xE1, 0xBC, 0xE0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x64, 0xC0,
  0x04, 0x77, 0xB8, 0x38, 0x30, 0xFF, 0xC1, 0xFF, 0x80, 0x86, 0x1C, 0x7F,
  0x60, 0x7A, 0xC6, 0x66, 0x30, 0x08, 0xC0, 0x1F, 0x18, 0xDB, 0xAA, 0xD5,
  0x5F, 0xAB, 0xFD, 0xA4, 0x44, 0x1E, 0x00, 0x0E, 0x3C, 0x78, 0xB3, 0x67,
  0xDF, 0xB3, 0xC6, 0x3C, 0x5D, 0x93, 0xE7, 0x8D, 0xB3, 0x7C, 0xF8, 0x1E,
  0x69, 0x83, 0x06, 0x1C, 0x38, 0x3C, 0x78, 0x3C, 0x5D, 0x9B, 0x36, 0x6D,
  0xB3, 0x7C, 0xF0, 0x3C, 0x86, 0x1E, 0x79, 0x8C, 0x3C, 0xF0, 0x3C, 0x86,
  0x18, 0x79, 0x8C, 0x30, 0xC0, 0x1E, 0x65, 0x83, 0x06, 0xFD, 0xBB, 0x3E,
  0x7C, 0x37, 0x26, 0x66, 0x7E, 0x7E, 0x6C, 0xCC, 0xCC, 0xCC, 0x3C, 0x61,
  0x86, 0x30, 0xC3, 0x0C, 0xF8, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C, 0x30,
  0xCE, 0x30, 0x37, 0x2C, 0x6C, 0x78, 0x78, 0x78, 0xD8, 0xD8, 0xDC, 0x32,
  0x66, 0x66, 0xCF, 0xF0, 0x31, 0xCC, 0xE7, 0x39, 0xCE, 0x7F, 0x97, 0x6D,
  0xD3, 0x6C, 0xDB, 0x00, 0x33, 0x33, 0x7A, 0x7E, 0x7E, 0x5E, 0xCE, 0xCC,
  0xCC, 0x3E, 0x6D, 0x9B, 0x36, 0x7C, 0xF3, 0x3E, 0x78, 0x3C, 0x5D, 0x9B,
  0x67, 0xCF, 0x30, 0x60, 0xC0, 0x3E, 0x6D, 0x9B, 0x36, 0x7C, 0xF3, 0x3E,
  0x78, 0x30, 0x60, 0x3C, 0xB6, 0xDB, 0x79, 0xED, 0xB6, 0xDC, 0x3D, 0xD6,
  0x1C, 0x38, 0x61, 0xBE, 0xF0, 0xF9, 0x18, 0xC6, 0x33, 0x18, 0xC0, 0x36,
  0x4D, 0x9B, 0x36, 0xCD, 0xB3, 0x3E, 0x78, 0xCF, 0x9B, 0x66, 0xCD, 0x1E,
  0x3C, 0x70, 0xE0, 0xCD, 0xF7, 0x6D, 0xD3, 0x6C, 0xFB, 0x3B, 0x8E, 0xE3,
  0xB8, 0xCC, 0x00, 0x33, 0x1E, 0x1C, 0x1C, 0x18, 0x3C, 0x3C, 0x6C, 0xEC,
  0xCF, 0x65, 0x9C, 0x61, 0x86, 0x10, 0xC0, 0x3E, 0x0C, 0x30, 0xC1, 0x86,
  0x08, 0x3E, 0xF8, 0x1C, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x4E, 0x00,
  0xC9, 0x26, 0xDB, 0x60, 0x38, 0xC6, 0x21, 0x18, 0xC6, 0x21, 0x38, 0x18,
  0xE2, 0x9A, 0x4F, 0x30, 0xF8, 0xD0, 0x3D, 0xB6, 0xF3, 0xDB, 0x67, 0x80,
  0x30, 0xC6, 0x1F, 0x6D, 0xB4, 0xF2, 0xFB, 0xC0, 0x3B, 0x59, 0x8C, 0x79,
  0xC0, 0x06, 0x0C, 0x11, 0xE6, 0xCD, 0xB3, 0x6C, 0xD8, 0xF0, 0x39, 0xB4,
  0xBE, 0xC3, 0x27, 0x80, 0x0C, 0x71, 0x0E, 0x30, 0xC3, 0x08, 0x61, 0x86,
  0x38, 0xC0, 0x3D, 0xB6, 0xF3, 0xDB, 0x67, 0x86, 0xB3, 0xC0, 0x30, 0xC6,
  0x1F, 0x6D, 0xB4, 0xF6, 0xDB, 0x60, 0x33, 0x06, 0x66, 0x4C, 0xCC, 0x0C,
  0x30, 0x06, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x38, 0xE0, 0x30, 0x41, 0x8B,
  0x67, 0x8F, 0x1C, 0x7C, 0xD9, 0xB0, 0x33, 0x66, 0x66, 0x4C, 0xCC, 0x7F,
  0xB6, 0xDB, 0x69, 0x2D, 0xB6, 0xDB, 0x6C, 0x7D, 0xB6, 0xD3, 0xDB, 0x6D,
  0x80, 0x39, 0xB4, 0xF3, 0xDB, 0x67, 0x00, 0x3E, 0x6C, 0xD9, 0x36, 0x6F,
  0x9E, 0x30, 0x41, 0x80, 0x3D, 0xB4, 0xF3, 0xDB, 0x67, 0x86, 0x10, 0xC0,
  0x7B, 0xD8, 0x8C, 0x63, 0x00, 0x7B, 0x58, 0xE3, 0x5B, 0x80, 0x31, 0x5C,
  0xC6, 0x31, 0x1A, 0x60, 0x6D, 0xB6, 0xD2, 0xDB, 0xE7, 0x80, 0xDE, 0xBD,
  0xEE, 0x73, 0x00, 0xDB, 0xFA, 0xBE, 0xBE, 0xFC, 0xDC, 0xD8, 0x36, 0x78,
  0xF0, 0xC3, 0x8D, 0x3B, 0x00, 0x36, 0x6C, 0xF1, 0xE3, 0x87, 0x0C, 0x18,
  0xE1, 0xC0, 0x3C, 0x31, 0x8C, 0x31, 0xEF, 0x80, 0x19, 0x8C, 0x66, 0x61,
  0x8C, 0x63, 0x18, 0xFF, 0xF8, 0x38, 0xC6, 0x21, 0x8C, 0xC6, 0x67, 0x38,
  0x67, 0xF8, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 3, 5, 1, -9 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 8, 9, 10, 1, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 3, 3, 3, 1, -9 },
  { 44, 5, 11, 4, 0, -9 },
  { 51, 4, 12, 4, -1, -10 },
  { 57, 5, 6, 6, 1, -10 },
  { 61, 5, 7, 6, 1, -8 },
  { 66, 3, 4, 3, -1, -2 },
  { 68, 4, 1, 4, 0, -4 },
  { 69, 2, 2, 3, 0, -2 },
  { 70, 7, 9, 5, -1, -9 },
  { 78, 6, 9, 6, 0, -9 },
  { 85, 5, 9, 6, 1, -9 },
  { 91, 6, 9, 6, 0, -9 },
  { 98, 6, 9, 6, 0, -9 },
  { 105, 6, 9, 6, 0, -9 },
  { 112, 6, 9, 6, 0, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 7, 9, 6, 0, -9 },
  { 134, 6, 9, 6, 0, -9 },
  { 141, 6, 9, 6, 0, -9 },
  { 148, 3, 7, 3, 0, -7 },
  { 151, 4, 9, 3, -1, -7 },
  { 156, 6, 6, 6, 0, -8 },
  { 161, 5, 5, 6, 1, -7 },
  { 165, 5, 6, 6, 1, -8 },
  { 169, 5, 9, 5, 0, -9 },
  { 175, 9, 10, 9, 0, -9 },
  { 187, 7, 9, 6, -1, -9 },
  { 195, 7, 9, 6, 0, -9 },
  { 203, 7, 9, 6, 0, -9 },
  { 211, 7, 9, 7, 0, -9 },
  { 219, 6, 9, 5, 0, -9 },
  { 226, 6, 9, 5, 0, -9 },
  { 233, 7, 9, 7, 0, -9 },
  { 241, 8, 9, 7, 0, -9 },
  { 250, 6, 9, 4, -1, -9 },
  { 257, 6, 12, 3, -2, -9 },
  { 266, 8, 9, 6, 0, -9 },
  { 275, 4, 9, 5, 0, -9 },
  { 280, 10, 9, 9, 0, -9 },
  { 292, 8, 9, 8, 0, -9 },
  { 301, 7, 9, 7, 0, -9 },
  { 309, 7, 9, 6, 0, -9 },
  { 317, 7, 11, 7, 0, -9 },
  { 327, 6, 9, 6, 0, -9 },
  { 334, 6, 9, 5, 0, -9 },
  { 341, 5, 9, 5, 1, -9 },
  { 347, 7, 9, 7, 0, -9 },
  { 355, 7, 9, 6, 1, -9 },
  { 363, 10, 9, 9, 1, -9 },
  { 375, 8, 9, 6, -1, -9 },
  { 384, 6, 9, 6, 1, -9 },
  { 391, 7, 9, 5, -1, -9 },
  { 399, 6, 11, 4, -1, -9 },
  { 408, 3, 9, 5, 1, -9 },
  { 412, 5, 11, 4, -1, -9 },
  { 419, 6, 6, 6, 0, -9 },
  { 424, 5, 1, 5, -1, 1 },
  { 425, 2, 2, 4, 2, -10 },
  { 426, 6, 7, 6, 0, -7 },
  { 432, 6, 10, 6, 0, -10 },
  { 440, 5, 7, 5, 0, -7 },
  { 445, 7, 10, 6, 0, -10 },
  { 454, 6, 7, 6, 0, -7 },
  { 460, 6, 13, 4, -1, -10 },
  { 470, 6, 10, 6, 0, -7 },
  { 478, 6, 10, 6, 0, -10 },
  { 486, 4, 10, 3, 0, -10 },
  { 491, 6, 13, 3, -2, -10 },
  { 501, 7, 10, 6, 0, -10 },
  { 510, 4, 10, 3, 0, -10 },
  { 515, 9, 7, 9, 0, -7 },
  { 523, 6, 7, 6, 0, -7 },
  { 529, 6, 7, 6, 0, -7 },
  { 535, 7, 10, 6, -1, -7 },
  { 544, 6, 10, 6, 0, -7 },
  { 552, 5, 7, 4, 0, -7 },
  { 557, 5, 7, 5, 0, -7 },
  { 562, 5, 9, 4, 0, -9 },
  { 568, 6, 7, 6, 0, -7 },
  { 574, 5, 7, 6, 1, -7 },
  { 579, 8, 7, 8, 1, -7 },
  { 586, 7, 7, 6, -1, -7 },
  { 593, 7, 10, 6, -1, -7 },
  { 602, 6, 7, 5, -1, -7 },
  { 608, 5, 11, 4, 0, -9 },
  { 615, 1, 13, 5, 2, -10 },
  { 617, 5, 11, 4, -1, -9 },
  { 624, 6, 3, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC13PT7B_H_
