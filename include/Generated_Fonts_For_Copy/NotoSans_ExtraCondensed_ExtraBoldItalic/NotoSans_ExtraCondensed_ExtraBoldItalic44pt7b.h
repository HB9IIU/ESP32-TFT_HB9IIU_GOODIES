#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x3F, 0x9F, 0x9F, 0x9F, 0x8F, 0xCF, 0xC7,
  0xE7, 0xE3, 0xF3, 0xF3, 0xF1, 0xF1, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E,
  0x3E, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF1,
  0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3C,
  0x00, 0x7C, 0x78, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x01,
  0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x11, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xE3, 0xE0,
  0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xED, 0xE0, 0x7E, 0xC2,
  0x03, 0xF6, 0x00, 0x1F, 0xB0, 0x00, 0xFD, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x37, 0xE0, 0x01, 0xBF, 0x08, 0x19,
  0xF8, 0x70, 0xCF, 0x83, 0xE6, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0x00, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03, 0xC0,
  0x1F, 0xF8, 0x1F, 0x00, 0xF9, 0xF0, 0x78, 0x03, 0xC7, 0xC3, 0xE0, 0x1F,
  0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x7C, 0x01, 0xE1, 0xE3, 0xE0, 0x07, 0x8F,
  0x8F, 0x80, 0x3E, 0x3E, 0x7C, 0x00, 0xF8, 0xF9, 0xE0, 0x03, 0xE3, 0xCF,
  0x8F, 0xCF, 0x9F, 0x3C, 0x7F, 0xBF, 0xF9, 0xF3, 0xFE, 0x7F, 0xEF, 0x9F,
  0xF9, 0xFF, 0x3E, 0xF9, 0xF3, 0xF9, 0xF3, 0xE7, 0xC7, 0x87, 0xCF, 0x1F,
  0x00, 0x3E, 0x7C, 0x7C, 0x00, 0xF1, 0xF1, 0xE0, 0x07, 0xC7, 0x87, 0x80,
  0x1E, 0x1E, 0x3E, 0x00, 0xF8, 0x78, 0xF8, 0x07, 0xC3, 0xE3, 0xE0, 0x1F,
  0x0F, 0x9F, 0x00, 0xF8, 0x1E, 0x7C, 0x03, 0xE0, 0x7F, 0xE0, 0x1F, 0x01,
  0xFF, 0x00, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xF1, 0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xF3, 0xF0,
  0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x0F, 0xFE, 0x3F,
  0x1F, 0xFE, 0x7E, 0x1F, 0xFF, 0x7E, 0x3F, 0x7F, 0xFE, 0x7F, 0x3F, 0xFC,
  0x7E, 0x3F, 0xF8, 0xFE, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x1F, 0xF0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFB, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F, 0x3F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x31, 0xF0, 0x1E,
  0x7C, 0x27, 0xFF, 0x79, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xF7, 0xC0, 0xF9, 0xF8,
  0x1E, 0x7E, 0x03, 0x0F, 0x00, 0x43, 0x00, 0x00, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE0,
  0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xF0, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0,
  0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0xDF, 0xC3,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x7F, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F,
  0x1F, 0x8F, 0xC3, 0xFB, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x7D,
  0xF8, 0x79, 0xF8, 0x31, 0xF8, 0x23, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0x8F, 0xE0, 0x70, 0x7F, 0x01, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x87,
  0xF0, 0x20, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x88, 0x03, 0xF8,
  0xF0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1E, 0xFC, 0x03, 0xEF, 0xC0,
  0x7D, 0xFC, 0x07, 0x9F, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x81, 0xE1, 0xF8,
  0x3E, 0x3F, 0x87, 0xC3, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0E, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0xC0, 0x7F, 0x87, 0x87, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0xC0, 0x3F, 0x3F, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF0, 0xFE, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF9, 0xFC, 0x0F, 0xDF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xF1, 0xFC, 0x3F, 0x0F,
  0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0x1F,
  0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF3,
  0xF8, 0x7F, 0x3F, 0x8F, 0xE1, 0xFD, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFE, 0xFC, 0x07, 0xCF, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x81, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0x80, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7C, 0x00, 0x00, 0x10,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x70, 0xFE, 0x20, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x78, 0x3F, 0xE7, 0xC7,
  0xC7, 0xFF, 0x3E, 0x3C, 0x3F, 0xF8, 0xF3, 0xE3, 0xE7, 0xCF, 0x9E, 0x3E,
  0x3C, 0x7C, 0xF1, 0xE1, 0xE3, 0xCF, 0x9F, 0x1F, 0x1E, 0x78, 0xF0, 0xF8,
  0xF3, 0xC7, 0x87, 0x87, 0x9E, 0x7C, 0x3C, 0x79, 0xF3, 0xE3, 0xE3, 0xCF,
  0x1F, 0x1F, 0x1E, 0x78, 0xF8, 0xF1, 0xE3, 0xC7, 0xCF, 0x8F, 0x1E, 0x3F,
  0xFF, 0xF0, 0xF0, 0xFF, 0xFF, 0x07, 0x87, 0xF7, 0xF0, 0x3C, 0x1E, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F,
  0x80, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x3F, 0x83,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0,
  0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x86, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x04, 0x07,
  0xF9, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0xFF, 0xC1, 0xFC, 0x7F,
  0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0x87,
  0xF8, 0x7F, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFE, 0x0E, 0x0F, 0xF0, 0x08, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x87, 0xFE, 0x7F, 0x0F, 0xFC, 0xFE, 0x1F, 0xF1, 0xFC,
  0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFF, 0x8F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0x83, 0xFE, 0x7F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x47, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3,
  0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83,
  0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0xC3, 0xEF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7D, 0xF1,
  0xFF, 0xE0, 0x7E, 0xF8, 0xFB, 0xF0, 0x3F, 0x7C, 0xFD, 0xF8, 0x1F, 0xBE,
  0x7D, 0xFC, 0x0F, 0xDF, 0x7E, 0xFC, 0x07, 0xEF, 0xBE, 0x7E, 0x07, 0xE7,
  0xDF, 0x3F, 0x03, 0xF3, 0xFF, 0x3F, 0x81, 0xF9, 0xFF, 0x9F, 0x80, 0xFC,
  0xFF, 0xCF, 0xC0, 0xFC, 0x7F, 0xC7, 0xE0, 0x7E, 0x3F, 0xE3, 0xF0, 0x3F,
  0x1F, 0xE3, 0xF8, 0x1F, 0x8F, 0xF1, 0xF8, 0x0F, 0xC7, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x80,
  0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFE,
  0x07, 0xE0, 0x7F, 0xC0, 0xFC, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xF0,
  0x3F, 0xF0, 0xFE, 0x07, 0xFE, 0x1F, 0x81, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC,
  0x7E, 0x07, 0xFF, 0x8F, 0xC0, 0xFF, 0xF3, 0xF0, 0x1F, 0x7E, 0x7E, 0x07,
  0xE7, 0xCF, 0xC0, 0xFC, 0xF9, 0xF8, 0x1F, 0x9F, 0xBF, 0x03, 0xF3, 0xFF,
  0xC0, 0x7C, 0x7F, 0xF8, 0x1F, 0x8F, 0xFF, 0x03, 0xF0, 0xFF, 0xE0, 0x7E,
  0x1F, 0xFC, 0x0F, 0xC3, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x0F, 0xFC,
  0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x1F, 0xE0, 0x3F, 0x03, 0xFC, 0x0F, 0xC0,
  0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0xFE, 0x03,
  0xF3, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x03, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF7, 0xFC, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7F, 0x07,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC3,
  0xF8, 0x3F, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F,
  0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFC, 0x03,
  0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x03, 0xFC, 0xFE, 0x0F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xF7, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8,
  0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE,
  0x0F, 0xC3, 0xF8, 0x3F, 0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81,
  0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x8F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0x8F,
  0x01, 0xFC, 0x08, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x40,
  0x1F, 0xC1, 0xC0, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x81,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F,
  0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xFE,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x1F,
  0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E,
  0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC,
  0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x3F, 0xBF, 0x03, 0xF0, 0x3F, 0x9F,
  0x81, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x0F, 0xE3,
  0xF0, 0x7F, 0x07, 0xE1, 0xF8, 0x7F, 0x83, 0xF0, 0xFC, 0x3F, 0xC3, 0xF8,
  0x7E, 0x1F, 0xE1, 0xF8, 0x3F, 0x1F, 0xF1, 0xFC, 0x1F, 0x8F, 0xF8, 0xFC,
  0x0F, 0xCF, 0xFC, 0x7E, 0x07, 0xE7, 0xFE, 0x7F, 0x03, 0xF3, 0xFF, 0x3F,
  0x03, 0xFB, 0xEF, 0x9F, 0x81, 0xF9, 0xF7, 0xDF, 0xC0, 0xFD, 0xFB, 0xEF,
  0xC0, 0x7E, 0xF9, 0xFF, 0xE0, 0x3F, 0x7C, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F,
  0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0xFC, 0x1F, 0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xE7, 0xF0, 0x01,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0xE0,
  0xFE, 0xFE, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x7E,
  0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0xFD,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0xBF, 0x80, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF0,
  0xFC, 0x3E, 0x00, 0x40, 0x00, 0x3F, 0x1F, 0x07, 0xFB, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE1,
  0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC,
  0x3F, 0x8F, 0xE7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xBF, 0x07,
  0xFB, 0xE0, 0x3E, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE1, 0x00, 0x7E, 0xFC, 0x0F, 0xDF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xE7, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7F, 0x3F, 0x07, 0xF3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xBF,
  0xE0, 0xF9, 0xF8, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0x08, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x02, 0x1F, 0xC7, 0x0F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0xC3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x7F, 0xBF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8,
  0x3F, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xEF, 0x80, 0x3F, 0x3E, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xF7, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x7F,
  0x0F, 0xDF, 0x87, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x10, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xF9, 0xF0, 0x1F, 0xEF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC,
  0x3F, 0x83, 0xF1, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x80, 0x3F, 0x03, 0x01, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE1, 0x00, 0x7E, 0xFC, 0x0F, 0xDF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F,
  0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC,
  0x3F, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x87,
  0xF0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x81,
  0xFD, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x40, 0x1F, 0x3F, 0x0F, 0xC0, 0xFB, 0xFE, 0xFF, 0x83, 0xEF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFE, 0x7F, 0x9F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xE1, 0xF8, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFE, 0x1F, 0x8F, 0xC3, 0xF0, 0xFE,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x41, 0x00, 0x78,
  0xFC, 0x0F, 0x9F, 0xE0, 0xFB, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3,
  0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x7F, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xBF, 0x0F, 0xEF, 0xC3, 0xF3, 0xF9, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x01,
  0xF3, 0xF0, 0x07, 0xEF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xDF, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0x9F, 0x07, 0xFB, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE,
  0x3F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0xFC, 0x3F, 0x8F, 0xE7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0x03, 0xE7, 0xC3, 0xF7, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xE4, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x01, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFE, 0x08, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x20, 0x3F, 0x1C, 0x3F, 0x8F, 0xFF,
  0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x88, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC3,
  0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F,
  0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xBE, 0x03, 0xF3, 0xE0, 0xFC, 0x1F,
  0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x1F, 0xC3, 0xFB, 0xF0, 0xFE, 0x1F, 0x9F,
  0x8F, 0xF0, 0xFC, 0xFC, 0x7F, 0x8F, 0xC7, 0xE7, 0xFC, 0x7E, 0x3F, 0x3F,
  0xE7, 0xE1, 0xF1, 0xFF, 0x3F, 0x0F, 0x9F, 0xF9, 0xF8, 0x7C, 0xFF, 0xDF,
  0x83, 0xE7, 0xBE, 0xFC, 0x1F, 0x7D, 0xF7, 0xC0, 0xFB, 0xEF, 0x7E, 0x07,
  0xDE, 0x7B, 0xF0, 0x7F, 0xF3, 0xDF, 0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xF9,
  0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE3,
  0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x7F,
  0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xFC, 0x03, 0xF1,
  0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xF7,
  0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x2F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xA0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 31, 11, 0, -31 },
  { 52, 17, 11, 18, 4, -31 },
  { 76, 23, 31, 22, 0, -31 },
  { 166, 21, 36, 20, 0, -33 },
  { 261, 30, 32, 33, 2, -32 },
  { 381, 24, 32, 24, 0, -32 },
  { 477, 8, 11, 11, 4, -31 },
  { 488, 15, 39, 12, 1, -32 },
  { 562, 15, 39, 12, -3, -32 },
  { 636, 18, 20, 19, 3, -34 },
  { 681, 18, 21, 21, 2, -26 },
  { 729, 10, 12, 11, -2, -6 },
  { 744, 13, 6, 13, 0, -15 },
  { 754, 7, 7, 11, 0, -7 },
  { 761, 23, 32, 17, -2, -32 },
  { 853, 19, 32, 20, 1, -32 },
  { 929, 16, 31, 20, 4, -31 },
  { 991, 21, 32, 20, -1, -32 },
  { 1075, 20, 32, 20, 0, -32 },
  { 1155, 20, 32, 20, 0, -32 },
  { 1235, 21, 31, 20, 0, -31 },
  { 1317, 20, 32, 20, 1, -32 },
  { 1397, 21, 31, 20, 1, -31 },
  { 1479, 21, 32, 20, 0, -32 },
  { 1563, 20, 32, 20, 0, -32 },
  { 1643, 11, 25, 11, 0, -25 },
  { 1678, 14, 31, 11, -3, -25 },
  { 1733, 18, 21, 21, 2, -26 },
  { 1781, 18, 15, 21, 2, -23 },
  { 1815, 18, 21, 21, 2, -26 },
  { 1863, 17, 32, 16, 1, -32 },
  { 1931, 29, 35, 30, 1, -32 },
  { 2058, 22, 32, 22, -3, -32 },
  { 2146, 22, 31, 22, 0, -31 },
  { 2232, 22, 32, 20, 1, -32 },
  { 2320, 23, 31, 23, 0, -31 },
  { 2410, 20, 31, 18, 0, -31 },
  { 2488, 20, 31, 17, 0, -31 },
  { 2566, 23, 32, 24, 2, -32 },
  { 2658, 26, 31, 24, 0, -31 },
  { 2759, 20, 31, 15, -2, -31 },
  { 2837, 20, 41, 11, -7, -31 },
  { 2940, 26, 31, 21, 0, -31 },
  { 3041, 15, 31, 17, 0, -31 },
  { 3100, 33, 31, 32, 0, -31 },
  { 3228, 27, 31, 26, 0, -31 },
  { 3333, 22, 32, 25, 2, -32 },
  { 3421, 22, 31, 21, 0, -31 },
  { 3507, 22, 39, 25, 2, -32 },
  { 3615, 22, 31, 21, 0, -31 },
  { 3701, 22, 32, 19, -1, -32 },
  { 3789, 19, 31, 18, 3, -31 },
  { 3863, 23, 31, 23, 2, -31 },
  { 3953, 21, 31, 22, 4, -31 },
  { 4035, 33, 31, 32, 3, -31 },
  { 4163, 27, 31, 21, -3, -31 },
  { 4268, 20, 31, 20, 4, -31 },
  { 4346, 23, 31, 18, -2, -31 },
  { 4436, 18, 39, 13, -2, -32 },
  { 4524, 10, 32, 17, 4, -32 },
  { 4564, 18, 39, 13, -3, -32 },
  { 4652, 21, 19, 20, -1, -31 },
  { 4702, 16, 4, 15, -4, 3 },
  { 4710, 9, 7, 14, 6, -34 },
  { 4718, 20, 25, 21, 1, -25 },
  { 4781, 20, 33, 21, 0, -33 },
  { 4864, 17, 25, 17, 1, -25 },
  { 4918, 22, 33, 21, 1, -33 },
  { 5009, 18, 25, 19, 1, -25 },
  { 5066, 23, 45, 13, -5, -34 },
  { 5196, 22, 36, 21, -1, -25 },
  { 5295, 20, 33, 21, 0, -33 },
  { 5378, 13, 34, 11, 0, -34 },
  { 5434, 19, 45, 11, -6, -34 },
  { 5541, 22, 33, 20, 0, -33 },
  { 5632, 13, 33, 10, 0, -33 },
  { 5686, 30, 25, 31, 0, -25 },
  { 5780, 20, 25, 21, 0, -25 },
  { 5843, 18, 25, 20, 1, -25 },
  { 5900, 23, 36, 21, -3, -25 },
  { 6004, 20, 36, 21, 1, -25 },
  { 6094, 17, 25, 15, 0, -25 },
  { 6148, 17, 25, 16, 0, -25 },
  { 6202, 13, 29, 14, 2, -29 },
  { 6250, 20, 24, 21, 1, -24 },
  { 6310, 18, 24, 19, 3, -24 },
  { 6364, 29, 24, 28, 2, -24 },
  { 6451, 23, 24, 19, -2, -24 },
  { 6520, 24, 35, 19, -3, -24 },
  { 6625, 19, 24, 16, -2, -24 },
  { 6682, 18, 38, 15, 0, -31 },
  { 6768, 6, 44, 17, 5, -34 },
  { 6801, 18, 38, 15, -3, -31 },
  { 6887, 19, 7, 21, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC44PT7B_H_
