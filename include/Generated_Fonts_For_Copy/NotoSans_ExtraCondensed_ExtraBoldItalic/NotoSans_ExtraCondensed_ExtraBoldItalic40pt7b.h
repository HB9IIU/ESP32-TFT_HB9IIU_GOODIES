#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x7E, 0xFC,
  0xFD, 0xF9, 0xF3, 0xE3, 0xE7, 0xCF, 0xCF, 0x9F, 0xBF, 0x3E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xF1, 0xE3, 0xC3, 0xC0, 0x00, 0x3C, 0xF8, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3E, 0x78, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x9F, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xB1, 0x81, 0xF6, 0x00, 0x3E,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0D,
  0xF0, 0x81, 0x3E, 0x1C, 0x6F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x7F, 0xC0,
  0xF0, 0x0F, 0xF8, 0x3E, 0x03, 0xCF, 0x07, 0x80, 0x79, 0xE1, 0xF0, 0x1E,
  0x3C, 0x3C, 0x03, 0xC7, 0x8F, 0x80, 0x78, 0xF1, 0xE0, 0x1F, 0x3E, 0x7C,
  0x03, 0xC7, 0x8F, 0x00, 0x78, 0xF3, 0xC1, 0x0F, 0x1E, 0xF9, 0xF9, 0xE7,
  0x9E, 0x7F, 0xBF, 0xF7, 0xDF, 0xF3, 0xFC, 0xF3, 0xDF, 0x7F, 0x3E, 0xF9,
  0xE7, 0xC7, 0x9E, 0x3C, 0x01, 0xF3, 0xC7, 0x80, 0x3C, 0xF9, 0xF0, 0x0F,
  0x1E, 0x3C, 0x03, 0xE3, 0xC7, 0x80, 0x78, 0x78, 0xF0, 0x1F, 0x0F, 0x3E,
  0x03, 0xC1, 0xE7, 0x80, 0xF8, 0x3F, 0xF0, 0x1E, 0x07, 0xFC, 0x07, 0xC0,
  0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7C,
  0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0xBE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xC7, 0xFF,
  0x3E, 0x3F, 0xFD, 0xF8, 0xFF, 0xFF, 0xE7, 0xE7, 0xFF, 0x1F, 0x1F, 0xFC,
  0xFC, 0x7F, 0xE3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFD, 0xF8, 0x1F, 0xC7,
  0xF0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0x80,
  0x03, 0xE0, 0x03, 0xE0, 0x43, 0xE0, 0x73, 0xE0, 0x7B, 0xC6, 0x7F, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0,
  0x7E, 0xF8, 0x3C, 0xFC, 0x1C, 0xF8, 0x08, 0x60, 0x00, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x1F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E,
  0x1F, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xFF, 0xFC, 0x7C, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0xFC, 0x7E, 0x7E, 0x3F,
  0x1F, 0x3F, 0x0F, 0x9F, 0x8F, 0xCF, 0xC7, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB,
  0xF0, 0xFD, 0xF8, 0x7C, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F,
  0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC3, 0xE3, 0xE3, 0xF1, 0xF9, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xFC,
  0xFF, 0xF3, 0xEF, 0xC7, 0x3F, 0x08, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0x9F, 0xC0, 0xE1, 0xF8, 0x18, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xE3, 0xF0,
  0x20, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC8,
  0x07, 0xE2, 0x03, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3D, 0xF0, 0x1E, 0x7C, 0x07, 0xBF, 0x03, 0xCF, 0xC1,
  0xF3, 0xF0, 0x78, 0xF8, 0x3C, 0x7E, 0x1F, 0x1F, 0x87, 0x87, 0xE3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x20, 0x1F, 0x86, 0x07, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF3, 0x80, 0xFB, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFC, 0xFC, 0xFE, 0x3F, 0x3F, 0x8F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F,
  0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xEF, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC1, 0xF1,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFE, 0x7E, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F,
  0xCF, 0xC7, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE0,
  0xF9, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x8F,
  0xE3, 0xF8, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x3E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xE3, 0x8F, 0xC4, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x3C, 0x06, 0x0F, 0x1F, 0x1F, 0xF3, 0xC7, 0x8F, 0xFC, 0xF3,
  0xC7, 0xFF, 0x3C, 0xF1, 0xE3, 0xCF, 0x38, 0xF1, 0xE3, 0xDE, 0x3C, 0x78,
  0xF7, 0x9E, 0x1E, 0x39, 0xC7, 0x8F, 0x8E, 0xF1, 0xE3, 0xC7, 0xBC, 0x78,
  0xF1, 0xEF, 0x3E, 0x3C, 0x73, 0xCF, 0x1F, 0x3C, 0xF3, 0xE7, 0xDE, 0x3C,
  0x7F, 0xFF, 0x8F, 0x1F, 0xDF, 0xC3, 0xC3, 0xE7, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x02, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x0F, 0xBE,
  0x01, 0xFB, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE3,
  0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x3E, 0x3F,
  0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7E, 0x7F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0x1C, 0x0F, 0xE0, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0x0F, 0xE1,
  0xF8, 0x7F, 0x0F, 0xCF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xE3, 0xC0,
  0xFE, 0x02, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0xC7, 0xE1, 0xFE,
  0x1F, 0x8F, 0xF8, 0x7E, 0x3F, 0xE1, 0xF8, 0xFF, 0x8F, 0xE0, 0x7E, 0x3F,
  0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xE7,
  0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFD, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF3, 0xEF, 0x81, 0xF7, 0xCF,
  0xFE, 0x07, 0xDF, 0x3D, 0xF8, 0x1F, 0x7D, 0xF7, 0xE0, 0xFD, 0xF7, 0x9F,
  0x83, 0xF7, 0xFE, 0x7C, 0x0F, 0x9F, 0xFB, 0xF0, 0x3E, 0x7F, 0xCF, 0xC1,
  0xF9, 0xFF, 0x3F, 0x07, 0xE7, 0xF8, 0xF8, 0x1F, 0x1F, 0xE3, 0xE0, 0x7C,
  0x7F, 0x1F, 0x81, 0xF1, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F, 0x1F,
  0x87, 0xC0, 0xF8, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xC1, 0xFE, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x7F, 0x83, 0xF0, 0x3F, 0xC1,
  0xF8, 0x1F, 0xE0, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x7E, 0x07, 0xFE,
  0x3F, 0x03, 0xFF, 0x1F, 0x81, 0xFF, 0x8F, 0x81, 0xFF, 0xC7, 0xC0, 0xF9,
  0xF7, 0xE0, 0x7C, 0xFB, 0xF0, 0x3E, 0x7D, 0xF8, 0x1F, 0x3E, 0xF8, 0x1F,
  0x9F, 0x7C, 0x0F, 0xCF, 0xFE, 0x07, 0xC3, 0xFF, 0x03, 0xE1, 0xFF, 0x03,
  0xF0, 0xFF, 0x81, 0xF8, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0, 0x7C, 0x1F, 0xF0,
  0x3E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xF9, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81,
  0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF7, 0xF0, 0x1F,
  0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7F, 0x07, 0xF1, 0xF8,
  0x7F, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xE3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7F,
  0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF9, 0xFC, 0x3F,
  0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xCF,
  0xE0, 0x7E, 0x7F, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xC7, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFF, 0x07, 0xC7, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E,
  0x1F, 0x8F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0xFC,
  0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xE0,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x60, 0x3F, 0x07, 0x8F, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xE7, 0xC1,
  0xF8, 0xF8, 0x3F, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F,
  0xC1, 0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E,
  0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0xFB, 0xE0, 0x7C, 0x0F, 0xDF, 0x03,
  0xE0, 0x7E, 0xF8, 0x3F, 0x07, 0xEF, 0xC1, 0xF8, 0x3F, 0x7E, 0x0F, 0xC1,
  0xF3, 0xF0, 0xFE, 0x1F, 0x9F, 0x87, 0xF0, 0xFC, 0xFC, 0x7F, 0x87, 0xC7,
  0xE3, 0xFC, 0x7E, 0x3F, 0x1F, 0xE3, 0xF1, 0xF9, 0xFF, 0x3F, 0x0F, 0xCF,
  0xF9, 0xF8, 0x7E, 0xFF, 0xCF, 0x83, 0xF7, 0xFE, 0xFC, 0x1F, 0xBD, 0xF7,
  0xE0, 0xFB, 0xEF, 0xFE, 0x07, 0xDF, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x01,
  0xFF, 0x9F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFB,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0x9F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8,
  0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x87, 0xC3,
  0xE3, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x1F,
  0x1F, 0x07, 0xE7, 0xC3, 0xFD, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0x8F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0xBF, 0x07, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0xFE, 0x3F, 0x7F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0x7C,
  0x0F, 0x9F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xDF, 0x03,
  0xEF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F,
  0x3E, 0x0F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F,
  0xDF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFB, 0xF8, 0x3C, 0x7C, 0x00, 0x03,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xE0, 0x9F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x31, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x07, 0xE7, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F,
  0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xFC, 0x7E, 0x0F, 0xDF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0x7C, 0x03, 0xE7, 0xC0, 0x01, 0xFC, 0x07, 0xFE,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x9F, 0x3F, 0x1F, 0x7E, 0x1F, 0x7E, 0x1F,
  0x7C, 0x7F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x08, 0xFC, 0x18, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xC8, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01,
  0xBF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x3F, 0xDF, 0x03, 0xFD, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x08, 0x07, 0xE0, 0xE0, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xDF, 0x03, 0xEF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x9F,
  0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3,
  0xF3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x80, 0x01, 0xC0, 0x3E, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x80,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x17, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E,
  0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x1F, 0x7E,
  0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE7, 0xC0, 0x7C,
  0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x3F, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x0F,
  0x9F, 0x0F, 0xC1, 0xF7, 0xF3, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8,
  0x7E, 0x3F, 0x3F, 0x0F, 0x87, 0xE7, 0xE1, 0xF0, 0xF8, 0xFC, 0x7E, 0x1F,
  0x1F, 0x0F, 0xC7, 0xE3, 0xE1, 0xF0, 0xFC, 0xFC, 0x3E, 0x1F, 0x1F, 0x8F,
  0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xF3,
  0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC,
  0x7E, 0x00, 0x0F, 0x9F, 0x03, 0xEF, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3,
  0xE3, 0xF0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF1,
  0xF8, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF1, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xDF, 0x83, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xE0, 0xFD,
  0xF0, 0xFC, 0xFC, 0x7E, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x3E, 0xFE, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFB, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3E, 0xFF, 0x03, 0xE7, 0xC0, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE7, 0xC1, 0xFD, 0xF0, 0xFF, 0x7C, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xC7,
  0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07, 0xCF, 0xC1, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xFC,
  0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xBF,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F,
  0x9E, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xE3, 0xF9, 0xC7, 0xE0, 0x8F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x81,
  0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xFF, 0x9F, 0xFD, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF0, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0x87, 0xC7, 0xC3, 0xF1, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF8, 0xF8, 0x7E,
  0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F,
  0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0x7C, 0x1F, 0x9F, 0x00, 0xFC, 0x1F, 0xFE, 0x0F,
  0xDF, 0x0F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9,
  0xF8, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x3F, 0x0F, 0xDF, 0x1F,
  0xC3, 0xEF, 0xC7, 0xF1, 0xFB, 0xF1, 0xFC, 0x7C, 0xFC, 0xFF, 0x1F, 0x3F,
  0x3F, 0xCF, 0xCF, 0xCF, 0xF3, 0xE3, 0xF7, 0xBC, 0xF8, 0xFD, 0xFF, 0x7C,
  0x3F, 0xFF, 0xDF, 0x0F, 0xBD, 0xFF, 0xC3, 0xEF, 0x7F, 0xE0, 0xFF, 0xDF,
  0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x1F,
  0x81, 0xF9, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x07,
  0xE3, 0xF0, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E,
  0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x04, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x4F,
  0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xE8, 0x07,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 29, 10, 0, -29 },
  { 45, 15, 11, 17, 4, -29 },
  { 66, 21, 29, 20, 0, -29 },
  { 143, 19, 32, 18, 0, -30 },
  { 219, 27, 29, 30, 2, -29 },
  { 317, 22, 29, 22, 0, -29 },
  { 397, 7, 11, 10, 4, -29 },
  { 407, 13, 35, 11, 1, -29 },
  { 464, 14, 35, 11, -3, -29 },
  { 526, 16, 18, 17, 3, -31 },
  { 562, 16, 19, 19, 2, -24 },
  { 600, 9, 12, 10, -2, -6 },
  { 614, 11, 5, 12, 0, -13 },
  { 621, 7, 6, 10, 0, -6 },
  { 627, 21, 29, 15, -2, -29 },
  { 704, 17, 29, 18, 1, -29 },
  { 766, 14, 29, 18, 4, -29 },
  { 817, 19, 29, 18, -1, -29 },
  { 886, 18, 29, 18, 0, -29 },
  { 952, 18, 29, 18, 0, -29 },
  { 1018, 19, 29, 18, 0, -29 },
  { 1087, 18, 29, 18, 1, -29 },
  { 1153, 19, 29, 18, 1, -29 },
  { 1222, 19, 29, 18, 0, -29 },
  { 1291, 18, 29, 18, 0, -29 },
  { 1357, 10, 22, 10, 0, -22 },
  { 1385, 12, 28, 10, -2, -22 },
  { 1427, 16, 19, 19, 2, -24 },
  { 1465, 16, 13, 19, 2, -21 },
  { 1491, 17, 19, 19, 2, -24 },
  { 1532, 15, 29, 14, 1, -29 },
  { 1587, 26, 32, 27, 1, -29 },
  { 1691, 20, 29, 20, -2, -29 },
  { 1764, 20, 29, 20, 0, -29 },
  { 1837, 20, 29, 18, 1, -29 },
  { 1910, 21, 29, 21, 0, -29 },
  { 1987, 18, 29, 16, 0, -29 },
  { 2053, 18, 29, 16, 0, -29 },
  { 2119, 22, 29, 21, 1, -29 },
  { 2199, 23, 29, 22, 0, -29 },
  { 2283, 19, 29, 14, -2, -29 },
  { 2352, 18, 38, 10, -6, -29 },
  { 2438, 23, 29, 19, 0, -29 },
  { 2522, 14, 29, 16, 0, -29 },
  { 2573, 30, 29, 29, 0, -29 },
  { 2682, 25, 29, 23, 0, -29 },
  { 2773, 21, 29, 22, 1, -29 },
  { 2850, 20, 29, 19, 0, -29 },
  { 2923, 21, 36, 22, 1, -29 },
  { 3018, 20, 29, 19, 0, -29 },
  { 3091, 20, 29, 17, -1, -29 },
  { 3164, 17, 29, 16, 3, -29 },
  { 3226, 22, 29, 21, 1, -29 },
  { 3306, 19, 29, 20, 4, -29 },
  { 3375, 29, 29, 29, 3, -29 },
  { 3481, 24, 29, 19, -2, -29 },
  { 3568, 18, 29, 18, 4, -29 },
  { 3634, 21, 29, 16, -2, -29 },
  { 3711, 17, 36, 11, -2, -29 },
  { 3788, 9, 29, 15, 4, -29 },
  { 3821, 16, 36, 11, -3, -29 },
  { 3893, 18, 18, 18, 0, -29 },
  { 3934, 15, 4, 14, -4, 3 },
  { 3942, 8, 7, 13, 6, -31 },
  { 3949, 18, 22, 19, 1, -22 },
  { 3999, 18, 30, 19, 0, -30 },
  { 4067, 15, 22, 15, 1, -22 },
  { 4109, 20, 30, 19, 1, -30 },
  { 4184, 16, 22, 18, 1, -22 },
  { 4228, 21, 41, 12, -5, -31 },
  { 4336, 20, 32, 19, -1, -22 },
  { 4416, 18, 30, 19, 0, -30 },
  { 4484, 12, 31, 10, 0, -31 },
  { 4531, 17, 41, 10, -5, -31 },
  { 4619, 20, 30, 18, 0, -30 },
  { 4694, 12, 30, 9, 0, -30 },
  { 4739, 27, 22, 28, 0, -22 },
  { 4814, 18, 22, 19, 0, -22 },
  { 4864, 17, 22, 18, 1, -22 },
  { 4911, 20, 32, 19, -2, -22 },
  { 4991, 18, 32, 19, 1, -22 },
  { 5063, 15, 22, 13, 0, -22 },
  { 5105, 15, 22, 15, 0, -22 },
  { 5147, 13, 26, 13, 1, -26 },
  { 5190, 18, 22, 19, 1, -22 },
  { 5240, 17, 22, 17, 2, -22 },
  { 5287, 26, 22, 26, 2, -22 },
  { 5359, 21, 22, 17, -2, -22 },
  { 5417, 22, 32, 17, -3, -22 },
  { 5505, 18, 22, 15, -2, -22 },
  { 5555, 17, 35, 14, 0, -29 },
  { 5630, 5, 40, 15, 5, -31 },
  { 5655, 15, 35, 14, -2, -29 },
  { 5721, 18, 7, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC40PT7B_H_
