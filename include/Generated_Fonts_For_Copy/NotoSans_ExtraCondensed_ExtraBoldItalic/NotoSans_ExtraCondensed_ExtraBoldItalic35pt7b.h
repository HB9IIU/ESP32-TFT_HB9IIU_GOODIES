#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x0C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x9F,
  0x1E, 0x7C, 0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0xF3, 0xC8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1E,
  0x78, 0x03, 0x8E, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71,
  0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xEE, 0x1F, 0x64, 0x1F, 0x40,
  0x1F, 0x40, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x41, 0x7C, 0x61, 0x7C, 0x7F, 0xF8,
  0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0F, 0x80, 0xF0, 0x3F, 0x81, 0xC0, 0xFF, 0x07, 0x83, 0xCE,
  0x0E, 0x07, 0x9C, 0x3C, 0x0E, 0x38, 0xF0, 0x3C, 0x71, 0xE0, 0x79, 0xE7,
  0x80, 0xF3, 0xCF, 0x01, 0xE7, 0xBC, 0x03, 0x9E, 0x79, 0xF7, 0xBD, 0xE7,
  0xFF, 0xF3, 0x9F, 0xFF, 0xCF, 0x7B, 0xDF, 0x3C, 0xF3, 0x80, 0x7B, 0xC7,
  0x01, 0xE7, 0x9E, 0x03, 0xCF, 0x3C, 0x0F, 0x1C, 0x78, 0x1E, 0x38, 0xE0,
  0x78, 0x73, 0xC0, 0xE0, 0xE7, 0x83, 0xC1, 0xFE, 0x07, 0x03, 0xF8, 0x1E,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xEF, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x3E, 0x3F, 0xE7, 0xCF,
  0xFD, 0xF3, 0xEF, 0xFE, 0x7C, 0xFF, 0x9F, 0x1F, 0xF3, 0xE1, 0xFC, 0x7C,
  0x3F, 0x0F, 0x8F, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0x9F, 0x80, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0xF8, 0x00, 0xF8,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x8F, 0x0F, 0x78, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x0F, 0xF8, 0xFC, 0x1F, 0xF1, 0xFF, 0xC7, 0x9F, 0x18, 0xF0,
  0x46, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x1F,
  0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xDF, 0xF7, 0xF9,
  0xFE, 0xFF, 0x80, 0x19, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xF1, 0xFB, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E,
  0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F,
  0x7C, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xE7, 0xCF, 0x8F, 0xBF, 0x1F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xFC,
  0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x9F, 0xFC, 0x7B, 0xE1, 0x9F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0x79, 0xF8, 0x38,
  0xFC, 0x08, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFF, 0x07, 0x3F, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x80, 0xF8, 0xC1, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xBC, 0x07, 0x7C, 0x0F, 0x7C, 0x0E, 0x7C, 0x1C, 0x7C, 0x3C, 0xF8,
  0x78, 0xF8, 0x78, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC,
  0x18, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x80, 0xF8, 0xE3, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3D, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFC, 0xFC, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x0F, 0xBE, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x7E, 0x3F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x83, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x02, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x00, 0x00,
  0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F,
  0x80, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F,
  0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0x8F, 0x90, 0x7C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x87, 0x87, 0xC7,
  0x0E, 0x3F, 0xEF, 0x3C, 0xFF, 0x9E, 0x71, 0xCF, 0x3D, 0xE7, 0x9E, 0x73,
  0x8E, 0x3C, 0xE7, 0x3C, 0x71, 0xDE, 0x71, 0xE3, 0xBC, 0xE3, 0xCF, 0x71,
  0xC7, 0x9C, 0xE7, 0x9E, 0x39, 0xCF, 0x3C, 0xE3, 0x8F, 0xFF, 0xC7, 0x1F,
  0xBF, 0x0E, 0x1E, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x01,
  0x00, 0x7E, 0x1E, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC0, 0xF9,
  0xE0, 0x7D, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x3E, 0x3E, 0x1F, 0xFF, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0xFB, 0xF0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x9F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E,
  0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFC, 0x60, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE7,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F,
  0x9F, 0x87, 0xC7, 0xC3, 0xF1, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x04, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0x38, 0x3F,
  0x81, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF, 0x3F, 0x1F, 0xC7, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x07, 0xE3,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0x60, 0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x07,
  0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0xBF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8,
  0x07, 0xEF, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x00, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7B, 0xC1, 0xFF, 0x1F, 0xF0, 0x7B,
  0xCF, 0xFC, 0x1E, 0xF3, 0xDF, 0x0F, 0xBD, 0xF7, 0x83, 0xEF, 0x7B, 0xE0,
  0xFB, 0xDE, 0xF8, 0x3C, 0xFF, 0x3E, 0x1F, 0x3F, 0xCF, 0x87, 0xCF, 0xE7,
  0xC1, 0xF3, 0xF9, 0xF0, 0x7C, 0xFE, 0x7C, 0x1E, 0x3F, 0x1F, 0x0F, 0x8F,
  0xC7, 0xC3, 0xE3, 0xE3, 0xE0, 0xF8, 0xF8, 0xF8, 0x00, 0x07, 0xE0, 0x7C,
  0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x83, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8, 0x3F,
  0xC3, 0xC0, 0xFF, 0x1F, 0x03, 0xFC, 0x7C, 0x1F, 0xF1, 0xF0, 0x7F, 0xC7,
  0xC1, 0xFF, 0x9E, 0x07, 0xBE, 0xF8, 0x1E, 0x7B, 0xE0, 0xF9, 0xEF, 0x83,
  0xE7, 0xBE, 0x0F, 0x9F, 0xF0, 0x3C, 0x7F, 0xC1, 0xF1, 0xFF, 0x07, 0xC3,
  0xFC, 0x1F, 0x0F, 0xE0, 0x7C, 0x3F, 0x81, 0xE0, 0xFE, 0x0F, 0x83, 0xF8,
  0x3E, 0x0F, 0xE0, 0xF8, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F,
  0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3,
  0xF3, 0xF0, 0xFC, 0x7E, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xBF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0x87,
  0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xC7,
  0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xE0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFB, 0xF0, 0x3E,
  0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0x7E, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0,
  0xFC, 0xF8, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xF0, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0x83,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0xE1,
  0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87,
  0xC3, 0xF1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F,
  0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C,
  0x3E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x07, 0xDF, 0x07, 0xC1, 0xF7, 0xC1, 0xF0,
  0xF9, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x0F, 0x9F, 0x1F, 0xC7, 0xC7, 0xC7,
  0xF1, 0xF1, 0xF1, 0xFC, 0xF8, 0x7C, 0xFF, 0x3E, 0x1F, 0x3F, 0xCF, 0x87,
  0xDF, 0xE7, 0xC1, 0xF7, 0xF9, 0xF0, 0x7D, 0xFE, 0x7C, 0x1E, 0xF7, 0xBE,
  0x07, 0xBD, 0xEF, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x1F, 0xE7,
  0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xFC, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C,
  0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7D, 0xF0, 0x7D, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xBC, 0x0F, 0xBC, 0x1F,
  0x3C, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFC, 0xF9, 0xF1, 0xE3, 0xE3, 0xC0,
  0x03, 0x00, 0x0F, 0xDF, 0x1F, 0xDF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x7E,
  0x7C, 0x7E, 0x7C, 0x7E, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFE, 0xF0, 0x7C, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x98, 0x0F, 0x7E, 0x1F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C,
  0x7C, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xF7, 0xF0, 0xF3, 0xE0, 0x00, 0x80,
  0x3F, 0xC3, 0xFE, 0x3F, 0xF3, 0xFF, 0x1F, 0x09, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0x1F, 0x18,
  0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3E,
  0x0F, 0xDF, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xE7, 0xE3, 0xE3,
  0xF1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0x78, 0x1F, 0x3C, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF,
  0x3F, 0x7C, 0xF8, 0xF7, 0xC3, 0xDF, 0x1F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFE,
  0x3F, 0xE0, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x08, 0xFF, 0xE3, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0xFD, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xE7,
  0xE1, 0xF1, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7D, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x83, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x88, 0x0F, 0x7E, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0x3F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x03, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0x80, 0x80, 0x00, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0x0F, 0x0F, 0x87, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F,
  0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x3E, 0x07, 0x8F, 0x83,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x00, 0x10, 0x08, 0x0F, 0x7E,
  0x7E, 0x1F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x3F,
  0x3F, 0x1F, 0x3F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x78, 0x78, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x10, 0x0F, 0x7E, 0x1E,
  0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0x00,
  0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0xF9, 0xF7, 0xC3, 0xDF,
  0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xEF,
  0x8F, 0xBE, 0x7E, 0xFF, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x00, 0x06,
  0x00, 0xF7, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFB, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x01, 0x00, 0x0F, 0xDF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E,
  0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7D, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x0C, 0x3D,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x80, 0x3F, 0xE1,
  0xFF, 0xC7, 0xFE, 0x3F, 0x70, 0xF8, 0x43, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x30, 0xF8,
  0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xC0, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7F, 0x8F, 0xF0,
  0xFE, 0x1F, 0xC0, 0x1F, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8,
  0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFE, 0xF0, 0x7C, 0xF0, 0xF8, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xE1, 0xF7, 0x81,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x9F,
  0xC7, 0xBE, 0x7F, 0x3E, 0xF9, 0xFC, 0xF3, 0xEF, 0xF7, 0xCF, 0xBF, 0xDF,
  0x3E, 0xEF, 0x78, 0xFF, 0xBF, 0xE3, 0xDE, 0xEF, 0x0F, 0x73, 0xBC, 0x3F,
  0xDF, 0xF0, 0xFF, 0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC7,
  0xE0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0,
  0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xE1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x3E, 0x01, 0xE7,
  0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x81,
  0xFE, 0x07, 0xE0, 0x1E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF8,
  0x1F, 0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x08, 0x00,
  0x00, 0x7F, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x06,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 11, 25, 9, 0, -25 },
  { 36, 14, 9, 15, 3, -25 },
  { 52, 19, 25, 18, 0, -25 },
  { 112, 16, 29, 16, 0, -27 },
  { 170, 23, 25, 26, 2, -25 },
  { 242, 19, 25, 19, 0, -25 },
  { 302, 7, 9, 9, 3, -25 },
  { 310, 13, 31, 10, 0, -25 },
  { 361, 12, 32, 10, -3, -26 },
  { 409, 13, 15, 15, 3, -27 },
  { 434, 15, 17, 17, 1, -21 },
  { 466, 8, 10, 9, -2, -5 },
  { 476, 10, 5, 10, 0, -12 },
  { 483, 6, 6, 9, 0, -6 },
  { 488, 19, 25, 13, -2, -25 },
  { 548, 15, 25, 16, 1, -25 },
  { 595, 13, 25, 16, 3, -25 },
  { 636, 17, 25, 16, -1, -25 },
  { 690, 16, 25, 16, 0, -25 },
  { 740, 16, 25, 16, 0, -25 },
  { 790, 16, 25, 16, 0, -25 },
  { 840, 16, 25, 16, 1, -25 },
  { 890, 17, 25, 16, 1, -25 },
  { 944, 16, 25, 16, 0, -25 },
  { 994, 16, 25, 16, 0, -25 },
  { 1044, 9, 20, 9, 0, -20 },
  { 1067, 11, 25, 9, -2, -20 },
  { 1102, 15, 17, 17, 1, -21 },
  { 1134, 15, 11, 17, 1, -18 },
  { 1155, 15, 17, 17, 1, -21 },
  { 1187, 13, 25, 12, 1, -25 },
  { 1228, 23, 28, 24, 1, -25 },
  { 1309, 17, 25, 17, -2, -25 },
  { 1363, 18, 25, 17, 0, -25 },
  { 1420, 17, 25, 16, 1, -25 },
  { 1474, 18, 25, 18, 0, -25 },
  { 1531, 16, 25, 14, 0, -25 },
  { 1581, 16, 25, 14, 0, -25 },
  { 1631, 19, 25, 19, 1, -25 },
  { 1691, 20, 25, 19, 0, -25 },
  { 1754, 16, 25, 12, -1, -25 },
  { 1804, 15, 33, 9, -5, -25 },
  { 1866, 20, 25, 17, 0, -25 },
  { 1929, 12, 25, 14, 0, -25 },
  { 1967, 26, 25, 25, 0, -25 },
  { 2049, 22, 25, 20, 0, -25 },
  { 2118, 18, 25, 20, 1, -25 },
  { 2175, 18, 25, 16, 0, -25 },
  { 2232, 18, 31, 20, 1, -25 },
  { 2302, 17, 25, 17, 0, -25 },
  { 2356, 18, 25, 15, -1, -25 },
  { 2413, 14, 25, 14, 3, -25 },
  { 2457, 19, 25, 19, 1, -25 },
  { 2517, 17, 25, 17, 3, -25 },
  { 2571, 26, 25, 25, 2, -25 },
  { 2653, 21, 25, 16, -2, -25 },
  { 2719, 16, 25, 16, 3, -25 },
  { 2769, 18, 25, 14, -1, -25 },
  { 2826, 15, 31, 10, -2, -25 },
  { 2885, 8, 25, 13, 3, -25 },
  { 2910, 15, 31, 10, -3, -25 },
  { 2969, 16, 16, 16, 0, -25 },
  { 3001, 13, 3, 12, -3, 3 },
  { 3006, 7, 6, 11, 5, -27 },
  { 3012, 16, 20, 17, 1, -20 },
  { 3052, 16, 27, 17, 0, -27 },
  { 3106, 13, 20, 13, 1, -20 },
  { 3139, 17, 27, 17, 1, -27 },
  { 3197, 14, 20, 15, 1, -20 },
  { 3232, 18, 35, 10, -4, -27 },
  { 3311, 18, 28, 17, -1, -20 },
  { 3374, 16, 27, 17, 0, -27 },
  { 3428, 10, 27, 8, 0, -27 },
  { 3462, 14, 35, 8, -4, -27 },
  { 3524, 18, 27, 16, 0, -27 },
  { 3585, 10, 27, 8, 0, -27 },
  { 3619, 24, 20, 24, 0, -20 },
  { 3679, 16, 20, 17, 0, -20 },
  { 3719, 14, 20, 16, 1, -20 },
  { 3754, 18, 28, 17, -2, -20 },
  { 3817, 16, 28, 17, 1, -20 },
  { 3873, 14, 20, 12, 0, -20 },
  { 3908, 14, 20, 13, 0, -20 },
  { 3943, 11, 23, 11, 1, -23 },
  { 3975, 16, 19, 16, 1, -19 },
  { 4013, 15, 19, 15, 2, -19 },
  { 4049, 22, 19, 23, 2, -19 },
  { 4102, 19, 19, 15, -2, -19 },
  { 4148, 19, 27, 15, -2, -19 },
  { 4213, 15, 19, 13, -1, -19 },
  { 4249, 14, 31, 12, 0, -25 },
  { 4304, 5, 35, 13, 4, -27 },
  { 4326, 14, 31, 12, -2, -25 },
  { 4381, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC35PT7B_H_
