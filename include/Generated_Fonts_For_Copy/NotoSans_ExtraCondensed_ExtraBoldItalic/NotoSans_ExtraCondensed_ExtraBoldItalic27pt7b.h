#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0xFB, 0xFC, 0xEF, 0x7B,
  0xDE, 0xE7, 0x39, 0xCE, 0x70, 0x03, 0x9C, 0x0E, 0x60, 0x33, 0x81, 0xCE,
  0x07, 0x30, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x0E, 0xE0, 0x73, 0x81, 0xCE,
  0x3F, 0xFE, 0xFF, 0xF3, 0xFF, 0xC3, 0x98, 0x0C, 0xE0, 0x73, 0x81, 0xCC,
  0x0E, 0x70, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x70, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF8, 0x74, 0x87, 0xA0, 0x3D, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x1F, 0x88, 0xBC, 0x77, 0xC7, 0xFE, 0x3F, 0xE0, 0x7C, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x04, 0x00, 0x07, 0xC1, 0xC3, 0xF0, 0xE0,
  0xEE, 0x38, 0x73, 0x9C, 0x1C, 0xE7, 0x07, 0x73, 0x81, 0x9C, 0xC0, 0xE7,
  0x73, 0xBB, 0xB9, 0xF7, 0xEE, 0xFD, 0xF7, 0x73, 0x11, 0xDC, 0xC0, 0xE7,
  0x70, 0x3B, 0x9C, 0x1C, 0xE7, 0x07, 0x39, 0xC3, 0x8F, 0xE1, 0xC1, 0xF0,
  0x70, 0x78, 0x00, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xE7, 0x81,
  0xCE, 0x03, 0xBC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x79, 0xFD,
  0xE7, 0xBF, 0xDE, 0x7F, 0x3C, 0xFE, 0x78, 0xF8, 0xF3, 0xF1, 0xFF, 0xE1,
  0xFF, 0xE1, 0xF3, 0xC0, 0xFF, 0xBD, 0xEE, 0x73, 0x80, 0x03, 0xC1, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x01, 0xE0, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x83, 0x83, 0xC1, 0xC1, 0xE1, 0xE0, 0x0E, 0x01, 0xE1, 0x38, 0x37, 0x1F,
  0xFD, 0xFF, 0x87, 0xF9, 0xF0, 0x7F, 0x1E, 0xF0, 0xCE, 0x11, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x38, 0xF1, 0xE3, 0x8F, 0x1C, 0x78,
  0x7F, 0x7E, 0xFE, 0xFE, 0x77, 0xFD, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x01, 0x01, 0xF8, 0x7F, 0x8F, 0xF3,
  0xDE, 0x71, 0xDE, 0x7B, 0xCF, 0x71, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x3D,
  0xE7, 0xB8, 0xF7, 0x3C, 0xF7, 0x9F, 0xE3, 0xF8, 0x3E, 0x00, 0x03, 0xC1,
  0xF0, 0xF8, 0xFE, 0x7F, 0xBF, 0xE7, 0x78, 0xBC, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0x00, 0x80,
  0x1F, 0x83, 0xFE, 0x3F, 0xF0, 0xE7, 0x84, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x7F, 0xE3, 0xFF, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x80, 0xFE, 0x1F, 0xF1,
  0xFF, 0x08, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0xF8, 0x1F, 0x81,
  0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0xC7, 0xCF, 0xFC, 0xFF, 0x8F,
  0xE0, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x6E, 0x0F, 0xE1,
  0xDE, 0x1D, 0xE3, 0x9C, 0x73, 0xC7, 0x3C, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF2, 0x0F, 0x18, 0xF8, 0xFF, 0x87, 0xFC, 0x3F,
  0x80, 0x00, 0x60, 0x3F, 0x0F, 0xF0, 0xFE, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0xB0, 0x7F, 0xCF, 0xFC, 0xFF, 0xCF, 0xBC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF7, 0x8F, 0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x80, 0x3F, 0x03, 0xFC, 0x3F, 0xE1, 0xE7, 0x8E, 0x38,
  0x73, 0xC3, 0xDE, 0x1F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x87, 0x9E, 0x38,
  0xF3, 0xC7, 0x9E, 0x3C, 0xF3, 0xC7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x00,
  0x80, 0x7E, 0x0F, 0xF1, 0xFF, 0x3E, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x38,
  0xF3, 0xDF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x8F,
  0x8F, 0xF8, 0xFF, 0x0F, 0xC0, 0x1C, 0x3C, 0xF9, 0xE0, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x8F, 0x9E, 0x3C, 0x00, 0x07, 0x03, 0xC3, 0xE1, 0xE0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xC1, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x3C, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xF9,
  0xF8, 0x3E, 0x07, 0xF0, 0x3F, 0xC0, 0xFC, 0x07, 0x80, 0x30, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xC0, 0x0F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0xFE,
  0x3F, 0x8F, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x04, 0x0F, 0xE7, 0xFD,
  0xFF, 0x23, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x20, 0x00,
  0xFE, 0x01, 0xFF, 0xC1, 0xE0, 0xE1, 0xC0, 0x39, 0xC2, 0x1C, 0xE7, 0xE6,
  0xE7, 0xF3, 0x77, 0x39, 0xF3, 0x9D, 0xF9, 0x8C, 0xFD, 0xCE, 0x7C, 0xE7,
  0x36, 0x73, 0xBB, 0x3B, 0xF9, 0x9F, 0xF8, 0xC7, 0x38, 0x70, 0x00, 0x38,
  0x00, 0x0F, 0x0C, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0xBC,
  0x3C, 0xF0, 0xF3, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0x0F,
  0x7C, 0x3D, 0xE0, 0xFF, 0x83, 0xC0, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7,
  0x9F, 0x1E, 0x3C, 0x79, 0xE1, 0xC7, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0xF8, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xE2,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF9, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0x9F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0xDE, 0x1E, 0x78, 0x79,
  0xE3, 0xC7, 0x9F, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC7, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x0F,
  0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x08, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE7, 0xEF, 0x9F, 0xBC, 0x7C, 0xF2, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF9, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x0F, 0x0F, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0xF0,
  0xFF, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0x1F, 0x0F, 0x3E, 0x1E, 0x3C, 0x1E,
  0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7B, 0xC0, 0x79, 0xE0, 0x79, 0xE0, 0x79,
  0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xF0, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF9,
  0xFE, 0x3F, 0x9D, 0xC3, 0xF9, 0xFC, 0x3B, 0xBB, 0xC7, 0xBB, 0xBC, 0x7B,
  0xFB, 0xC7, 0xBF, 0x38, 0x7B, 0xF7, 0x87, 0x3E, 0x78, 0xF3, 0xE7, 0x8F,
  0x3C, 0x78, 0xF3, 0xCF, 0x00, 0x0F, 0x07, 0x87, 0xC3, 0x87, 0xE3, 0xC3,
  0xF1, 0xE1, 0xF8, 0xF0, 0xFC, 0x70, 0x7F, 0x38, 0x7F, 0xBC, 0x3F, 0xDE,
  0x1E, 0xEF, 0x0E, 0x77, 0x0F, 0x3B, 0x87, 0x9F, 0xC3, 0xCF, 0xE1, 0xE7,
  0xF0, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x00, 0x00, 0x80,
  0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3E, 0x7C, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F,
  0x78, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F,
  0x3C, 0x7C, 0xFB, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x87, 0x9F, 0x1E, 0x7C, 0x79, 0xF1, 0xE7, 0x8F, 0x1E, 0x3C,
  0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xC0, 0xFF,
  0x87, 0xFE, 0x3E, 0x7C, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0x78, 0x3F, 0xE1,
  0xFF, 0x87, 0xFC, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F, 0x3C, 0x7C, 0xFB,
  0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x7F, 0xC7, 0xFE, 0x3C, 0xF1, 0xE7, 0x8F,
  0x3C, 0x71, 0xE7, 0x9F, 0x3F, 0xF1, 0xFF, 0x8F, 0xF0, 0xFF, 0x87, 0xBC,
  0x3D, 0xE1, 0xEF, 0x8F, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x7C, 0x00, 0x40,
  0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0x10, 0x7C, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x10, 0x78, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0xF9, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7,
  0x8F, 0x1E, 0x3E, 0xF8, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0xF0, 0x7F,
  0xC1, 0xEF, 0x0F, 0x1C, 0x3C, 0x70, 0xF1, 0xC7, 0x87, 0x1E, 0x1C, 0xF0,
  0x73, 0xC1, 0xCE, 0x07, 0x78, 0x1D, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0xFF, 0x0F,
  0x1E, 0xF1, 0xF1, 0xEF, 0x1F, 0x3C, 0xF1, 0xF3, 0xCF, 0x3F, 0x3C, 0xF3,
  0xF7, 0x8F, 0x7F, 0x78, 0xF7, 0xE7, 0x8F, 0x7E, 0xF0, 0xFE, 0xEF, 0x0F,
  0xEE, 0xE0, 0xFE, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x00, 0x07, 0x8F, 0x83, 0xCF,
  0x81, 0xE7, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0xF0, 0x3C, 0x3C, 0x3E, 0x1E,
  0x00, 0xF8, 0xFB, 0xC7, 0x9E, 0x78, 0xF3, 0xC7, 0xBC, 0x3D, 0xC1, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xFC, 0x3F, 0xF1,
  0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xF8,
  0x3F, 0x07, 0xE0, 0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1C,
  0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8F, 0x07, 0xE0, 0xFC, 0x1F, 0x84, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0xF8,
  0x3F, 0x07, 0xE0, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0xE0, 0xFE,
  0x1E, 0xE3, 0xCE, 0x38, 0xE7, 0x8F, 0x70, 0x7E, 0x07, 0x7F, 0xDF, 0xFF,
  0xFC, 0xF7, 0x9E, 0x73, 0x80, 0x0F, 0x38, 0xFF, 0xC7, 0xFE, 0x7D, 0xE3,
  0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x79, 0xE7, 0x8F, 0x3C, 0x79, 0xF7,
  0xC7, 0xFC, 0x3E, 0xE0, 0xE7, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0x3F, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF,
  0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xEF, 0x9E, 0xFF, 0xCE, 0xFC,
  0xEF, 0x00, 0x0F, 0x87, 0xF3, 0xF9, 0xF2, 0x78, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC8, 0xFE, 0x3F, 0x87, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0xF7, 0x87, 0xFE, 0x1F,
  0xF8, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x8E, 0x3C,
  0x78, 0xF1, 0xE3, 0xEF, 0x87, 0xFC, 0x1F, 0xF0, 0x3D, 0xC0, 0x0F, 0x83,
  0xF8, 0xFF, 0xBC, 0xF7, 0x1F, 0xE7, 0xBF, 0xF7, 0xFC, 0xFC, 0x1C, 0x03,
  0x80, 0x70, 0x4F, 0xF1, 0xFE, 0x1F, 0xC0, 0x00, 0x38, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0x03, 0xFC, 0x0F, 0xF0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x9C, 0x3F, 0xF0, 0xFF,
  0xC7, 0x9E, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1F, 0x7C, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x78, 0x01,
  0xE2, 0x0F, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0x3F, 0xF3, 0xEF, 0x3C,
  0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xE7, 0x9E, 0x79, 0xEF, 0x1E, 0xF1,
  0xEF, 0x3C, 0xF3, 0xC0, 0x06, 0x0F, 0x1F, 0x0E, 0x04, 0x00, 0x1E, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xF0, 0x00, 0xC0, 0x3C, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x00, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xFC, 0x1F,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE7, 0xC7, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xFC, 0x0E, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7B, 0xC3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF0, 0xF1, 0xE0, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xF0, 0x1D, 0xE7, 0x87, 0xFF, 0xF3, 0xFF, 0xFC, 0xFB, 0xEF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0x8F, 0x3D, 0xE3, 0x8F, 0x79, 0xE3, 0x9E, 0x79, 0xE7,
  0x1E, 0x7B, 0xC7, 0x1E, 0xF1, 0xC7, 0xBC, 0xF1, 0xCF, 0x3C, 0xF0, 0x1D,
  0xE1, 0xFF, 0x3F, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x78,
  0xE7, 0x9E, 0x71, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xC0, 0x0F, 0x83,
  0xF8, 0xFF, 0x3C, 0xF7, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7B,
  0x8F, 0x7B, 0xEF, 0xF9, 0xFE, 0x1F, 0x80, 0x07, 0x78, 0x1F, 0xF0, 0xFF,
  0xC3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE7, 0x8F, 0x9E, 0x3F, 0xF0, 0xFF, 0xC3, 0xDE, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x38, 0xFF, 0xC7,
  0xFE, 0x79, 0xE3, 0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xE7, 0x8F,
  0x3C, 0x79, 0xF7, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x1D, 0xC7, 0xF3, 0xFC, 0xFE,
  0x3E, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x00, 0x0F, 0x8F, 0xF3, 0xFC, 0xF2, 0x78, 0x0F, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7A, 0x3E, 0xFF, 0x3F, 0xCF, 0xE0, 0x0E, 0x1C, 0x1C,
  0x3F, 0x7F, 0xFF, 0x38, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFC, 0xFC, 0x7C, 0x3C, 0xF3, 0x8F, 0x78, 0xE7, 0x9E, 0x79, 0xE7, 0x1E,
  0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x7C, 0xFF, 0x8F, 0xF8,
  0xFB, 0x80, 0xE1, 0xFC, 0x7B, 0x8F, 0x71, 0xCE, 0x79, 0xCF, 0x3B, 0xC7,
  0x78, 0xEE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x71,
  0xE3, 0xDC, 0x78, 0xE7, 0x3E, 0x79, 0xCF, 0x9C, 0x77, 0xEF, 0x1D, 0xFB,
  0xC7, 0x7E, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC, 0x3F, 0xBF, 0x0F, 0xCF, 0xC3,
  0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x8F, 0x00, 0x1E, 0x7C, 0x79,
  0xE1, 0xEF, 0x03, 0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1, 0xE7, 0x8F, 0x1E, 0x00,
  0x0E, 0x1E, 0x1C, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0xF7, 0x81, 0xEF, 0x03,
  0xFC, 0x07, 0xF8, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0x8F,
  0xF8, 0xFF, 0x80, 0x01, 0xE0, 0xFC, 0x1F, 0x83, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x38, 0x0F, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0xF0, 0x3F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0xF7,
  0xFF, 0xFC, 0xFF, 0x81, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 10, 7, 11, 3, -19 },
  { 29, 14, 19, 14, 0, -19 },
  { 63, 13, 23, 12, 0, -21 },
  { 101, 18, 20, 20, 1, -20 },
  { 146, 15, 20, 15, 0, -20 },
  { 184, 5, 7, 7, 3, -19 },
  { 189, 10, 24, 7, 0, -20 },
  { 219, 9, 24, 7, -2, -20 },
  { 246, 11, 12, 11, 2, -21 },
  { 263, 11, 13, 13, 1, -16 },
  { 281, 7, 8, 7, -2, -4 },
  { 288, 8, 4, 8, 0, -9 },
  { 292, 5, 4, 7, 0, -4 },
  { 295, 14, 20, 10, -1, -20 },
  { 330, 11, 20, 12, 1, -20 },
  { 358, 10, 19, 12, 2, -19 },
  { 382, 13, 20, 12, -1, -20 },
  { 415, 12, 20, 12, 0, -20 },
  { 445, 12, 19, 12, 0, -19 },
  { 474, 13, 19, 12, 0, -19 },
  { 505, 12, 20, 12, 1, -20 },
  { 535, 13, 19, 12, 1, -19 },
  { 566, 13, 20, 12, 0, -20 },
  { 599, 12, 20, 12, 0, -20 },
  { 629, 7, 15, 7, 0, -15 },
  { 643, 9, 19, 7, -2, -15 },
  { 665, 11, 13, 13, 1, -16 },
  { 683, 11, 9, 13, 1, -14 },
  { 696, 12, 13, 13, 1, -16 },
  { 716, 10, 20, 10, 1, -20 },
  { 741, 17, 22, 18, 1, -20 },
  { 788, 14, 19, 13, -2, -19 },
  { 822, 14, 19, 13, 0, -19 },
  { 856, 13, 20, 12, 1, -20 },
  { 889, 14, 19, 14, 0, -19 },
  { 923, 12, 19, 11, 0, -19 },
  { 952, 12, 19, 11, 0, -19 },
  { 981, 14, 20, 14, 1, -20 },
  { 1016, 16, 19, 15, 0, -19 },
  { 1054, 12, 19, 9, -1, -19 },
  { 1083, 12, 25, 7, -4, -19 },
  { 1121, 16, 19, 13, 0, -19 },
  { 1159, 9, 19, 11, 0, -19 },
  { 1181, 20, 19, 19, 0, -19 },
  { 1229, 17, 19, 16, 0, -19 },
  { 1270, 14, 20, 15, 1, -20 },
  { 1305, 14, 19, 13, 0, -19 },
  { 1339, 14, 25, 15, 1, -20 },
  { 1383, 13, 19, 13, 0, -19 },
  { 1414, 14, 20, 11, -1, -20 },
  { 1449, 11, 19, 11, 2, -19 },
  { 1476, 14, 19, 14, 1, -19 },
  { 1510, 14, 19, 13, 2, -19 },
  { 1544, 20, 19, 19, 2, -19 },
  { 1592, 17, 19, 13, -2, -19 },
  { 1633, 13, 19, 12, 2, -19 },
  { 1664, 14, 19, 11, -1, -19 },
  { 1698, 11, 24, 8, -1, -20 },
  { 1731, 6, 20, 10, 3, -20 },
  { 1746, 11, 24, 8, -2, -20 },
  { 1779, 12, 12, 12, 0, -19 },
  { 1797, 10, 3, 10, -3, 2 },
  { 1801, 5, 5, 8, 4, -21 },
  { 1805, 13, 15, 13, 0, -15 },
  { 1830, 12, 21, 13, 0, -21 },
  { 1862, 10, 15, 10, 1, -15 },
  { 1881, 14, 21, 13, 0, -21 },
  { 1918, 11, 15, 12, 1, -15 },
  { 1939, 14, 27, 8, -3, -21 },
  { 1987, 14, 21, 13, -1, -15 },
  { 2024, 12, 21, 13, 0, -21 },
  { 2056, 8, 21, 6, 0, -21 },
  { 2077, 11, 27, 6, -3, -21 },
  { 2115, 14, 21, 12, 0, -21 },
  { 2152, 8, 21, 6, 0, -21 },
  { 2173, 18, 15, 19, 0, -15 },
  { 2207, 12, 15, 13, 0, -15 },
  { 2230, 11, 15, 12, 1, -15 },
  { 2251, 14, 21, 13, -2, -15 },
  { 2288, 13, 21, 13, 0, -15 },
  { 2323, 10, 15, 9, 0, -15 },
  { 2342, 10, 15, 10, 0, -15 },
  { 2361, 8, 18, 9, 1, -18 },
  { 2379, 12, 15, 13, 1, -15 },
  { 2402, 11, 15, 12, 2, -15 },
  { 2423, 18, 15, 17, 1, -15 },
  { 2457, 14, 15, 12, -1, -15 },
  { 2484, 15, 21, 12, -2, -15 },
  { 2524, 12, 15, 10, -1, -15 },
  { 2547, 11, 23, 9, 0, -19 },
  { 2579, 4, 27, 10, 3, -21 },
  { 2593, 11, 23, 9, -2, -19 },
  { 2625, 12, 5, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC27PT7B_H_
