#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0x7C, 0x3E, 0x1F, 0x0F,
  0x00, 0x79, 0xEF, 0x7D, 0xEF, 0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xE0, 0x01,
  0xCE, 0x01, 0xCE, 0x03, 0x9E, 0x03, 0x9C, 0x03, 0x9C, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x0F, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x39, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x73,
  0xC0, 0x73, 0x80, 0x73, 0x80, 0x00, 0x60, 0x01, 0x00, 0x0E, 0x01, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE1, 0xEB, 0x87, 0xA0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xBC, 0x42, 0xF1, 0x8B,
  0xC7, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x0E, 0x00, 0x03, 0xF0, 0x78, 0x3F, 0x07, 0x07, 0xF8, 0xF0, 0x73,
  0x8E, 0x0E, 0x79, 0xC0, 0xE7, 0x1C, 0x0E, 0x73, 0x80, 0xE7, 0x78, 0x0E,
  0xF7, 0x3C, 0xEE, 0xF7, 0xEF, 0xEE, 0xFE, 0xFD, 0xEE, 0xF3, 0x1D, 0xEF,
  0x03, 0x9C, 0xE0, 0x39, 0xCE, 0x07, 0x1C, 0xE0, 0xF1, 0xCE, 0x0E, 0x1D,
  0xC1, 0xE1, 0xFC, 0x1C, 0x1F, 0x83, 0xC0, 0xF0, 0x00, 0xE0, 0x01, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF3, 0xE3, 0xF9, 0xE3, 0xFE, 0xF3,
  0xFF, 0xF1, 0xE7, 0xF9, 0xF3, 0xF8, 0xF1, 0xFC, 0x78, 0x7C, 0x3E, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xF9, 0xF0, 0x7B, 0xDF, 0xEF, 0x7B, 0xC0,
  0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x00,
  0x07, 0x80, 0x78, 0x47, 0x07, 0x71, 0x7F, 0xFF, 0xFF, 0x3F, 0xF1, 0xF0,
  0x3F, 0x87, 0xFC, 0x7B, 0xC3, 0x1E, 0x11, 0x00, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x3C, 0xF9,
  0xE3, 0xCF, 0x1E, 0x78, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x33, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x3F,
  0x03, 0xFC, 0x3F, 0xE1, 0xEF, 0x1E, 0x7C, 0xF3, 0xEF, 0x9F, 0x78, 0xF3,
  0xC7, 0xBE, 0x3D, 0xF1, 0xEF, 0x1F, 0x78, 0xFB, 0xC7, 0x9E, 0x3C, 0xF3,
  0xE7, 0x9E, 0x3F, 0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xC3, 0xF1,
  0xFC, 0xFE, 0x7F, 0xBF, 0xEF, 0x79, 0xBE, 0x4F, 0x03, 0xC0, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x00,
  0x00, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xF3, 0xE0, 0x87, 0xC1,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x3F, 0xE1, 0xFF, 0x83,
  0xFF, 0x0C, 0x7C, 0x21, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF2,
  0x07, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xBC, 0x0E,
  0xF0, 0x73, 0xC3, 0x9F, 0x0E, 0x78, 0x71, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFC, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xFC,
  0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x04, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x83, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x00,
  0x78, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x7B, 0xC3, 0xFF, 0x1F, 0xF9, 0xFF, 0xEF, 0x9F, 0x7C, 0xFB, 0xC7, 0xDE,
  0x3C, 0xF1, 0xE7, 0x9F, 0x3F, 0xF1, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x1F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE7,
  0xC7, 0x9E, 0x1F, 0xF8, 0x3F, 0xC0, 0xFC, 0x07, 0xF8, 0x3F, 0xE1, 0xF7,
  0xC7, 0x8F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x9E, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFE, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x1F, 0x78,
  0xF9, 0xF3, 0xE7, 0xCF, 0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x8F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xC0, 0xCF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x8F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x06, 0x1E, 0x1F, 0x1E, 0x1E, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x01,
  0x81, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3,
  0xF8, 0x1F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0x80,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xF8, 0xFF, 0x1F, 0xE1, 0xF8, 0x0F,
  0x00, 0x60, 0x00, 0x07, 0x03, 0xF9, 0xFF, 0x9F, 0xF3, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x70, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xC1, 0xE0, 0xE0, 0x1E, 0x38, 0x01,
  0xCF, 0x1F, 0xB9, 0xCF, 0xF7, 0x71, 0xDC, 0xEE, 0x73, 0x9D, 0xDE, 0x73,
  0xF3, 0x8E, 0x7E, 0x73, 0xCF, 0xCE, 0x73, 0xB9, 0xCE, 0x77, 0x3B, 0xDC,
  0xE7, 0xFF, 0x9C, 0xFB, 0xE3, 0x84, 0x30, 0x70, 0x00, 0x0F, 0x00, 0x80,
  0xF8, 0x70, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x7C, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0xC1, 0xFF, 0x03,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x79, 0xF1, 0xF1, 0xE3, 0xE3,
  0xC7, 0x8F, 0x8F, 0x1E, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3,
  0xC7, 0x8F, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xF9, 0x87, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x43, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x3F, 0x1F, 0x1F, 0x1E,
  0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C,
  0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0xFC, 0x79, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x1F, 0x8E, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x02, 0x78, 0xFC, 0xF8, 0xFC, 0xF9, 0xFC, 0xF9, 0xFC, 0xF8,
  0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xE1, 0xF1,
  0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x3E, 0x1F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8,
  0x78, 0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x80,
  0x0F, 0xFC, 0x3F, 0xE0, 0x7E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x17, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x0C, 0x00, 0x0F, 0x8F, 0x87, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0xC1, 0xF7,
  0xC0, 0xFB, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xF3, 0xE0,
  0x79, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x1F, 0x1F, 0x0F, 0x0F, 0x80, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E,
  0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3,
  0xFC, 0x1F, 0xC7, 0x78, 0x7B, 0x9F, 0xE0, 0xF7, 0x3B, 0xC1, 0xEE, 0xF7,
  0x83, 0xDD, 0xEF, 0x0F, 0xBF, 0xBE, 0x1E, 0x7F, 0x78, 0x3C, 0xFC, 0xF0,
  0x79, 0xF9, 0xE0, 0xF3, 0xE3, 0xC3, 0xE7, 0xCF, 0x87, 0x8F, 0x1E, 0x0F,
  0x1E, 0x3C, 0x00, 0x0F, 0x83, 0xE1, 0xF8, 0x78, 0x3F, 0x0F, 0x07, 0xE1,
  0xE1, 0xFC, 0x7C, 0x3F, 0x8F, 0x07, 0xF1, 0xE0, 0xFF, 0x3C, 0x1D, 0xE7,
  0x87, 0xBD, 0xE0, 0xF7, 0xBC, 0x1E, 0xF7, 0x83, 0xCF, 0xF0, 0xF9, 0xFE,
  0x1E, 0x3F, 0x83, 0xC7, 0xF0, 0x78, 0xFE, 0x0F, 0x0F, 0xC3, 0xC1, 0xF8,
  0x78, 0x3E, 0x0F, 0x07, 0xC0, 0x00, 0xE0, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x78, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7B, 0xF1, 0xF3, 0xE3, 0xE3,
  0xC7, 0x8F, 0x8F, 0x1F, 0x1E, 0x3C, 0x7C, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7B, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F,
  0x8F, 0x1E, 0x1E, 0x7C, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x0F,
  0xBC, 0x1F, 0x78, 0x3C, 0xF8, 0x79, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7,
  0xCF, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFD,
  0xC1, 0xE0, 0x87, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x40, 0xF0, 0xC3,
  0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFB, 0xFF,
  0x9F, 0xFD, 0xFF, 0xE0, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x1E, 0x1F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C,
  0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8, 0x78,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xF0, 0xF3, 0xC7,
  0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x7C, 0x3D, 0xE0, 0xF7,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x00, 0x78, 0x78, 0x3D, 0xE1, 0xE1, 0xF7, 0x87, 0x87, 0x9E,
  0x3E, 0x3E, 0x78, 0xF8, 0xF1, 0xE7, 0xE3, 0xCF, 0x9F, 0x9F, 0x3E, 0x7E,
  0x78, 0xFB, 0xF9, 0xE3, 0xEF, 0xEF, 0x0F, 0x7F, 0xBC, 0x3D, 0xFF, 0xF0,
  0xF7, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C,
  0x00, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xDE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3D,
  0xE0, 0x1F, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x00, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xF3, 0xCF, 0xBE, 0x3D, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0xF1, 0xE3, 0xC7,
  0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x0F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE1, 0xC3, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0x9C,
  0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9C, 0x1E, 0xF0, 0x3C, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xF9, 0xE3, 0xCF, 0x1C, 0x03, 0x02, 0x1F, 0x78, 0x7F, 0xF0,
  0xFF, 0xE3, 0xE7, 0xC7, 0x8F, 0x1F, 0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xF1,
  0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0,
  0x3C, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE7, 0x07, 0xBE, 0x1F, 0xF8, 0x7F, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C,
  0x7C, 0xF1, 0xF3, 0xC7, 0x9E, 0x1E, 0x78, 0xF9, 0xE3, 0xE7, 0x8F, 0x3F,
  0x7C, 0xFF, 0xE3, 0xFF, 0x0E, 0x78, 0x00, 0x03, 0xC1, 0xFC, 0x7F, 0x9F,
  0xE7, 0xC4, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x09, 0xF6, 0x3F, 0xC7, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x03, 0x3E, 0x0F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0x78, 0xF0, 0xF8, 0xF0, 0xF9, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7E, 0xE0, 0x3C, 0xE0, 0x03, 0x80, 0xFE, 0x1F, 0xF3, 0xFF, 0x7C,
  0xF7, 0x8F, 0xF9, 0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x0C, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1E, 0x00, 0x00, 0x01, 0xC1, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1F, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C,
  0x3C, 0x78, 0x7C, 0x78, 0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0,
  0x1E, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x81, 0xE0, 0xE7, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xE6, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xE7, 0xCF,
  0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x3E, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x1E, 0x00, 0x07, 0x07, 0xC3,
  0xE1, 0xE0, 0x60, 0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1,
  0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC0, 0x00,
  0x70, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x8F, 0x1E, 0x1E, 0x7C, 0x3D, 0xF0, 0xF3, 0xC1, 0xEF, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xE7, 0x87,
  0xCF, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x00, 0x0F, 0x87, 0xC3, 0xC1,
  0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1, 0xE0,
  0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC0, 0x02, 0x70,
  0xE1, 0xDF, 0xBF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3E, 0x7C, 0xF3, 0xE7,
  0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x7C, 0xF9, 0xF7, 0xCF, 0x1E, 0x78,
  0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xEF, 0x9F, 0x3C, 0xF1, 0xE3, 0xCF,
  0x1E, 0x3C, 0xF1, 0xE3, 0xC0, 0x00, 0x60, 0x77, 0xE1, 0xDF, 0x87, 0xFF,
  0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x1F, 0x3C, 0x78, 0xF1, 0xE0, 0x07,
  0x80, 0xFE, 0x3F, 0xE3, 0xFF, 0x7C, 0xF7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0x1E, 0xF3, 0xEF, 0xFC, 0xFF, 0xC7, 0xF8, 0x3F,
  0x00, 0x00, 0x18, 0x07, 0xBE, 0x07, 0x7E, 0x07, 0xFF, 0x0F, 0x9F, 0x0F,
  0x9F, 0x0F, 0x1F, 0x0F, 0x1F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3E, 0x1E, 0x3C, 0x3F, 0x7C, 0x3F, 0xF8, 0x3F, 0xF8, 0x3D, 0xE0, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x3F, 0x71, 0xFF, 0xC7, 0xFF, 0x3E, 0x7C, 0xF1, 0xE7,
  0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE3, 0xE7, 0x8F, 0x3E, 0x3C, 0xF9, 0xF3,
  0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x3D, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x71, 0xEE, 0x1D, 0xE1,
  0xFE, 0x3F, 0xC3, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xFF,
  0x3F, 0xE3, 0xFE, 0x3C, 0x43, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7C, 0x87, 0xCE, 0xF8, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x0F,
  0x07, 0x03, 0x83, 0xC7, 0xFB, 0xFF, 0xFE, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xFA, 0x7F, 0x3F, 0x8F, 0xC0, 0x3C, 0x79,
  0xE3, 0xCF, 0x1E, 0xF1, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xDF, 0x1E, 0xF1,
  0xF7, 0x8F, 0x3C, 0x79, 0xE7, 0xCF, 0xFE, 0x7F, 0xE3, 0xF7, 0x0F, 0x38,
  0xF0, 0xFF, 0x1F, 0xF1, 0xEF, 0x3E, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0x78,
  0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF1, 0xF3, 0xFE, 0x7E, 0x7B, 0xCF, 0xCF, 0x7B, 0xFB, 0xCF, 0x7E, 0x79,
  0xEF, 0xCE, 0x3F, 0xFB, 0xC7, 0xF7, 0x78, 0xEE, 0xFE, 0x1F, 0xDF, 0xC3,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0x8F, 0x80, 0x0F, 0x9F, 0x07, 0x9E, 0x07, 0xBC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0xF8, 0x0F, 0x0F,
  0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x87,
  0xFC, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x3F, 0x07, 0xE0, 0x78, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x3E, 0x07, 0xE0,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF8, 0x0E, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x1F,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 11, 7, 13, 3, -21 },
  { 35, 16, 21, 15, 0, -21 },
  { 77, 14, 25, 13, 0, -23 },
  { 121, 20, 22, 22, 2, -22 },
  { 176, 17, 22, 17, 0, -22 },
  { 223, 5, 7, 7, 3, -21 },
  { 228, 11, 27, 8, 0, -22 },
  { 266, 10, 27, 8, -2, -22 },
  { 300, 12, 13, 13, 2, -23 },
  { 320, 13, 15, 14, 1, -18 },
  { 345, 7, 8, 7, -2, -4 },
  { 352, 9, 4, 9, 0, -10 },
  { 357, 5, 5, 7, 0, -5 },
  { 361, 16, 22, 12, -2, -22 },
  { 405, 13, 22, 13, 1, -22 },
  { 441, 10, 21, 14, 3, -21 },
  { 468, 15, 22, 13, -1, -22 },
  { 510, 14, 22, 13, 0, -22 },
  { 549, 14, 21, 14, 0, -21 },
  { 586, 14, 21, 13, 0, -21 },
  { 623, 13, 22, 13, 1, -22 },
  { 659, 14, 21, 13, 1, -21 },
  { 696, 14, 22, 13, 0, -22 },
  { 735, 14, 22, 13, 0, -22 },
  { 774, 8, 17, 8, 0, -17 },
  { 791, 10, 21, 8, -2, -17 },
  { 818, 13, 14, 14, 1, -18 },
  { 841, 13, 9, 14, 1, -15 },
  { 856, 13, 14, 14, 1, -18 },
  { 879, 11, 22, 11, 1, -22 },
  { 910, 19, 24, 20, 1, -22 },
  { 967, 15, 22, 15, -2, -22 },
  { 1009, 15, 21, 15, 0, -21 },
  { 1049, 15, 22, 14, 1, -22 },
  { 1091, 16, 21, 16, 0, -21 },
  { 1133, 14, 21, 12, 0, -21 },
  { 1170, 14, 21, 12, 0, -21 },
  { 1207, 16, 22, 16, 1, -22 },
  { 1251, 17, 21, 16, 0, -21 },
  { 1296, 14, 21, 10, -1, -21 },
  { 1333, 14, 28, 8, -5, -21 },
  { 1382, 17, 21, 15, 0, -21 },
  { 1427, 10, 21, 12, 0, -21 },
  { 1454, 23, 21, 22, 0, -21 },
  { 1515, 19, 21, 17, 0, -21 },
  { 1565, 16, 22, 17, 1, -22 },
  { 1609, 15, 21, 14, 0, -21 },
  { 1649, 16, 27, 17, 1, -22 },
  { 1703, 15, 21, 14, 0, -21 },
  { 1743, 15, 22, 13, -1, -22 },
  { 1785, 13, 21, 12, 2, -21 },
  { 1820, 16, 21, 16, 1, -21 },
  { 1862, 14, 21, 15, 3, -21 },
  { 1899, 22, 21, 22, 2, -21 },
  { 1957, 18, 21, 14, -2, -21 },
  { 2005, 13, 21, 14, 3, -21 },
  { 2040, 15, 21, 12, -1, -21 },
  { 2080, 12, 27, 9, -1, -22 },
  { 2121, 7, 22, 12, 3, -22 },
  { 2141, 12, 27, 9, -2, -22 },
  { 2182, 14, 13, 13, 0, -21 },
  { 2205, 11, 3, 11, -3, 2 },
  { 2210, 6, 5, 9, 4, -23 },
  { 2214, 15, 17, 14, 0, -17 },
  { 2246, 14, 23, 14, 0, -23 },
  { 2287, 11, 17, 11, 1, -17 },
  { 2311, 16, 23, 14, 0, -23 },
  { 2357, 12, 17, 13, 1, -17 },
  { 2383, 15, 30, 9, -3, -23 },
  { 2440, 16, 24, 14, -1, -17 },
  { 2488, 14, 23, 14, 0, -23 },
  { 2529, 9, 23, 7, 0, -23 },
  { 2555, 13, 30, 7, -4, -23 },
  { 2604, 15, 23, 14, 0, -23 },
  { 2648, 9, 23, 7, 0, -23 },
  { 2674, 20, 17, 21, 0, -17 },
  { 2717, 14, 17, 14, 0, -17 },
  { 2747, 12, 17, 14, 1, -17 },
  { 2773, 16, 24, 14, -2, -17 },
  { 2821, 14, 24, 14, 0, -17 },
  { 2863, 12, 17, 10, 0, -17 },
  { 2889, 12, 17, 11, 0, -17 },
  { 2915, 9, 20, 9, 1, -20 },
  { 2938, 13, 16, 14, 1, -16 },
  { 2964, 12, 16, 13, 2, -16 },
  { 2988, 19, 16, 19, 2, -16 },
  { 3026, 16, 16, 13, -2, -16 },
  { 3058, 16, 23, 13, -2, -16 },
  { 3104, 13, 16, 11, -1, -16 },
  { 3130, 12, 26, 10, 0, -21 },
  { 3169, 3, 30, 11, 4, -23 },
  { 3181, 12, 26, 10, -2, -21 },
  { 3220, 13, 5, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC30PT7B_H_
