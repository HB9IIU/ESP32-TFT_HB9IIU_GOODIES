#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x3E, 0x7E, 0x7C, 0xF9, 0xF9, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0xF0, 0x00, 0x79, 0xE0, 0x0F, 0x1C, 0x00,
  0xF3, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x81,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x78, 0xE0,
  0x07, 0x9E, 0x00, 0x71, 0xE0, 0x0F, 0x1C, 0x07, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0x4E, 0x0F, 0x22, 0x0F, 0xB0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x6F, 0x88, 0x37, 0xC6, 0x1B, 0xE3, 0x8B, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x07, 0x80, 0x04, 0x07, 0xE0, 0x3C, 0x07, 0xF8, 0x3E,
  0x07, 0xFC, 0x1E, 0x03, 0xDE, 0x1E, 0x03, 0xCF, 0x0F, 0x01, 0xE7, 0x8F,
  0x00, 0xE3, 0xC7, 0x80, 0xF1, 0xE7, 0x80, 0x78, 0xF3, 0xC0, 0x3C, 0xF3,
  0xC0, 0x1E, 0x7B, 0xE7, 0xCF, 0x7D, 0xE7, 0xF7, 0xFD, 0xE7, 0xFB, 0xFC,
  0xF7, 0xFE, 0xFC, 0xF3, 0xCF, 0x1C, 0x7B, 0xC7, 0x80, 0x79, 0xE3, 0xC0,
  0x3C, 0xF1, 0xC0, 0x3C, 0x79, 0xE0, 0x1E, 0x3C, 0xF0, 0x1E, 0x1C, 0x78,
  0x1E, 0x0E, 0x78, 0x0F, 0x07, 0xBC, 0x0F, 0x03, 0xFC, 0x07, 0x81, 0xFC,
  0x07, 0x80, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x87, 0xF8, 0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0x7C, 0x7E, 0xFB,
  0xE3, 0xE7, 0xFE, 0x1F, 0x3F, 0xF1, 0xF8, 0xFF, 0x0F, 0x87, 0xF8, 0x7C,
  0x1F, 0x83, 0xF3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x7E,
  0x0F, 0xE3, 0xF0, 0x7D, 0xFF, 0xFE, 0xFB, 0xEF, 0xBC, 0xF0, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0,
  0x0F, 0x04, 0x3C, 0x18, 0xF0, 0x7B, 0x8F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x0F, 0xFC, 0x7F, 0x03, 0xFE, 0x3F, 0x78, 0x7D, 0xF0, 0xE3, 0xE1, 0x0E,
  0x00, 0x20, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00,
  0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xEF, 0xF8, 0x39, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x3F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0xFC, 0x3E, 0xFC, 0x7E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC,
  0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF9,
  0xFF, 0xDF, 0xBE, 0x7B, 0xF1, 0x9F, 0x08, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xC1, 0xE3, 0xF0, 0x30,
  0xFC, 0x08, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x30, 0xFC, 0x10,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC4, 0x07, 0xE3, 0xCF, 0xF1, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xDF, 0x01, 0xCF, 0x81, 0xEF, 0xC1, 0xE7, 0xC0,
  0xE3, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x88, 0x0F,
  0xC7, 0x9F, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E,
  0x7E, 0x3F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF7,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7E, 0x3F, 0x3F, 0x1F,
  0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xF1, 0xF1, 0xFF, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0xFC, 0x7E, 0x7E, 0x3E, 0x3F,
  0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xF3, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0x9F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC3, 0x1F, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0x07, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C,
  0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0x00, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x1F,
  0xF0, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x01,
  0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0x63,
  0xF2, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFC, 0xFC, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x1E,
  0x0F, 0x8F, 0x1E, 0x3F, 0xEF, 0x3C, 0x7F, 0xCF, 0x3C, 0xF3, 0xCF, 0x78,
  0xE3, 0xCF, 0x79, 0xE3, 0xCF, 0x71, 0xC3, 0x8E, 0x73, 0xC7, 0x8E, 0xF3,
  0xC7, 0x8E, 0xF3, 0xC7, 0x9E, 0xF3, 0xCF, 0x1C, 0xE3, 0xCF, 0x3C, 0xE3,
  0xDF, 0x78, 0xE3, 0xFF, 0xF0, 0xE1, 0xF3, 0xF0, 0xF0, 0xE1, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0x00, 0x7E, 0x1F, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xC1, 0xF3, 0xE0, 0x7D,
  0xF8, 0x1F, 0x7E, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xDF, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF8,
  0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x82,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xFE,
  0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9,
  0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7,
  0xE7, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x0C, 0x1F, 0xC0, 0x41,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x3F, 0xC7, 0xE3, 0xFC, 0x7C, 0x7F, 0xC7, 0xC7, 0xF8, 0xFC, 0x7F,
  0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x07, 0xE1,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x81, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x81,
  0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x0F,
  0xC0, 0x7C, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F,
  0x9F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F,
  0x80, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7,
  0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xEF, 0x81,
  0xFF, 0xBE, 0xF8, 0x3E, 0xFB, 0xDF, 0x83, 0xEF, 0xFD, 0xF0, 0x3E, 0xFF,
  0x9F, 0x03, 0xE7, 0xF9, 0xF0, 0x7E, 0x7F, 0x9F, 0x07, 0xC7, 0xF3, 0xF0,
  0x7C, 0x7F, 0x3E, 0x07, 0xC7, 0xE3, 0xE0, 0x7C, 0x7E, 0x3E, 0x0F, 0x87,
  0xC3, 0xE0, 0xF8, 0x7C, 0x7E, 0x0F, 0x87, 0x87, 0xC0, 0x07, 0xF0, 0x3E,
  0x0F, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x3F, 0x83, 0xE0, 0xFF, 0x07, 0xC1,
  0xFE, 0x0F, 0x83, 0xFE, 0x3E, 0x07, 0xFC, 0x7C, 0x0F, 0xF8, 0xF8, 0x3F,
  0xF1, 0xF0, 0x7D, 0xE7, 0xE0, 0xFB, 0xEF, 0x81, 0xF7, 0xDF, 0x03, 0xEF,
  0xBE, 0x0F, 0x9F, 0x7C, 0x1F, 0x3E, 0xF0, 0x3E, 0x3F, 0xE0, 0x7C, 0x7F,
  0xC1, 0xF0, 0xFF, 0x83, 0xE1, 0xFF, 0x07, 0xC3, 0xFC, 0x0F, 0x87, 0xF8,
  0x1F, 0x07, 0xF0, 0x7C, 0x0F, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFC, 0x7E, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xF0,
  0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x1F, 0x87, 0xC3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0xFE, 0x1F, 0x8F, 0xC3, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x8F,
  0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC,
  0x7E, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xF0, 0x3E, 0x3E,
  0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0x7D, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F,
  0xBF, 0x07, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xC7,
  0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xCF, 0x03, 0xF0,
  0x40, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x04, 0x07, 0xE0, 0xE0, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xE1, 0xF0, 0x7C, 0x3F, 0x07,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0x87, 0xE0,
  0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF1,
  0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x7D, 0xF8,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7B, 0xE0, 0x1E, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x83, 0xF7, 0xC0, 0xF8,
  0x3E, 0x7C, 0x1F, 0x87, 0xE7, 0xC1, 0xF8, 0x7C, 0x7C, 0x3F, 0x87, 0xC7,
  0xC3, 0xF8, 0xFC, 0x7C, 0x3F, 0x8F, 0x87, 0xC7, 0xF8, 0xF8, 0x7C, 0x7F,
  0x9F, 0x87, 0xCF, 0xF9, 0xF0, 0x7C, 0xFF, 0x3F, 0x07, 0xCF, 0xF3, 0xE0,
  0x7D, 0xFF, 0x3E, 0x07, 0xDE, 0xF7, 0xE0, 0x7F, 0xEF, 0x7C, 0x07, 0xFE,
  0xF7, 0xC0, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0xFC,
  0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0xC0, 0x1F, 0x9F, 0x00, 0x7C,
  0x7C, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0xBE, 0x1F, 0x9F, 0x0F, 0xCF, 0x8F, 0xC7, 0xC7, 0xC3,
  0xE7, 0xE1, 0xF3, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x80, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x1F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xBE, 0x07, 0xCF, 0x07, 0xC7, 0x87, 0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9,
  0xE0, 0x3D, 0xF0, 0x1F, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x7E,
  0x3E, 0x3E, 0x1F, 0x0F, 0x01, 0x80, 0x07, 0xE7, 0xC7, 0xFB, 0xE3, 0xFF,
  0xE3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E,
  0x1F, 0x3F, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF1,
  0xF1, 0xF8, 0xF9, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x38, 0x0F, 0xBE, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x3F, 0x3E,
  0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xCF, 0xC3, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1,
  0xF9, 0xF8, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x1E, 0x7C,
  0x00, 0x00, 0xE0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF8, 0xFC, 0x47,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x08, 0xFC, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1C, 0x7C, 0x0F, 0xEF, 0x81,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xCF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7C, 0x00, 0x00, 0x60, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF7, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE, 0x1F,
  0x7C, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x11, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xE4, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x5F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x7C, 0x0F, 0xEF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x9F, 0x87, 0xE3, 0xF0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3F, 0x7F, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xDF, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x80, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x18, 0x0F, 0xBF,
  0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC,
  0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x1F, 0x80, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x7C, 0x7E,
  0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0, 0xF8, 0xFC, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x0C, 0x0E, 0x07,
  0xBF, 0x9F, 0x83, 0xFF, 0xDF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFC, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x7E, 0x3E, 0x1F, 0x3E, 0x1F, 0x1F,
  0x9F, 0x0F, 0x8F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC7, 0xC3, 0xE7, 0xE3, 0xE1,
  0xF3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C,
  0x3E, 0x7E, 0x3E, 0x3F, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x8F,
  0x87, 0xC0, 0x00, 0x08, 0x07, 0x9F, 0x83, 0xDF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC7, 0xE7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x7E, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC0, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xDF, 0x8F,
  0xBE, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF,
  0x0F, 0xBE, 0x1F, 0x7C, 0x7E, 0xFD, 0xF9, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x79, 0xF8, 0x0F, 0x7F, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xCF, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x87,
  0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F,
  0x87, 0xC3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0x7F, 0x03, 0xEF, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x03, 0xF7, 0xC3, 0xFB, 0xE3, 0xFF, 0xE3,
  0xFF, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F,
  0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1,
  0xF8, 0xFD, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xDF, 0x07, 0xCF, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0x3C, 0xF0, 0xF7,
  0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x1F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0xFC, 0x23, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x20, 0xFC,
  0xE3, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x81, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xE3, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x7F, 0x80, 0x1F,
  0x1F, 0x8F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF9,
  0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x8F,
  0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xDF, 0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x79, 0xF0, 0x79, 0xF0,
  0x7B, 0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x7E,
  0x3F, 0xF8, 0xFE, 0x3E, 0xF8, 0xFE, 0x3E, 0xF8, 0xFE, 0x7C, 0xF9, 0xFE,
  0x7C, 0xF9, 0xFE, 0xF8, 0xFB, 0xFE, 0xF8, 0xFB, 0xFC, 0xF8, 0xFB, 0xFD,
  0xF0, 0xFF, 0xBD, 0xF0, 0xFF, 0xBD, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC7,
  0xF0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E,
  0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x08, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x01, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x3F,
  0x01, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0x7E,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 11, 26, 9, 0, -26 },
  { 37, 15, 9, 16, 3, -26 },
  { 54, 20, 26, 19, 0, -26 },
  { 119, 17, 30, 17, 0, -28 },
  { 183, 25, 27, 28, 2, -27 },
  { 268, 21, 27, 21, 0, -27 },
  { 339, 6, 9, 9, 4, -26 },
  { 346, 13, 33, 10, 0, -27 },
  { 400, 13, 33, 10, -3, -27 },
  { 454, 14, 16, 16, 3, -28 },
  { 482, 15, 18, 18, 2, -22 },
  { 516, 9, 10, 9, -2, -5 },
  { 528, 11, 5, 11, 0, -12 },
  { 535, 6, 6, 9, 0, -6 },
  { 540, 20, 27, 14, -2, -27 },
  { 608, 16, 27, 17, 1, -27 },
  { 662, 13, 26, 17, 3, -26 },
  { 705, 18, 27, 17, -1, -27 },
  { 766, 17, 27, 17, 0, -27 },
  { 824, 17, 26, 17, 0, -26 },
  { 880, 17, 26, 17, 0, -26 },
  { 936, 17, 27, 17, 1, -27 },
  { 994, 18, 26, 17, 1, -26 },
  { 1053, 17, 27, 17, 0, -27 },
  { 1111, 17, 27, 17, 0, -27 },
  { 1169, 9, 21, 9, 0, -21 },
  { 1193, 11, 26, 9, -2, -21 },
  { 1229, 16, 18, 18, 1, -22 },
  { 1265, 15, 12, 18, 2, -19 },
  { 1288, 15, 18, 18, 2, -22 },
  { 1322, 14, 27, 13, 1, -27 },
  { 1370, 24, 30, 25, 1, -27 },
  { 1460, 18, 27, 18, -2, -27 },
  { 1521, 19, 26, 18, 0, -26 },
  { 1583, 18, 27, 17, 1, -27 },
  { 1644, 19, 26, 20, 0, -26 },
  { 1706, 17, 26, 15, 0, -26 },
  { 1762, 17, 26, 15, 0, -26 },
  { 1818, 20, 27, 20, 1, -27 },
  { 1886, 22, 26, 20, 0, -26 },
  { 1958, 16, 26, 13, -1, -26 },
  { 2010, 17, 34, 10, -6, -26 },
  { 2083, 22, 26, 18, 0, -26 },
  { 2155, 13, 26, 15, 0, -26 },
  { 2198, 28, 26, 27, 0, -26 },
  { 2289, 23, 26, 22, 0, -26 },
  { 2364, 20, 27, 21, 1, -27 },
  { 2432, 19, 26, 17, 0, -26 },
  { 2494, 20, 33, 21, 1, -27 },
  { 2577, 18, 26, 18, 0, -26 },
  { 2636, 19, 27, 16, -1, -27 },
  { 2701, 15, 26, 15, 3, -26 },
  { 2750, 20, 26, 20, 1, -26 },
  { 2815, 18, 26, 18, 3, -26 },
  { 2874, 28, 26, 27, 2, -26 },
  { 2965, 22, 26, 17, -2, -26 },
  { 3037, 17, 26, 17, 3, -26 },
  { 3093, 19, 26, 15, -1, -26 },
  { 3155, 15, 33, 11, -2, -27 },
  { 3217, 8, 27, 14, 4, -27 },
  { 3244, 15, 33, 11, -3, -27 },
  { 3306, 17, 16, 17, 0, -26 },
  { 3340, 14, 3, 13, -4, 3 },
  { 3346, 8, 6, 12, 5, -28 },
  { 3352, 17, 21, 18, 1, -21 },
  { 3397, 17, 28, 17, 0, -28 },
  { 3457, 14, 21, 14, 1, -21 },
  { 3494, 19, 28, 18, 1, -28 },
  { 3561, 15, 21, 16, 1, -21 },
  { 3601, 19, 37, 11, -4, -28 },
  { 3689, 19, 30, 18, -1, -21 },
  { 3761, 17, 28, 18, 0, -28 },
  { 3821, 11, 28, 9, 0, -28 },
  { 3860, 16, 37, 9, -5, -28 },
  { 3934, 19, 28, 17, 0, -28 },
  { 4001, 11, 28, 9, 0, -28 },
  { 4040, 25, 21, 26, 0, -21 },
  { 4106, 17, 21, 18, 0, -21 },
  { 4151, 15, 21, 17, 1, -21 },
  { 4191, 19, 30, 17, -2, -21 },
  { 4263, 17, 30, 17, 1, -21 },
  { 4327, 14, 21, 12, 0, -21 },
  { 4364, 14, 21, 14, 0, -21 },
  { 4401, 12, 25, 12, 1, -25 },
  { 4439, 17, 20, 17, 1, -20 },
  { 4482, 16, 20, 16, 2, -20 },
  { 4522, 24, 20, 24, 2, -20 },
  { 4582, 20, 20, 16, -2, -20 },
  { 4632, 21, 29, 16, -3, -20 },
  { 4709, 16, 20, 13, -1, -20 },
  { 4749, 15, 32, 13, 0, -26 },
  { 4809, 4, 36, 14, 5, -28 },
  { 4827, 14, 32, 13, -2, -26 },
  { 4883, 16, 6, 18, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC37PT7B_H_
