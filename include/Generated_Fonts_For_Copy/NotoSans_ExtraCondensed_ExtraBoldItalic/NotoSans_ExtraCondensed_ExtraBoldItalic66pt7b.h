#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xFC,
  0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xF8, 0x7F,
  0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x04, 0x1F, 0xC3, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xEE, 0x3E, 0x00, 0xFF, 0x9C, 0x18, 0x01, 0xFF, 0x38, 0x10, 0x03,
  0xFC, 0x70, 0x00, 0x07, 0xFC, 0xC0, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0x7F, 0xE0, 0x00, 0x0E, 0x7F, 0xC0, 0x00, 0x1C, 0xFF,
  0x81, 0x00, 0x39, 0xFE, 0x03, 0x80, 0x73, 0xFC, 0x07, 0x81, 0xCF, 0xF8,
  0x0F, 0xC3, 0xBF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF1,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0xFE,
  0x00, 0x00, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xFC, 0x3F, 0x0F, 0xE7, 0xF8, 0xFF, 0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xC7, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F,
  0xF8, 0xFE, 0x3F, 0x87, 0xE1, 0xFF, 0x07, 0xF1, 0xFC, 0x3F, 0x83, 0xE0,
  0x7F, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x0F, 0xC0, 0x00, 0x3F,
  0x87, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x87,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x20, 0x1F, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F,
  0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xFC, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F,
  0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0x80,
  0x7F, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x08, 0x0F, 0xF0, 0x03, 0x83, 0xFC, 0x00, 0xF0, 0xFE, 0x00, 0x3F,
  0x3F, 0x81, 0x9F, 0xFF, 0xE3, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0x80,
  0xFF, 0x1F, 0xF0, 0x1F, 0xC3, 0xFE, 0x03, 0xE0, 0xFE, 0x00, 0x70, 0x3F,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x07, 0x03, 0xF8, 0xFF, 0xBF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF1, 0xFC, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x03, 0xFF,
  0x3F, 0xF0, 0x3F, 0xF3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE,
  0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F,
  0xE7, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F,
  0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x8F,
  0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F, 0xCF, 0xF8, 0x3F,
  0x3F, 0xF0, 0x3C, 0x7F, 0xE0, 0x30, 0xFF, 0x80, 0x41, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x3E, 0x03,
  0xFF, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x38, 0x03, 0xFF, 0x00, 0x10, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0xFC, 0x00, 0xC0, 0x1F, 0xF8,
  0x01, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x10, 0x00, 0x1F, 0xF8, 0x38, 0x00, 0x7F, 0xF0,
  0x7C, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFD, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x7F, 0x3F,
  0xE0, 0x00, 0xFC, 0xFF, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x0F, 0xE3, 0xFE,
  0x00, 0x1F, 0x87, 0xFC, 0x00, 0x7F, 0x1F, 0xF8, 0x01, 0xFC, 0x3F, 0xE0,
  0x03, 0xF8, 0x7F, 0xC0, 0x0F, 0xE0, 0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x00,
  0x7F, 0x07, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0C, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x80, 0x03, 0xFF,
  0x03, 0x00, 0x1F, 0xFC, 0x0F, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE3,
  0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF,
  0x83, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFF, 0x83, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0x80, 0x1F, 0xE7, 0xFE, 0x00, 0x1E, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x20, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0x01, 0xFF, 0x0C, 0x01, 0xFF, 0x08, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0xE0, 0x0F, 0xC0, 0xFE, 0x03, 0xFF, 0x83,
  0xF0, 0x7F, 0x03, 0xFF, 0xF8, 0xFC, 0x1F, 0x81, 0xFF, 0xFE, 0x3F, 0x0F,
  0xE0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0x7F, 0xFF, 0xC3, 0xF1, 0xFC, 0x3F,
  0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0x83, 0xF3, 0xF0, 0xFE, 0x0F, 0xE0, 0xFD,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0xDF, 0x87,
  0xF0, 0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0xC1, 0xFB, 0xF8, 0x7E, 0x07,
  0xF0, 0x7E, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F,
  0xCF, 0xC3, 0xF8, 0x3F, 0x83, 0xF3, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0xFC,
  0x3F, 0x87, 0xF8, 0x7E, 0x3F, 0x0F, 0xE1, 0xFE, 0x3F, 0x0F, 0xC3, 0xFC,
  0xFF, 0x9F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0x8F, 0xFC, 0x03,
  0xF0, 0x1F, 0xC1, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x78, 0x03, 0xFF,
  0xC0, 0x10, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x06, 0x00, 0x7F, 0xF8, 0x3E, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x03, 0xE0, 0x07, 0xFF, 0x80, 0x1C, 0x01, 0xFF, 0xE0, 0x00, 0x80, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x63, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x80,
  0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE3,
  0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00,
  0x1F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7,
  0xF8, 0x3F, 0xFF, 0xF0, 0x07, 0xFD, 0xFE, 0x1F, 0xEF, 0xF8, 0x01, 0xFF,
  0x7F, 0x87, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xE1, 0xFE, 0xFF, 0x80, 0x1F,
  0xF7, 0xF8, 0xFF, 0x7F, 0xE0, 0x07, 0xFD, 0xFE, 0x3F, 0xDF, 0xF0, 0x03,
  0xFE, 0x7F, 0x9F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xE7, 0xF9, 0xFF, 0x00,
  0x3F, 0xE7, 0xFB, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0xFF, 0x3F, 0xF0,
  0x07, 0xFC, 0x7F, 0xBF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xFF, 0xE3, 0xFE,
  0x00, 0x7F, 0xC7, 0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0xFC, 0x7F,
  0xE0, 0x07, 0xFC, 0x7F, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xC0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFF,
  0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xBF, 0xE1, 0xFF, 0x00,
  0x7F, 0xCF, 0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x80, 0x1F, 0xF3,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x9F,
  0xF0, 0x07, 0xFC, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0x1F, 0xEF, 0xF8, 0x01,
  0xFF, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x87, 0xFB, 0xFE, 0x00, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x1F,
  0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF9,
  0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF3,
  0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xC0, 0x78,
  0x01, 0xFF, 0x80, 0x10, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x20, 0x00, 0xFF, 0xC0, 0x70, 0x01, 0xFF, 0xC0,
  0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0x9F, 0xEF, 0xF3, 0xFE, 0x00, 0x7F, 0xCF,
  0xF7, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF3, 0xFD, 0xFF, 0x80, 0x1F, 0xF7,
  0xF9, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x7F, 0x7F, 0xC0, 0x03, 0xFF, 0xFE, 0x3F, 0xBF, 0xE0, 0x01, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03,
  0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF,
  0x87, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x81,
  0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xE7, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x8F,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1,
  0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0x03, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFD,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xF7, 0xFC, 0x00, 0xFF, 0xC7,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0,
  0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xC0,
  0x3F, 0xCF, 0xFF, 0x00, 0x7F, 0x9F, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x1E, 0x03, 0xFF, 0x80,
  0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xC0, 0xFF,
  0xE0, 0x70, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0,
  0x03, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0xF3, 0xFC, 0x00, 0x1F, 0xF8, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7,
  0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xE1,
  0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x04, 0x07, 0xFE, 0x03, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC1, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x37, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x7F, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFB, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x18, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x08, 0x00, 0x1F, 0xF8, 0x03, 0x80, 0x0F, 0xFE, 0x00, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x7F, 0xDF, 0xFC, 0x01, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x7F, 0xC0, 0xFF, 0x80,
  0x0F, 0xE7, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0x7F, 0xFE, 0x01,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0xFF, 0xE0, 0x07, 0xF3, 0xFF,
  0xE0, 0x1F, 0xEF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1,
  0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0xE0,
  0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF,
  0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xFC,
  0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F,
  0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0x7F,
  0xC3, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0xF0, 0x00,
  0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xDF, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xF8, 0x00, 0xFF,
  0xBF, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x07,
  0xFE, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xDF, 0xE0,
  0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xFC, 0x01,
  0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x60, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xE0,
  0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x8C, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFC, 0x1E, 0x03, 0xFE, 0x01, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x82, 0x00, 0x7F, 0xE0, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFE,
  0xFF, 0x00, 0x7F, 0xF9, 0xFE, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0x87,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF,
  0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x87, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xBF, 0xE0,
  0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFC, 0x0F, 0xF9, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFF, 0xE1, 0xFE,
  0x0F, 0xF8, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xFF, 0x8F, 0xF8, 0x3F,
  0xE7, 0xFF, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F,
  0xFF, 0x8F, 0xF0, 0x1F, 0xE7, 0xF7, 0xF3, 0xFE, 0x03, 0xFC, 0xFE, 0xFE,
  0x7F, 0xC0, 0x7F, 0xBF, 0xDF, 0xCF, 0xF0, 0x0F, 0xF7, 0xF3, 0xFB, 0xFE,
  0x01, 0xFE, 0xFE, 0x7F, 0x7F, 0x80, 0x3F, 0xDF, 0xCF, 0xEF, 0xF0, 0x07,
  0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x1F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF,
  0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x6F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x08, 0xFF, 0xF0, 0x00,
  0xDF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0x30, 0x00, 0x3F, 0xF1, 0x00, 0x00, 0x18,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 20, 48, 17, 0, -47 },
  { 121, 25, 17, 28, 6, -47 },
  { 175, 35, 47, 33, 0, -47 },
  { 381, 31, 54, 30, 0, -50 },
  { 591, 45, 49, 49, 3, -48 },
  { 867, 37, 49, 37, 0, -48 },
  { 1094, 13, 17, 16, 6, -47 },
  { 1122, 23, 58, 18, 1, -48 },
  { 1289, 22, 58, 18, -5, -48 },
  { 1449, 26, 29, 28, 5, -51 },
  { 1544, 27, 32, 32, 3, -39 },
  { 1652, 16, 18, 16, -4, -9 },
  { 1688, 18, 9, 20, 1, -22 },
  { 1709, 11, 12, 16, 0, -11 },
  { 1726, 35, 49, 25, -4, -48 },
  { 1941, 28, 49, 30, 2, -48 },
  { 2113, 23, 47, 30, 6, -47 },
  { 2249, 32, 48, 30, -2, -48 },
  { 2441, 31, 49, 30, -1, -48 },
  { 2631, 31, 47, 30, -1, -47 },
  { 2814, 30, 48, 30, 1, -47 },
  { 2994, 30, 49, 30, 2, -48 },
  { 3178, 31, 47, 30, 2, -47 },
  { 3361, 31, 49, 30, 0, -48 },
  { 3551, 30, 49, 30, 0, -48 },
  { 3735, 17, 38, 17, 0, -37 },
  { 3816, 21, 46, 17, -4, -37 },
  { 3937, 27, 32, 32, 3, -40 },
  { 4045, 27, 22, 32, 3, -34 },
  { 4120, 28, 32, 32, 3, -40 },
  { 4232, 24, 49, 23, 2, -48 },
  { 4379, 42, 53, 45, 2, -48 },
  { 4658, 33, 47, 33, -4, -47 },
  { 4852, 33, 47, 33, 0, -47 },
  { 5046, 32, 49, 30, 2, -48 },
  { 5242, 35, 47, 35, 0, -47 },
  { 5448, 30, 47, 27, 0, -47 },
  { 5625, 30, 47, 26, 0, -47 },
  { 5802, 35, 49, 35, 2, -48 },
  { 6017, 38, 47, 36, 0, -47 },
  { 6241, 31, 47, 23, -3, -47 },
  { 6424, 30, 61, 17, -10, -47 },
  { 6653, 38, 47, 32, 0, -47 },
  { 6877, 22, 47, 26, 0, -47 },
  { 7007, 50, 47, 47, 0, -47 },
  { 7301, 41, 47, 38, 0, -47 },
  { 7542, 35, 49, 37, 2, -48 },
  { 7757, 33, 47, 31, 0, -47 },
  { 7951, 35, 59, 37, 2, -48 },
  { 8210, 33, 47, 32, 0, -47 },
  { 8404, 32, 49, 28, -1, -48 },
  { 8600, 27, 47, 27, 5, -47 },
  { 8759, 36, 48, 35, 2, -47 },
  { 8975, 32, 47, 32, 6, -47 },
  { 9163, 49, 47, 48, 4, -47 },
  { 9451, 40, 47, 31, -4, -47 },
  { 9686, 30, 47, 30, 6, -47 },
  { 9863, 35, 47, 27, -3, -47 },
  { 10069, 27, 59, 19, -3, -48 },
  { 10269, 14, 49, 25, 7, -48 },
  { 10355, 27, 59, 19, -5, -48 },
  { 10555, 31, 30, 30, -1, -47 },
  { 10672, 24, 6, 23, -6, 5 },
  { 10690, 14, 11, 21, 9, -51 },
  { 10710, 31, 38, 31, 1, -37 },
  { 10858, 31, 51, 31, -1, -50 },
  { 11056, 26, 38, 25, 1, -37 },
  { 11180, 34, 51, 31, 1, -50 },
  { 11397, 28, 38, 29, 1, -37 },
  { 11530, 34, 66, 19, -7, -50 },
  { 11811, 34, 53, 31, -2, -37 },
  { 12037, 31, 50, 31, -1, -50 },
  { 12231, 20, 51, 16, -1, -51 },
  { 12359, 27, 67, 16, -8, -51 },
  { 12586, 34, 50, 30, -1, -50 },
  { 12799, 20, 50, 16, -1, -50 },
  { 12924, 46, 37, 46, -1, -37 },
  { 13137, 31, 37, 31, -1, -37 },
  { 13281, 28, 38, 30, 1, -37 },
  { 13414, 34, 53, 31, -4, -37 },
  { 13640, 31, 53, 31, 1, -37 },
  { 13846, 27, 37, 22, -1, -37 },
  { 13971, 26, 38, 25, 0, -37 },
  { 14095, 21, 45, 21, 2, -44 },
  { 14214, 31, 37, 31, 1, -36 },
  { 14358, 28, 36, 28, 4, -36 },
  { 14484, 43, 36, 42, 3, -36 },
  { 14678, 34, 36, 28, -3, -36 },
  { 14831, 37, 52, 28, -5, -36 },
  { 15072, 29, 36, 24, -3, -36 },
  { 15203, 26, 57, 23, 1, -47 },
  { 15389, 8, 66, 25, 8, -51 },
  { 15455, 26, 57, 23, -4, -47 },
  { 15641, 29, 12, 32, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC66PT7B_H_
