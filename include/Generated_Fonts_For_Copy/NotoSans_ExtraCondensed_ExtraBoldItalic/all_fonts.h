#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_ExtraBoldItalic
// Headers: 67

#include "NotoSans_ExtraCondensed_ExtraBoldItalic6pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic7pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic8pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic9pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic10pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic11pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic12pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic13pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic14pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic15pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic16pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic17pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic18pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic19pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic20pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic21pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic22pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic23pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic24pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic25pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic26pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic27pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic28pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic29pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic30pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic31pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic32pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic33pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic34pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic35pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic36pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic37pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic38pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic39pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic40pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic41pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic42pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic43pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic44pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic45pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic46pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic47pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic48pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic49pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic50pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic51pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic52pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic53pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic54pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic55pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic56pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic57pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic58pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic59pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic60pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic61pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic62pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic63pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic64pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic65pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic66pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic67pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic68pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic69pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic70pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic71pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBoldItalic72pt7b.h"
