#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC,
  0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x7F, 0x00, 0x3F, 0xCE, 0x3C, 0x00, 0xFF, 0x9C, 0x18, 0x01, 0xFE, 0x38,
  0x00, 0x03, 0xFC, 0xE0, 0x00, 0x07, 0xF9, 0xC0, 0x00, 0x0F, 0xFB, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xBF, 0xE0, 0x00, 0x07, 0x7F, 0xC0, 0x00, 0x0E, 0x7F, 0x80, 0x80,
  0x1C, 0xFF, 0x01, 0x80, 0x73, 0xFE, 0x03, 0xC0, 0xE7, 0xFC, 0x07, 0xE1,
  0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE0,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xC7, 0xF8, 0x08, 0x0F, 0xE1, 0xFC,
  0x7F, 0x07, 0xF8, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0xFC, 0x7F, 0x7F, 0x9F, 0xC7, 0xFF, 0xE7, 0xFF, 0xF1, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0x8F, 0xFF, 0xF7, 0xFF, 0xE3, 0xF9, 0xFC, 0x7F,
  0x3F, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0x8F, 0xF3, 0xF8, 0x7F, 0x07,
  0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x7E, 0x00, 0x03, 0xF8,
  0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7E,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x7F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF,
  0xFE, 0x7F, 0xC1, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0x83,
  0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC7,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0x01, 0xFC,
  0x00, 0xE0, 0xFE, 0x00, 0x7C, 0x7F, 0x00, 0x7F, 0xBF, 0x83, 0xBF, 0xFF,
  0xDF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xF8, 0x0F, 0x83, 0xFC,
  0x03, 0x81, 0xF8, 0x00, 0xC0, 0xF0, 0x00, 0x40, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x02, 0x03, 0xF8,
  0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF1, 0xFC,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0,
  0x1F, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xF8, 0x0F, 0xFB,
  0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0x7F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFF, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xFB, 0xFE, 0x1F, 0xEF, 0xFC, 0x1F, 0x9F, 0xF0,
  0x3E, 0x3F, 0xE0, 0x38, 0x7F, 0xC0, 0x20, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xCF, 0xFE, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0xF8, 0x1F, 0xF8, 0x01, 0xC0,
  0x3F, 0xF0, 0x01, 0x00, 0x7F, 0xE0, 0x02, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x70, 0x0F, 0xFC, 0x00, 0xC0, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x04, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x08, 0x00, 0x0F, 0xFC, 0x18, 0x00, 0x3F, 0xF8, 0x3E, 0x00, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0x74, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xEF, 0xF8, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x3F, 0x7F, 0xC0, 0x00, 0xFC,
  0xFF, 0x80, 0x03, 0xF9, 0xFF, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0x1F, 0xCF,
  0xFC, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x7F,
  0xC0, 0x0F, 0xE0, 0xFF, 0x80, 0x3F, 0x83, 0xFF, 0x00, 0x7F, 0x07, 0xFC,
  0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC1, 0x00, 0x07,
  0xFE, 0x0C, 0x00, 0x7F, 0xF0, 0x78, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x30, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x20, 0x00, 0xFF, 0x8F, 0xE0, 0x07,
  0xFD, 0xFF, 0x80, 0x7F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0,
  0xFF, 0x83, 0xFF, 0x87, 0xFC, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFE, 0x01, 0xFF, 0xBF, 0xF0,
  0x03, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFF, 0x0E, 0x01, 0xFF, 0x0C, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x1F, 0xC0, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8,
  0x3F, 0x83, 0xFF, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0x87, 0xE1, 0xFC,
  0x1F, 0xEF, 0xF0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x3F, 0x0F, 0xE0, 0xFE,
  0x1F, 0x8F, 0xE1, 0xF8, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8, 0x1F, 0xC1, 0xF9, 0xFC,
  0x3F, 0x03, 0xF0, 0x7E, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC,
  0x1F, 0xC1, 0xF8, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0x7E,
  0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF8, 0xFF, 0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0xFF, 0xEF, 0xFF, 0x00, 0xFC, 0x0F,
  0xF8, 0xFF, 0xC0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x02, 0x00,
  0x20, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xFF,
  0x00, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF9,
  0xF0, 0x03, 0xFF, 0xC0, 0x70, 0x03, 0xFF, 0x80, 0x20, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x04, 0x00, 0x7F, 0xF0, 0x3C,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xC0, 0x0F,
  0xFF, 0x00, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xE0, 0x7F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xF0, 0x7F, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xE0, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x47, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x01, 0xFE, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xBF, 0x83, 0xFD, 0xFF, 0x00, 0x7F, 0xDF, 0xE1, 0xFF,
  0xFF, 0x80, 0x3F, 0xEF, 0xF1, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF3, 0xFC, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFE, 0x7F,
  0xBF, 0xF0, 0x07, 0xFC, 0xFF, 0x3F, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xBF,
  0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xDF, 0xE7, 0xFC, 0x00, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0x00, 0x7F, 0xC7, 0xFF,
  0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xE1, 0xFF,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F,
  0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFE,
  0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFD, 0xFE, 0x0F, 0xF8,
  0x03, 0xFD, 0xFE, 0x1F, 0xF0, 0x03, 0xFD, 0xFE, 0x1F, 0xF0, 0x07, 0xFD,
  0xFF, 0x1F, 0xF0, 0x07, 0xFD, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x1F,
  0xF0, 0x07, 0xF8, 0xFF, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF8, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0xBF, 0xE0, 0x0F, 0xF8, 0xFF,
  0xBF, 0xC0, 0x0F, 0xF0, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0,
  0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF7,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x07, 0xFE,
  0x1F, 0xFC, 0x07, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF1,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0xF8, 0x01, 0xFF, 0x80, 0x30, 0x01, 0xFF, 0x80, 0x10, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x20, 0x01, 0xFF, 0xC0, 0x70, 0x01,
  0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x9F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC7, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE1, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0xFF, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xFF, 0x1F, 0xF8,
  0x03, 0xFE, 0x3F, 0xBF, 0x8F, 0xF8, 0x01, 0xFF, 0x3F, 0xDF, 0xCF, 0xFC,
  0x00, 0xFF, 0x9F, 0xEF, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xE7, 0xF3, 0xFE,
  0x00, 0x3F, 0xEF, 0xF3, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xF1, 0xFD, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0xFE, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0xFF, 0xFF,
  0xC0, 0x03, 0xFD, 0xFC, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x07,
  0xFE, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0x7F,
  0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x80,
  0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x3F,
  0xC0, 0x7F, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE7,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFD, 0xFF, 0x00, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0,
  0x03, 0xF8, 0x7F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF1, 0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0x80, 0x3F, 0x8F,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFE, 0x0C, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x02, 0x03, 0xFF, 0x81, 0x80, 0x7F, 0xF3, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0xF3, 0xF8,
  0x00, 0x3F, 0xF1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0x8F, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF9, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x02,
  0x07, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC4, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xFE, 0x3F,
  0xC0, 0x07, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x06, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x40, 0x00, 0xFF, 0x80, 0x38, 0x00, 0xFF,
  0xC0, 0x1F, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x0F, 0xFB, 0xFF, 0x00,
  0x7F, 0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83,
  0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF1, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0x9F, 0xFE, 0x7F, 0xFC, 0x03, 0xFD, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0xFF, 0xC0, 0x0F, 0xE7,
  0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xF7, 0xFE, 0x03,
  0xFF, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0,
  0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE7, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF1, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0xFC, 0x00, 0x3F, 0xDF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF7,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE3, 0xFC, 0x00,
  0x1F, 0xF0, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xFC,
  0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF,
  0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x03,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xFB, 0xFE,
  0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0xF8, 0x0C,
  0x07, 0xFC, 0x02, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x20, 0x07, 0xFE, 0x1C, 0x03, 0xFF, 0x0F,
  0xEF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xCC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFE, 0xFE, 0x00, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0x8F, 0xE0, 0x07,
  0xFC, 0x7F, 0x80, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xF9,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0xFF,
  0x80, 0x7F, 0x9F, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F,
  0xDF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFE, 0x0F,
  0xF9, 0xFF, 0x07, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0x9F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F,
  0xFF, 0x07, 0xF8, 0x7F, 0xC7, 0xFF, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0xF0,
  0xFF, 0x87, 0xF8, 0x7F, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xFF, 0x1F, 0xF0,
  0x7F, 0x8F, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xFF, 0xF3, 0xFE, 0x07, 0xF9,
  0xFD, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x7F, 0x3F, 0xC0, 0x7F, 0xBF, 0xDF,
  0xDF, 0xF0, 0x1F, 0xEF, 0xE7, 0xF7, 0xF8, 0x07, 0xFB, 0xF9, 0xFD, 0xFE,
  0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xBF, 0xC0, 0x1F,
  0xFF, 0xCF, 0xEF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x11, 0xFF, 0x80, 0x01, 0x3F, 0xFF, 0x00, 0x37, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0xC0, 0x01,
  0xFF, 0xC8, 0x00, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 20, 47, 17, 0, -46 },
  { 119, 25, 16, 27, 6, -46 },
  { 169, 35, 46, 33, 0, -46 },
  { 371, 31, 53, 29, 0, -49 },
  { 577, 44, 48, 48, 3, -47 },
  { 841, 36, 48, 36, 0, -47 },
  { 1057, 12, 16, 16, 6, -46 },
  { 1081, 22, 57, 18, 1, -47 },
  { 1238, 22, 58, 18, -5, -48 },
  { 1398, 25, 29, 28, 5, -50 },
  { 1489, 27, 32, 31, 3, -39 },
  { 1597, 16, 18, 16, -4, -9 },
  { 1633, 17, 9, 19, 1, -22 },
  { 1653, 11, 12, 16, 0, -11 },
  { 1670, 35, 48, 25, -4, -47 },
  { 1880, 27, 48, 29, 2, -47 },
  { 2042, 23, 46, 29, 6, -46 },
  { 2175, 31, 47, 29, -2, -47 },
  { 2358, 31, 48, 29, -1, -47 },
  { 2544, 31, 47, 29, -1, -47 },
  { 2727, 29, 47, 29, 1, -46 },
  { 2898, 29, 48, 29, 2, -47 },
  { 3072, 31, 46, 29, 2, -46 },
  { 3251, 30, 48, 29, 0, -47 },
  { 3431, 29, 48, 29, 0, -47 },
  { 3605, 16, 37, 17, 0, -36 },
  { 3679, 21, 45, 17, -4, -36 },
  { 3798, 28, 31, 31, 2, -39 },
  { 3907, 27, 21, 31, 3, -33 },
  { 3978, 27, 31, 31, 3, -39 },
  { 4083, 24, 48, 23, 2, -47 },
  { 4227, 43, 52, 44, 1, -47 },
  { 4507, 32, 47, 32, -4, -47 },
  { 4695, 33, 46, 32, 0, -46 },
  { 4885, 32, 48, 29, 2, -47 },
  { 5077, 34, 46, 34, 0, -46 },
  { 5273, 30, 46, 27, 0, -46 },
  { 5446, 30, 46, 26, 0, -46 },
  { 5619, 35, 48, 35, 2, -47 },
  { 5829, 38, 46, 35, 0, -46 },
  { 6048, 30, 46, 22, -3, -46 },
  { 6221, 29, 60, 17, -10, -46 },
  { 6439, 38, 46, 32, 0, -46 },
  { 6658, 22, 46, 25, 0, -46 },
  { 6785, 49, 46, 47, 0, -46 },
  { 7067, 40, 46, 38, 0, -46 },
  { 7297, 34, 48, 36, 2, -47 },
  { 7501, 33, 46, 31, 0, -46 },
  { 7691, 34, 58, 36, 2, -47 },
  { 7938, 32, 46, 31, 0, -46 },
  { 8122, 32, 48, 27, -1, -47 },
  { 8314, 27, 46, 27, 5, -46 },
  { 8470, 35, 47, 34, 2, -46 },
  { 8676, 32, 46, 32, 6, -46 },
  { 8860, 49, 46, 47, 4, -46 },
  { 9142, 39, 46, 30, -4, -46 },
  { 9367, 29, 46, 30, 6, -46 },
  { 9534, 34, 46, 27, -3, -46 },
  { 9730, 27, 58, 19, -3, -47 },
  { 9926, 15, 48, 25, 6, -47 },
  { 10016, 27, 58, 19, -5, -47 },
  { 10212, 30, 29, 29, -1, -46 },
  { 10321, 24, 6, 23, -6, 5 },
  { 10339, 13, 11, 20, 9, -50 },
  { 10357, 30, 37, 31, 1, -36 },
  { 10496, 31, 50, 31, -1, -49 },
  { 10690, 26, 37, 25, 1, -36 },
  { 10811, 33, 50, 31, 1, -49 },
  { 11018, 27, 37, 29, 1, -36 },
  { 11143, 33, 66, 19, -7, -50 },
  { 11416, 33, 52, 31, -2, -36 },
  { 11631, 30, 49, 31, -1, -49 },
  { 11815, 20, 50, 16, -1, -50 },
  { 11940, 27, 66, 16, -8, -50 },
  { 12163, 34, 49, 29, -1, -49 },
  { 12372, 20, 49, 15, -1, -49 },
  { 12495, 45, 36, 45, -1, -36 },
  { 12698, 30, 36, 31, -1, -36 },
  { 12833, 28, 37, 30, 1, -36 },
  { 12963, 34, 52, 31, -4, -36 },
  { 13184, 30, 52, 31, 1, -36 },
  { 13379, 26, 36, 22, -1, -36 },
  { 13496, 25, 37, 24, 0, -36 },
  { 13612, 21, 44, 20, 2, -43 },
  { 13728, 30, 37, 31, 1, -36 },
  { 13867, 27, 36, 28, 4, -36 },
  { 13989, 42, 36, 42, 3, -36 },
  { 14178, 34, 36, 28, -3, -36 },
  { 14331, 35, 52, 28, -4, -36 },
  { 14559, 29, 36, 24, -3, -36 },
  { 14690, 26, 56, 22, 1, -46 },
  { 14872, 8, 65, 25, 8, -50 },
  { 14937, 26, 56, 22, -4, -46 },
  { 15119, 28, 12, 31, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC65PT7B_H_
