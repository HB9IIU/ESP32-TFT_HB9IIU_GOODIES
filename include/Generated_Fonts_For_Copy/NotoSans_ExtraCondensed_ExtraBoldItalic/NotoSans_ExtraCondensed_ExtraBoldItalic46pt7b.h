#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x40,
  0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87,
  0xC7, 0xE3, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xE3,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0xC7,
  0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xB3, 0x80, 0xFC,
  0xC6, 0x03, 0xF3, 0x00, 0x0F, 0xDC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x06, 0xFE, 0x00, 0x1B,
  0xF8, 0x40, 0x6F, 0xC1, 0x81, 0xBF, 0x07, 0x86, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0,
  0x3F, 0xF0, 0x1F, 0x00, 0xFF, 0xE0, 0x7C, 0x01, 0xF7, 0xC0, 0xF8, 0x07,
  0xC7, 0x83, 0xE0, 0x0F, 0x8F, 0x07, 0xC0, 0x1E, 0x3E, 0x1F, 0x00, 0x7C,
  0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0xF8, 0x01, 0xF1, 0xF1, 0xF0, 0x03, 0xC3,
  0xE7, 0xC0, 0x0F, 0x8F, 0x9F, 0x80, 0x1F, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E,
  0xF8, 0xFF, 0x3E, 0xF9, 0xF3, 0xFE, 0x7F, 0xE7, 0xCF, 0xFE, 0xFF, 0xCF,
  0x9F, 0x7C, 0xFF, 0x3E, 0x7C, 0xF8, 0xFC, 0x7C, 0xF1, 0xF0, 0x01, 0xF3,
  0xE3, 0xE0, 0x07, 0xE7, 0xC7, 0xC0, 0x0F, 0x8F, 0x8F, 0x80, 0x3E, 0x1E,
  0x1F, 0x00, 0x7C, 0x7C, 0x3C, 0x01, 0xF0, 0xF8, 0xF8, 0x03, 0xE1, 0xF1,
  0xF0, 0x0F, 0x83, 0xE3, 0xC0, 0x1F, 0x07, 0xCF, 0x80, 0x7C, 0x07, 0xFE,
  0x00, 0xF8, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0x07, 0xFE, 0x3F, 0x87, 0xFF, 0x9F, 0xC7, 0xFF, 0xCF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xF3, 0xFF, 0xE3, 0xF9, 0xFF, 0xF1, 0xF8, 0x7F, 0xF1,
  0xFC, 0x3F, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xE7, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF7, 0xF8, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0x9F, 0xCF, 0xC7,
  0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x83, 0xE0, 0x38, 0xF8, 0x0F, 0x3C,
  0x37, 0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0xFC, 0x1E,
  0x3F, 0x03, 0x8F, 0x80, 0x41, 0x80, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF,
  0xE7, 0xFF, 0x7F, 0xF8, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x10,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xE7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF3,
  0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7E,
  0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0xFF, 0xFC, 0x7E, 0xFC, 0x3D, 0xFC, 0x39, 0xFC, 0x11, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7C, 0x7F, 0x80, 0x70, 0x7F,
  0x00, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0E, 0x0F, 0xE0, 0x40, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC4, 0x00, 0xFE, 0x20, 0x0F, 0xE1, 0xFB,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xBF, 0x00, 0x3F, 0xFC,
  0x00, 0xF7, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF8, 0x07,
  0xCF, 0xE0, 0x3E, 0x3F, 0x81, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3E, 0x1F,
  0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC8, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC4, 0x01, 0xFE, 0x30, 0x1F, 0xE1, 0xFB, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xB8, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x0C, 0x03, 0xFB, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC, 0xFE,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xF9, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xBF, 0x83, 0xF9, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x9F,
  0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x87, 0xF1, 0xFC, 0x3F,
  0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x3F,
  0x8F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xEF, 0xC0, 0xFE, 0xFE, 0x01, 0xC7, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xC1, 0xC7, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x3E, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x18,
  0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x60, 0x7E, 0x20, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E,
  0x1F, 0xF8, 0xF1, 0xF0, 0xFF, 0xE3, 0xC7, 0xC7, 0xFF, 0x8F, 0x1E, 0x3F,
  0x3E, 0x3C, 0xF8, 0xF8, 0xF0, 0xF3, 0xC7, 0xC3, 0xC7, 0xDF, 0x1F, 0x1F,
  0x1F, 0x7C, 0x78, 0x7C, 0x79, 0xE3, 0xE1, 0xE1, 0xE7, 0x8F, 0x87, 0x87,
  0x9E, 0x3C, 0x3E, 0x3E, 0xF8, 0xF0, 0xF8, 0xF3, 0xE3, 0xC3, 0xE3, 0xCF,
  0x0F, 0x1F, 0x1E, 0x3C, 0x3E, 0xFC, 0xF8, 0xF0, 0xFF, 0xFF, 0xC3, 0xC3,
  0xFD, 0xFE, 0x0F, 0x87, 0xE7, 0xF0, 0x3E, 0x07, 0x07, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0C,
  0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0x7F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0x06, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x20, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF1, 0xFF, 0x07, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x1F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x1C, 0x0F, 0xF0, 0x04, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xFC, 0xFF, 0x1F, 0xFC, 0xFE, 0x1F,
  0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x04, 0x7F, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFD, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xF8, 0xFB, 0xF0, 0x1F, 0xFF, 0x3F,
  0x7E, 0x03, 0xF7, 0xE7, 0xDF, 0xC0, 0x7E, 0xFD, 0xFB, 0xF8, 0x0F, 0xCF,
  0xBE, 0x7F, 0x03, 0xF9, 0xF7, 0xCF, 0xC0, 0x7F, 0x3F, 0xF9, 0xF8, 0x0F,
  0xC7, 0xFE, 0x7F, 0x01, 0xF8, 0xFF, 0xCF, 0xE0, 0x3F, 0x1F, 0xF1, 0xF8,
  0x0F, 0xE3, 0xFE, 0x3F, 0x01, 0xFC, 0x7F, 0x87, 0xE0, 0x3F, 0x0F, 0xF1,
  0xFC, 0x07, 0xE1, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x87,
  0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x87, 0xF0, 0x00,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xFE, 0x03, 0xF0, 0x3F,
  0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7E, 0x07, 0xFE, 0x07,
  0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0xFC, 0x07,
  0xFF, 0x0F, 0xC0, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0x1F, 0xC0, 0xFD, 0xF9,
  0xFC, 0x0F, 0xDF, 0x9F, 0x80, 0xFD, 0xF9, 0xF8, 0x1F, 0xDF, 0x9F, 0x81,
  0xF9, 0xF9, 0xF8, 0x1F, 0x8F, 0xBF, 0x81, 0xF8, 0xFF, 0xF0, 0x3F, 0x8F,
  0xFF, 0x03, 0xF8, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0x03, 0xF0, 0xFF, 0xE0,
  0x3F, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xE0,
  0x7F, 0xE0, 0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0xFE, 0x03, 0xFC,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x81,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F,
  0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0xBF,
  0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8,
  0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83,
  0xF8, 0xFF, 0x07, 0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x81, 0xFC, 0xFE,
  0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0xBF, 0x80, 0xFE,
  0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x7F, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFC, 0x7F,
  0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF1, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFE, 0x1E, 0x03,
  0xF8, 0x08, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x40, 0x1F, 0xC0, 0xC0, 0x3F, 0x81, 0xE0, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF7,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x01, 0xF0, 0x1F, 0xDF, 0xC0, 0xFC, 0x07, 0xF7,
  0xF0, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0xFE, 0x7E, 0x07, 0xF0, 0x3F,
  0x9F, 0x81, 0xFC, 0x0F, 0xC7, 0xE0, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xF0, 0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0x87, 0xE1, 0xFF,
  0x0F, 0xC1, 0xF8, 0xFF, 0xC7, 0xF0, 0x7E, 0x3F, 0xF1, 0xFC, 0x1F, 0x8F,
  0xFC, 0x7E, 0x07, 0xE7, 0xFF, 0x3F, 0x81, 0xF9, 0xF7, 0xCF, 0xC0, 0x7E,
  0xFF, 0xF7, 0xF0, 0x1F, 0xBF, 0xFD, 0xFC, 0x07, 0xEF, 0xBF, 0x7E, 0x01,
  0xFF, 0xEF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0,
  0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x7F,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x03, 0xFB, 0xF8, 0x0F, 0xDF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xBE, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F,
  0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x0F, 0x9F,
  0x80, 0x3E, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x00, 0xE0,
  0x00, 0x1F, 0xCF, 0xC1, 0xFF, 0x7E, 0x1F, 0xFB, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0x9F, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x1C, 0x01, 0xFB, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xF1,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F,
  0xCF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xCF, 0xF0,
  0x3E, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFC, 0x30, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x20,
  0xFF, 0x38, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x01, 0xC3, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xE7, 0xF8,
  0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07,
  0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF,
  0x00, 0xFF, 0x3E, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xDF, 0xC7, 0xE1, 0xF9,
  0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xE1, 0xF9, 0xF8, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x61, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xEC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFC, 0xFC, 0x07, 0xFD, 0xF8,
  0x1F, 0xFB, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC,
  0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F,
  0x03, 0xF9, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xEF, 0xC0, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x30, 0x1F, 0xE0, 0x7E, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x1C, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0xFF, 0x1F, 0xE3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE0, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xF8,
  0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFE, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0F, 0x9F, 0xC3, 0xF8,
  0x1F, 0x7F, 0xDF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xF9, 0xFF, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1,
  0xF8, 0x7F, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0xFE, 0x1F,
  0x83, 0xF1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0xC7, 0xE1, 0xFC,
  0x3F, 0x1F, 0xC3, 0xF8, 0x7E, 0x3F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF8, 0xFC, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x0F, 0xC0, 0x00, 0x01, 0x80,
  0x3E, 0x7F, 0x01, 0xF7, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF3, 0xF9, 0xFC,
  0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83,
  0xFB, 0xF0, 0x7F, 0x7F, 0x1F, 0xCF, 0xE7, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00,
  0xF9, 0xFC, 0x00, 0xFB, 0xFE, 0x01, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xFC, 0x0F, 0xF3, 0xF8, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xBF, 0xE0, 0x1F, 0xBF, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0xCF, 0xC1, 0xFF, 0x7E, 0x1F, 0xFB, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x7F, 0xBF, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xC1, 0xF3, 0xF0, 0x7D, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xE4, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xC1, 0xF8, 0x30, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE2, 0x03, 0xF8, 0xF1, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0xF7, 0xFF, 0xDF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x43, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0x7C, 0x0F, 0xF3, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0x0F,
  0xFF, 0x81, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x1F,
  0xE1, 0xFD, 0xF8, 0x7F, 0x87, 0xE7, 0xE1, 0xFE, 0x1F, 0x9F, 0x8F, 0xF8,
  0xFE, 0x7E, 0x3F, 0xE3, 0xF1, 0xF8, 0xFF, 0x8F, 0xC7, 0xE7, 0xFE, 0x7E,
  0x1F, 0x9F, 0xF9, 0xF8, 0x7E, 0xFB, 0xEF, 0xE1, 0xFB, 0xFF, 0x3F, 0x07,
  0xEF, 0xFC, 0xFC, 0x1F, 0xFD, 0xF7, 0xE0, 0x7D, 0xF7, 0xDF, 0x81, 0xF7,
  0xDF, 0x7E, 0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xE7,
  0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x03,
  0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xF8, 0x03,
  0xFB, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8,
  0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7E,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xF4, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 34, 12, 0, -33 },
  { 61, 18, 12, 19, 4, -33 },
  { 88, 24, 33, 23, 0, -33 },
  { 187, 22, 38, 21, 0, -35 },
  { 292, 31, 33, 34, 2, -33 },
  { 420, 25, 33, 25, 0, -33 },
  { 524, 9, 12, 11, 4, -33 },
  { 538, 15, 40, 13, 1, -33 },
  { 613, 16, 41, 13, -4, -34 },
  { 695, 18, 20, 20, 3, -35 },
  { 740, 19, 22, 22, 2, -27 },
  { 793, 11, 12, 11, -3, -6 },
  { 810, 13, 6, 14, 0, -15 },
  { 820, 8, 8, 11, 0, -7 },
  { 828, 25, 33, 18, -3, -33 },
  { 932, 20, 33, 21, 1, -33 },
  { 1015, 16, 33, 21, 4, -33 },
  { 1081, 23, 33, 21, -2, -33 },
  { 1176, 21, 33, 21, 0, -33 },
  { 1263, 22, 33, 21, -1, -33 },
  { 1354, 21, 33, 21, 0, -33 },
  { 1441, 21, 33, 21, 1, -33 },
  { 1528, 22, 33, 21, 1, -33 },
  { 1619, 21, 33, 21, 0, -33 },
  { 1706, 21, 33, 21, 0, -33 },
  { 1793, 12, 27, 12, 0, -26 },
  { 1834, 15, 32, 12, -3, -26 },
  { 1894, 19, 23, 22, 2, -28 },
  { 1949, 19, 15, 22, 2, -24 },
  { 1985, 19, 23, 22, 2, -28 },
  { 2040, 17, 34, 16, 1, -33 },
  { 2113, 30, 37, 31, 1, -33 },
  { 2252, 23, 33, 23, -3, -33 },
  { 2347, 23, 33, 23, 0, -33 },
  { 2442, 22, 33, 21, 2, -33 },
  { 2533, 24, 33, 24, 0, -33 },
  { 2632, 21, 33, 19, 0, -33 },
  { 2719, 21, 33, 18, 0, -33 },
  { 2806, 24, 33, 25, 2, -33 },
  { 2905, 27, 33, 25, 0, -33 },
  { 3017, 21, 33, 16, -2, -33 },
  { 3104, 21, 43, 12, -7, -33 },
  { 3217, 27, 33, 22, 0, -33 },
  { 3329, 16, 33, 18, 0, -33 },
  { 3395, 35, 33, 33, 0, -33 },
  { 3540, 28, 33, 27, 0, -33 },
  { 3656, 23, 33, 26, 2, -33 },
  { 3751, 23, 33, 22, 0, -33 },
  { 3846, 23, 41, 26, 2, -33 },
  { 3964, 23, 33, 22, 0, -33 },
  { 4059, 23, 33, 19, -1, -33 },
  { 4154, 20, 33, 19, 3, -33 },
  { 4237, 24, 33, 24, 2, -33 },
  { 4336, 23, 33, 23, 4, -33 },
  { 4431, 34, 33, 33, 3, -33 },
  { 4572, 28, 33, 21, -3, -33 },
  { 4688, 21, 33, 21, 4, -33 },
  { 4775, 24, 33, 19, -2, -33 },
  { 4874, 19, 41, 13, -2, -33 },
  { 4972, 10, 33, 18, 5, -33 },
  { 5014, 18, 41, 13, -3, -33 },
  { 5107, 22, 21, 21, -1, -33 },
  { 5165, 17, 4, 16, -4, 4 },
  { 5174, 9, 7, 14, 7, -35 },
  { 5182, 21, 26, 22, 1, -26 },
  { 5251, 21, 35, 22, 0, -35 },
  { 5343, 18, 26, 18, 1, -26 },
  { 5402, 23, 35, 22, 1, -35 },
  { 5503, 19, 26, 20, 1, -26 },
  { 5565, 24, 46, 13, -5, -35 },
  { 5703, 23, 37, 22, -1, -26 },
  { 5810, 21, 35, 22, 0, -35 },
  { 5902, 13, 35, 11, 0, -35 },
  { 5959, 19, 46, 11, -6, -35 },
  { 6069, 23, 35, 21, 0, -35 },
  { 6170, 14, 35, 11, 0, -35 },
  { 6232, 31, 26, 32, 0, -26 },
  { 6333, 21, 26, 22, 0, -26 },
  { 6402, 19, 26, 21, 1, -26 },
  { 6464, 24, 37, 22, -3, -26 },
  { 6575, 21, 37, 22, 1, -26 },
  { 6673, 18, 26, 15, 0, -26 },
  { 6732, 18, 26, 17, 0, -26 },
  { 6791, 14, 30, 14, 2, -30 },
  { 6844, 21, 25, 22, 1, -25 },
  { 6910, 19, 25, 20, 3, -25 },
  { 6970, 30, 25, 30, 2, -25 },
  { 7064, 24, 25, 20, -2, -25 },
  { 7139, 25, 36, 20, -3, -25 },
  { 7252, 20, 25, 17, -2, -25 },
  { 7315, 19, 40, 16, 0, -33 },
  { 7410, 5, 45, 18, 6, -35 },
  { 7439, 18, 40, 16, -3, -33 },
  { 7529, 19, 8, 22, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC46PT7B_H_
