#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x01,
  0x80, 0x00, 0x3F, 0xC7, 0xFC, 0xFF, 0x1F, 0xF7, 0xFC, 0x7F, 0x9F, 0xE1,
  0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xFC,
  0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFD, 0xC7,
  0x80, 0x3F, 0x9C, 0x30, 0x03, 0xF9, 0xC1, 0x00, 0x7F, 0x9C, 0x00, 0x07,
  0xF9, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0C, 0xFF, 0x02, 0x00, 0xCF, 0xF0, 0x30, 0x1C, 0xFF, 0x03, 0x81,
  0xCF, 0xE0, 0x3E, 0x1D, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xF7, 0xF0, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x1F,
  0xC0, 0x07, 0xE1, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x8F,
  0xC0, 0x01, 0xF8, 0x7E, 0x3F, 0x03, 0xC3, 0xF0, 0xFC, 0xFE, 0x1F, 0xE7,
  0xE3, 0xF9, 0xF8, 0xFF, 0xEF, 0xEF, 0xE7, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xC7, 0xFF, 0xDF, 0xFF, 0x3F, 0x9F, 0xFF, 0xBF, 0xFC, 0x7E, 0x7F, 0x3F,
  0x3F, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0xC3, 0xF1, 0xF8, 0xFC, 0x1C, 0x0F,
  0xC7, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x87,
  0xE0, 0x01, 0xFC, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x0F,
  0xE1, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0xFC, 0x00, 0x7F, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xC7,
  0xFC, 0x0F, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xFD,
  0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0x87, 0xFC, 0x7F,
  0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x10, 0x3F, 0x00, 0x38, 0x3F, 0x00, 0x3E, 0x3F,
  0x00, 0x3F, 0xBF, 0x0E, 0x7F, 0xFE, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0x01, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xEF,
  0xE0, 0x7F, 0xCF, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0x87, 0xF8, 0x07, 0x07,
  0xE0, 0x03, 0x07, 0xC0, 0x02, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x06, 0x0F,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x1F, 0x81, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F,
  0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x7F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xDF, 0xE0, 0xF8, 0xFF, 0x03, 0x8F, 0xF8, 0x08, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFE,
  0x1F, 0xF8, 0x03, 0xE0, 0x7F, 0xC0, 0x1E, 0x03, 0xFE, 0x00, 0x60, 0x1F,
  0xF0, 0x02, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x78, 0x3F,
  0xF0, 0x06, 0x01, 0xFF, 0x00, 0x40, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x08, 0x00, 0x3F, 0xF0, 0xC0, 0x03, 0xFE, 0x0F, 0x80, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xBF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x07, 0xE7, 0xF8, 0x00,
  0x7E, 0xFF, 0x80, 0x0F, 0xCF, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0x8F,
  0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xF0, 0x07, 0xE1, 0xFE, 0x00,
  0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x03,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xE7, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x0F, 0xFC, 0x18, 0x03, 0xFF,
  0x03, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xA0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x0E, 0x00, 0x3F, 0xE7, 0xF0, 0x07, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07,
  0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F,
  0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE7, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x3F,
  0xF3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC7,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x1F,
  0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xFC, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x40, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x3F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0E, 0x07, 0xFC, 0x20,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x03,
  0xFF, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x1F,
  0x87, 0xE0, 0xFF, 0xFE, 0x3F, 0x0F, 0xC3, 0xF8, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF9, 0xF8, 0x7E, 0x0F, 0xC3,
  0xE3, 0xF0, 0xFC, 0x1F, 0x07, 0xC7, 0xE3, 0xF0, 0x7E, 0x0F, 0x8F, 0x87,
  0xE0, 0xFC, 0x3F, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x7E, 0x3F, 0x07, 0xE0,
  0xF8, 0xFC, 0x7E, 0x0F, 0xC1, 0xF1, 0xF0, 0xFC, 0x1F, 0x87, 0xE3, 0xE1,
  0xF8, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0xFE, 0x3F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC,
  0x3F, 0xFB, 0xFF, 0x81, 0xF8, 0x3F, 0xF7, 0xFE, 0x03, 0xF0, 0x7F, 0xCF,
  0xF8, 0x03, 0xE0, 0x3E, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x40, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x00,
  0x7F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFF,
  0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC,
  0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC,
  0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0x83, 0x80, 0x3F, 0xF8, 0x04, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x04, 0x00, 0xFF, 0xC1, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xFC,
  0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80,
  0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F, 0x87, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0xF8, 0x07, 0xFE, 0x00, 0x60, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x0F, 0xFF, 0xC7, 0xFC, 0x1F,
  0xFF, 0x0F, 0xF8, 0x3F, 0xFE, 0x1F, 0xF0, 0x7F, 0xFC, 0x3F, 0xE0, 0xFF,
  0xF8, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x87, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x10, 0x7F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF0, 0xFE,
  0xFF, 0x00, 0xFF, 0x7F, 0x9F, 0xCF, 0xF0, 0x0F, 0xF7, 0xF9, 0xFD, 0xFF,
  0x00, 0xFF, 0x7F, 0xBF, 0x9F, 0xE0, 0x0F, 0xF7, 0xFB, 0xF9, 0xFE, 0x01,
  0xFE, 0x3F, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFF, 0xF3, 0xFE, 0x01, 0xFE,
  0x3F, 0xFF, 0x3F, 0xE0, 0x1F, 0xE3, 0xFF, 0xE3, 0xFC, 0x03, 0xFC, 0x3F,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xF8, 0x7F,
  0x80, 0x7F, 0x83, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0x80,
  0x7F, 0x83, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xE0, 0x1F, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F,
  0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0x87, 0xFC,
  0x03, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0x87, 0xF8, 0x07, 0xFB, 0xF8,
  0x7F, 0x80, 0x7F, 0xBF, 0x87, 0xF8, 0x07, 0xFB, 0xFC, 0xFF, 0x80, 0x7F,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xCF, 0xF0,
  0x0F, 0xF1, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xCF, 0xE0, 0x0F, 0xE1, 0xFF,
  0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0xFE, 0x01, 0xFE,
  0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xC0, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF,
  0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF8, 0x07, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFE,
  0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F,
  0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x1F, 0xF0,
  0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xCF, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFF, 0x01, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01,
  0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F,
  0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF,
  0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9,
  0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF,
  0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F,
  0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFD, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1,
  0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFE, 0x1F, 0xF0,
  0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xC0, 0x1F, 0xF8, 0x0E, 0x00, 0xFF,
  0xC0, 0x20, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x40, 0x03, 0xFE, 0x03, 0x80, 0x1F,
  0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xE8, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F,
  0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xCF,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0xC0,
  0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F,
  0x80, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x7F, 0x81,
  0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFF,
  0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFF, 0xC3,
  0xFC, 0x07, 0xF8, 0x7F, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xFF, 0xC7, 0xF8,
  0x07, 0xF8, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xDF, 0x8F, 0xF8, 0x07,
  0xF9, 0xFD, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0x9F, 0xF0, 0x07, 0xFB,
  0xFB, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0xBF, 0x9F, 0xE0, 0x07, 0xF3, 0xFB,
  0xFB, 0xFE, 0x00, 0x7F, 0x7F, 0x3F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF3, 0xFB,
  0xFC, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xEF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xF8,
  0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x10, 0x0F, 0xF8, 0xFE, 0x01, 0xFF,
  0xCF, 0xE0, 0x3F, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x80,
  0x7F, 0xF3, 0xF8, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xF8, 0x07, 0xF3, 0xFF, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0x3C, 0x1F, 0xF8, 0x10, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xC1, 0xFF, 0x83, 0x83, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0x1F, 0xF0, 0x03, 0xFE,
  0x7F, 0x80, 0x1F, 0xFD, 0xFE, 0x00, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xF0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFE,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xBF, 0x80, 0x0F, 0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xF8, 0x7F, 0x1F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x3F, 0xE0, 0x7F, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0xDF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x7F, 0xC0, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0x88, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x04, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x02, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0xDF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x00,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE3,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F,
  0x80, 0x03, 0xF9, 0xFF, 0x00, 0x00, 0x83, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x30, 0x01, 0xFF, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x1F, 0xE7,
  0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x9F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x20, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0xFE, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xFB, 0xFF, 0x03,
  0xFE, 0x1F, 0xF8, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x1F, 0xDF, 0xFE, 0x01, 0xFB,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFB, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F, 0xCF,
  0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFD,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F,
  0xFB, 0xFE, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x87, 0xFC, 0x7F, 0xC3,
  0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0xFE, 0x7F, 0xE0, 0x01, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFD, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F,
  0xE0, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x07, 0xF8,
  0xFE, 0x01, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x1F, 0xC7,
  0xF8, 0x00, 0x20, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0xFE,
  0x01, 0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x88, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xF8, 0x38, 0x1F, 0xF0, 0x10, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x80, 0x3F, 0xE1, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x08, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFE, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xF0,
  0x0F, 0xFC, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF,
  0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x83, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xF0,
  0x7F, 0x9F, 0xE1, 0xFF, 0xC3, 0xFE, 0x7F, 0x87, 0xFF, 0x0F, 0xF1, 0xFE,
  0x3F, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0xF1, 0xFE, 0x1F, 0xC3, 0xFF, 0xC7,
  0xF8, 0x7F, 0x1F, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0xF8, 0xFF, 0x07, 0xF1,
  0xFF, 0xE3, 0xFC, 0x3F, 0xCF, 0xFF, 0x8F, 0xE0, 0xFF, 0x3F, 0x7E, 0x7F,
  0x83, 0xFD, 0xFD, 0xF9, 0xFE, 0x0F, 0xF7, 0xF7, 0xEF, 0xF0, 0x3F, 0xDF,
  0x9F, 0xBF, 0xC0, 0xFF, 0xFE, 0x7E, 0xFE, 0x03, 0xFF, 0xF3, 0xFF, 0xF8,
  0x0F, 0xFF, 0xCF, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0xFF, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80,
  0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x47, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x9F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFE, 0x00, 0x37,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0xC0, 0x0F, 0xFF, 0x20, 0x00,
  0xFF, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 18, 43, 15, 0, -42 },
  { 98, 22, 15, 25, 6, -42 },
  { 140, 31, 42, 30, 0, -42 },
  { 303, 28, 48, 26, 0, -45 },
  { 471, 39, 44, 44, 3, -43 },
  { 686, 33, 44, 33, 0, -43 },
  { 868, 11, 15, 14, 6, -42 },
  { 889, 20, 52, 16, 1, -43 },
  { 1019, 21, 52, 16, -5, -43 },
  { 1156, 24, 26, 25, 4, -45 },
  { 1234, 25, 28, 28, 2, -35 },
  { 1322, 14, 16, 15, -3, -8 },
  { 1350, 16, 8, 18, 1, -20 },
  { 1366, 10, 11, 15, 0, -10 },
  { 1380, 31, 44, 23, -3, -43 },
  { 1551, 26, 44, 26, 1, -43 },
  { 1694, 21, 42, 27, 5, -42 },
  { 1805, 29, 43, 26, -2, -43 },
  { 1961, 28, 44, 26, -1, -43 },
  { 2115, 28, 42, 27, -1, -42 },
  { 2262, 27, 43, 26, 1, -42 },
  { 2408, 27, 44, 26, 2, -43 },
  { 2557, 28, 42, 26, 2, -42 },
  { 2704, 28, 44, 26, 0, -43 },
  { 2858, 27, 44, 26, 0, -43 },
  { 3007, 15, 34, 15, 0, -33 },
  { 3071, 18, 41, 15, -3, -33 },
  { 3164, 25, 29, 28, 2, -36 },
  { 3255, 25, 19, 28, 2, -30 },
  { 3315, 25, 29, 28, 2, -36 },
  { 3406, 22, 44, 21, 2, -43 },
  { 3527, 39, 48, 40, 1, -43 },
  { 3761, 30, 42, 29, -4, -42 },
  { 3919, 30, 42, 29, 0, -42 },
  { 4077, 29, 44, 27, 2, -43 },
  { 4237, 31, 42, 31, 0, -42 },
  { 4400, 27, 42, 24, 0, -42 },
  { 4542, 27, 42, 23, 0, -42 },
  { 4684, 31, 44, 32, 2, -43 },
  { 4855, 34, 42, 32, 0, -42 },
  { 5034, 27, 42, 20, -2, -42 },
  { 5176, 27, 55, 15, -9, -42 },
  { 5362, 34, 42, 29, 0, -42 },
  { 5541, 20, 42, 23, 0, -42 },
  { 5646, 44, 42, 42, 0, -42 },
  { 5877, 36, 42, 34, 0, -42 },
  { 6066, 31, 44, 33, 2, -43 },
  { 6237, 30, 42, 28, 0, -42 },
  { 6395, 31, 53, 33, 2, -43 },
  { 6601, 29, 42, 28, 0, -42 },
  { 6754, 29, 44, 25, -1, -43 },
  { 6914, 25, 42, 24, 4, -42 },
  { 7046, 32, 43, 31, 2, -42 },
  { 7218, 29, 42, 29, 5, -42 },
  { 7371, 44, 42, 42, 4, -42 },
  { 7602, 35, 42, 28, -3, -42 },
  { 7786, 27, 42, 27, 5, -42 },
  { 7928, 30, 42, 24, -2, -42 },
  { 8086, 24, 53, 17, -3, -43 },
  { 8245, 13, 44, 23, 6, -43 },
  { 8317, 24, 53, 17, -4, -43 },
  { 8476, 28, 26, 26, -1, -42 },
  { 8567, 22, 5, 21, -6, 5 },
  { 8581, 12, 9, 18, 8, -45 },
  { 8595, 28, 34, 28, 1, -33 },
  { 8714, 28, 46, 28, -1, -45 },
  { 8875, 23, 34, 22, 1, -33 },
  { 8973, 30, 46, 28, 1, -45 },
  { 9146, 24, 34, 26, 1, -33 },
  { 9248, 31, 59, 17, -7, -45 },
  { 9477, 31, 47, 28, -2, -33 },
  { 9660, 28, 45, 28, -1, -45 },
  { 9818, 18, 45, 14, -1, -45 },
  { 9920, 24, 59, 14, -7, -45 },
  { 10097, 31, 45, 27, -1, -45 },
  { 10272, 18, 45, 14, -1, -45 },
  { 10374, 41, 33, 41, -1, -33 },
  { 10544, 28, 33, 28, -1, -33 },
  { 10660, 25, 34, 27, 1, -33 },
  { 10767, 31, 47, 28, -4, -33 },
  { 10950, 28, 47, 28, 1, -33 },
  { 11115, 24, 33, 20, -1, -33 },
  { 11214, 23, 34, 22, 0, -33 },
  { 11312, 19, 40, 19, 2, -39 },
  { 11407, 27, 33, 28, 1, -32 },
  { 11519, 24, 32, 25, 4, -32 },
  { 11615, 38, 32, 38, 3, -32 },
  { 11767, 31, 32, 25, -3, -32 },
  { 11891, 32, 46, 25, -4, -32 },
  { 12075, 25, 32, 21, -2, -32 },
  { 12175, 24, 51, 20, 0, -42 },
  { 12328, 8, 58, 23, 7, -45 },
  { 12386, 23, 51, 20, -3, -42 },
  { 12533, 26, 10, 28, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC59PT7B_H_
