#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x00, 0x00, 0x20, 0x78, 0xF8, 0xF0, 0xF0, 0x7B, 0xFC, 0xFF,
  0x3F, 0xCE, 0xF7, 0xB9, 0xEE, 0x70, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70,
  0x1D, 0xC0, 0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C,
  0xC0, 0x73, 0x80, 0xE7, 0x0F, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C, 0xE0,
  0x33, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x38, 0x00, 0x00, 0xC0, 0x04, 0x01,
  0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x74, 0x43, 0xA0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF1, 0x1B, 0x88, 0xFC, 0x7F, 0xE7,
  0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x0F, 0x03,
  0x83, 0xF0, 0xE0, 0xFE, 0x38, 0x39, 0xC7, 0x07, 0x39, 0xC0, 0xE7, 0x38,
  0x1C, 0xEE, 0x03, 0x39, 0xC0, 0xE7, 0x73, 0xCF, 0xCE, 0xFD, 0xFB, 0xBF,
  0xBE, 0xF7, 0x70, 0x1D, 0xCE, 0x07, 0x39, 0xC0, 0xE7, 0x38, 0x38, 0xE7,
  0x07, 0x1D, 0xC1, 0xC3, 0xF8, 0x38, 0x7E, 0x0E, 0x07, 0x80, 0x03, 0xF0,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x9F, 0x3F, 0xDE, 0x3F, 0xDE, 0x7B, 0xFC,
  0xF3, 0xFC, 0xF1, 0xF8, 0xF1, 0xF0, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3E, 0x7C, 0x7F, 0xFD, 0xEF, 0x73, 0x80, 0x03, 0xC1, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xE0, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0x83,
  0xC1, 0xC1, 0xE1, 0xE0, 0x08, 0x01, 0xE0, 0x3C, 0x37, 0x87, 0xEF, 0xFF,
  0xDF, 0xF8, 0xF8, 0x3F, 0x0F, 0xF1, 0xCF, 0x19, 0xC0, 0x20, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x3C, 0xF1, 0xE3, 0x8F,
  0x1C, 0x78, 0x7F, 0x7F, 0xFE, 0x23, 0xFF, 0xEF, 0x00, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xFE, 0x1F, 0xE3, 0xFF, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x79,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7,
  0x8F, 0xF0, 0xFF, 0x07, 0xC0, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xF7, 0xFB,
  0xBC, 0x9E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xDF, 0x0C,
  0x7C, 0x21, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xE1, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0x07, 0xE0, 0xFF, 0x87, 0xFE, 0x1D, 0xF0, 0x87, 0x80,
  0x3C, 0x03, 0xC0, 0x3E, 0x0F, 0xC0, 0x78, 0x07, 0xF0, 0x0F, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x90, 0x7C, 0xC7, 0xC7, 0xFE, 0x3F, 0xE1, 0xFC, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x1B, 0xC1,
  0xFC, 0x1D, 0xE0, 0xEF, 0x0E, 0x78, 0xE3, 0xC7, 0x3C, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFC, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x90, 0x7C, 0xE7,
  0xC7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x3E,
  0x21, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x78, 0x7F, 0xC7, 0xFF, 0x3E, 0xF9,
  0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xCF, 0x1E, 0x78, 0xF7, 0xC7, 0xFC, 0x1F,
  0xC0, 0x7C, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x7B, 0xC3,
  0xFE, 0x1F, 0xE0, 0x7C, 0x07, 0xF0, 0x7F, 0xC7, 0x9E, 0x7C, 0xF3, 0xC7,
  0x9E, 0x3C, 0xF1, 0xE7, 0xFE, 0x1F, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F,
  0x87, 0xFC, 0x3D, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3C, 0xF1,
  0xEF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFE, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x8F,
  0xC7, 0xFC, 0x3F, 0xC1, 0xF8, 0x00, 0x04, 0x3C, 0xF9, 0xF1, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x07, 0x9F, 0x3E, 0x78, 0x01, 0x03, 0xC3, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0x80,
  0xE0, 0x08, 0x00, 0x1F, 0x9F, 0xF7, 0xFC, 0xCF, 0x43, 0xC0, 0xF0, 0x38,
  0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38,
  0x0E, 0x1C, 0x01, 0xCE, 0x3E, 0x73, 0x1F, 0xDD, 0xCE, 0x67, 0x77, 0x39,
  0xF9, 0xCE, 0x7E, 0x63, 0x9B, 0xB8, 0xC6, 0xCE, 0x73, 0xB3, 0x9C, 0xCC,
  0xFF, 0xF3, 0x1E, 0xF8, 0xC3, 0x1C, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xE1,
  0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xDC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D,
  0xF0, 0xF7, 0x83, 0xFE, 0x0F, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x9F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9E, 0x3F, 0xF0, 0xFF, 0x83, 0xFF,
  0x0F, 0x7C, 0x7C, 0xF9, 0xE3, 0xE7, 0x8F, 0x1E, 0x3C, 0x7B, 0xF3, 0xFF,
  0x8F, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xEC, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFD, 0xC1, 0xFF, 0x07,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xE3,
  0xC3, 0xC7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3C, 0x3E, 0x78, 0x78, 0xF0, 0xF1,
  0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x3E, 0x3C, 0xF8, 0x7F, 0xF1, 0xFF,
  0xC3, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x21, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x01,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFD, 0xE3, 0xE0, 0x47, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x05, 0xF3, 0xF3, 0xE7, 0xE7, 0x8F, 0xCF, 0x07, 0x9E,
  0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0xFD, 0xF0, 0xFF, 0xE1, 0xFF, 0x80, 0xFE,
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3C,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xF8, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x3E, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x79,
  0xE0, 0x79, 0xE0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF0, 0xF0, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x7F, 0xFF, 0xEF, 0xFB, 0xFE, 0x0F, 0x81,
  0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1, 0xFE, 0xFF,
  0x0F, 0xF7, 0x78, 0x7F, 0xFB, 0xC7, 0xBF, 0xBC, 0x3D, 0xFD, 0xE1, 0xEF,
  0xCF, 0x0F, 0x7E, 0x78, 0x71, 0xF3, 0xC7, 0x8F, 0x3C, 0x3C, 0x79, 0xE1,
  0xE3, 0x8F, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE3, 0xF0, 0xF1,
  0xF8, 0xF0, 0xFE, 0x78, 0x7F, 0x3C, 0x3F, 0x9E, 0x3D, 0xCF, 0x1E, 0xEF,
  0x0F, 0x77, 0x87, 0xBF, 0xC7, 0x9F, 0xE3, 0xCF, 0xE1, 0xE3, 0xF0, 0xF1,
  0xF8, 0x70, 0xFC, 0x78, 0x7E, 0x3C, 0x3E, 0x1E, 0x1F, 0x00, 0x03, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xE3, 0xE3, 0xC7, 0x87, 0x9F, 0x0F, 0xBC,
  0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xE0, 0xF7, 0xC3, 0xEF, 0x07, 0xDE, 0x0F,
  0x3C, 0x3E, 0x7C, 0x78, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x9F, 0x3C, 0x78, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xE3, 0xE3, 0xC7, 0x87, 0x9F, 0x0F,
  0xBC, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xE0, 0xF7, 0xC3, 0xEF, 0x07, 0xDE,
  0x0F, 0x3C, 0x3E, 0x7C, 0x78, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x87, 0xBF, 0x1E, 0x7C, 0x78, 0xF1, 0xE7, 0xC7, 0x9E,
  0x3C, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xEF, 0x07, 0x9E,
  0x1E, 0x78, 0x79, 0xE3, 0xC7, 0x8F, 0x1F, 0x3C, 0x7C, 0x03, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0x08, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x10,
  0x78, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x7F, 0xF7, 0xFE, 0xFF,
  0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7,
  0x87, 0x8F, 0x1F, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7,
  0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0xFB, 0xE1, 0xFF, 0xC1,
  0xFF, 0x01, 0xF8, 0x00, 0xF0, 0x7F, 0x87, 0xFC, 0x3D, 0xE3, 0xEF, 0x1E,
  0x78, 0xF3, 0xCF, 0x1E, 0x78, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xDE, 0x0E,
  0xF0, 0x77, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x00, 0x70, 0x70, 0xFF, 0x87, 0x87, 0xBC, 0x3C, 0x3D, 0xE1, 0xE3, 0xCF,
  0x1F, 0x1E, 0x78, 0xF8, 0xF3, 0xCF, 0xCF, 0x1E, 0x7E, 0x78, 0xF3, 0xF7,
  0x87, 0xBB, 0xBC, 0x3D, 0xDD, 0xE1, 0xFE, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xC7, 0xE0,
  0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x87, 0x83, 0xC7, 0x81, 0xE7,
  0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x1E, 0x3C, 0x1F, 0x1E, 0x1F, 0x0F,
  0x00, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x87,
  0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7F,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x00, 0xE3, 0x8F, 0x3C, 0xF1, 0xC7, 0x1C, 0x71,
  0xE7, 0x9E, 0x78, 0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x07, 0xE0, 0xFC, 0x1F,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x7B, 0x83, 0x9C, 0x3C, 0xF1, 0xC7, 0x9E,
  0x1D, 0xE0, 0xEE, 0x07, 0x80, 0x7F, 0xEF, 0xFB, 0xFF, 0x00, 0xF9, 0xE3,
  0x8F, 0x03, 0x04, 0x3E, 0xE1, 0xFF, 0x8F, 0xFE, 0x3C, 0xF8, 0xF3, 0xE7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x9E, 0x3E, 0x78, 0xFB, 0xE1,
  0xFF, 0x87, 0xFE, 0x0F, 0x70, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x30, 0x7F, 0xC3, 0xFE, 0x3F, 0xF9, 0xF3, 0xCF, 0x1E, 0x78,
  0xF3, 0x8F, 0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0x79, 0xF7, 0xCF, 0x3F, 0xF9,
  0xFF, 0x8E, 0xF8, 0x00, 0x07, 0x03, 0xFC, 0xFF, 0x1F, 0xC7, 0x88, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x31, 0xFE, 0x3F,
  0xC3, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0xE7, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x79, 0xF0, 0xF3, 0xC3, 0xC7,
  0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x70, 0xF9, 0xE1, 0xF7, 0xC1,
  0xFF, 0x83, 0xFF, 0x03, 0xDC, 0x00, 0x03, 0x03, 0xF8, 0xFF, 0x9E, 0xF7,
  0x8E, 0xE3, 0xFC, 0xFF, 0xFE, 0xFF, 0x9F, 0x83, 0x80, 0x70, 0x0F, 0x09,
  0xFF, 0x3F, 0xE3, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x01,
  0xE0, 0x0F, 0x20, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x38, 0x00, 0x01, 0x82, 0x0F, 0xB8, 0x3F, 0xF0, 0xFF,
  0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF1,
  0xF3, 0xC3, 0xE7, 0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xC2, 0x0F, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x20, 0x7F,
  0xC3, 0xFE, 0x3F, 0xF9, 0xF7, 0xCF, 0x1E, 0x79, 0xE3, 0x8F, 0x3C, 0x79,
  0xE3, 0xCF, 0x1E, 0x79, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3C, 0x00,
  0x02, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0x20,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0x70, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE7, 0xC7, 0x3E, 0x3C, 0xF0, 0xF7, 0x83,
  0xFC, 0x0E, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC3,
  0xCF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xE0, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0xC1, 0x83, 0xBE, 0xF8, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xEF, 0x9E, 0x79, 0xE3, 0xCF, 0x3C, 0x79, 0xC7, 0x9E, 0x78,
  0xF3, 0xCF, 0x1C, 0x79, 0xE7, 0x8F, 0x3C, 0xF1, 0xEF, 0x1E, 0x79, 0xE3,
  0xCF, 0x3C, 0x71, 0xE7, 0x9E, 0x3C, 0x00, 0x60, 0xEF, 0x87, 0xFE, 0x7F,
  0xF3, 0xEF, 0x9E, 0x3C, 0xF3, 0xC7, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C,
  0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x78, 0x07, 0x03, 0xF8, 0xFF,
  0x9F, 0xF7, 0x9E, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF9,
  0xEF, 0x7D, 0xFF, 0x3F, 0xC3, 0xF0, 0x00, 0x10, 0x0E, 0xF8, 0x1F, 0xF0,
  0x7F, 0xF0, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x0F, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0xF0, 0xF3, 0xE3, 0xE7, 0x87, 0xFF, 0x0F, 0xFC, 0x1E, 0xF0,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x04, 0x3E, 0xE1, 0xFF, 0x87, 0xFE, 0x3C, 0xF8, 0xF3,
  0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x8E, 0x3E, 0x78, 0xFB,
  0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x63, 0xBC, 0x7F, 0x1F,
  0xE3, 0xFC, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x07, 0x03, 0xFC, 0xFF, 0x1F, 0xE3, 0xC4,
  0x78, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1E, 0x03, 0xCC, 0xF9, 0xFF,
  0x3F, 0xC7, 0xF0, 0x0E, 0x07, 0x07, 0x83, 0x87, 0xFB, 0xFB, 0xFC, 0x70,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE4, 0xFC, 0x7E, 0x1F,
  0x00, 0x3C, 0xF3, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x9E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x7C, 0xFF, 0xCF, 0xFC, 0x7B, 0x80,
  0xF1, 0xFE, 0x3F, 0xCF, 0x79, 0xEF, 0x79, 0xEF, 0x3D, 0xC7, 0xF8, 0xEE,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0x79, 0xF3, 0xDE,
  0x7C, 0xF7, 0x3F, 0x39, 0xCF, 0xDE, 0x73, 0xF7, 0x9D, 0xFB, 0xC7, 0x7E,
  0xF1, 0xFF, 0xB8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x80, 0x1E, 0x3C, 0x79, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x03, 0xFC, 0x0F, 0x70, 0x79, 0xE1, 0xE7, 0x8F, 0x1E, 0x00, 0x0F, 0x1F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xCF, 0xF8, 0xFF, 0x80, 0x00, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x7E, 0x07, 0xC0, 0xF0,
  0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0xF8, 0x1F, 0x07,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x81, 0xF0,
  0x3E, 0x0F, 0xC3, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE1,
  0xF8, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 10, 7, 12, 3, -20 },
  { 30, 15, 20, 14, 0, -20 },
  { 68, 13, 23, 13, 0, -21 },
  { 106, 19, 20, 21, 1, -20 },
  { 154, 16, 20, 16, 0, -20 },
  { 194, 5, 7, 7, 3, -20 },
  { 199, 10, 24, 8, 0, -20 },
  { 229, 9, 24, 8, -2, -20 },
  { 256, 11, 13, 12, 2, -22 },
  { 274, 12, 14, 13, 1, -17 },
  { 295, 7, 8, 7, -2, -4 },
  { 302, 8, 3, 8, 0, -9 },
  { 305, 5, 5, 7, 0, -5 },
  { 309, 15, 20, 11, -2, -20 },
  { 347, 12, 20, 13, 1, -20 },
  { 377, 9, 20, 13, 3, -20 },
  { 400, 14, 20, 13, -1, -20 },
  { 435, 13, 20, 13, 0, -20 },
  { 468, 13, 20, 13, 0, -20 },
  { 501, 13, 20, 13, 0, -20 },
  { 534, 13, 20, 13, 1, -20 },
  { 567, 13, 20, 13, 1, -20 },
  { 600, 13, 20, 13, 0, -20 },
  { 633, 13, 20, 13, 0, -20 },
  { 666, 7, 16, 7, 0, -16 },
  { 680, 9, 20, 7, -2, -16 },
  { 703, 12, 14, 13, 1, -17 },
  { 724, 12, 9, 13, 1, -14 },
  { 738, 12, 14, 13, 1, -17 },
  { 759, 10, 20, 10, 1, -20 },
  { 784, 18, 22, 19, 1, -20 },
  { 834, 14, 20, 14, -2, -20 },
  { 869, 14, 20, 14, 0, -20 },
  { 904, 14, 20, 13, 1, -20 },
  { 939, 15, 20, 15, 0, -20 },
  { 977, 13, 20, 11, 0, -20 },
  { 1010, 13, 20, 11, 0, -20 },
  { 1043, 15, 20, 15, 1, -20 },
  { 1081, 16, 20, 15, 0, -20 },
  { 1121, 13, 20, 10, -1, -20 },
  { 1154, 12, 26, 7, -4, -20 },
  { 1193, 16, 20, 14, 0, -20 },
  { 1233, 10, 20, 11, 0, -20 },
  { 1258, 21, 20, 20, 0, -20 },
  { 1311, 17, 20, 16, 0, -20 },
  { 1354, 15, 20, 16, 1, -20 },
  { 1392, 14, 20, 13, 0, -20 },
  { 1427, 15, 25, 16, 1, -20 },
  { 1474, 14, 20, 14, 0, -20 },
  { 1509, 14, 20, 12, -1, -20 },
  { 1544, 12, 20, 12, 2, -20 },
  { 1574, 15, 20, 15, 1, -20 },
  { 1612, 13, 20, 14, 3, -20 },
  { 1645, 21, 20, 20, 2, -20 },
  { 1698, 17, 20, 13, -2, -20 },
  { 1741, 12, 20, 13, 3, -20 },
  { 1771, 14, 20, 12, -1, -20 },
  { 1806, 11, 25, 8, -1, -20 },
  { 1841, 6, 20, 11, 3, -20 },
  { 1856, 11, 25, 8, -2, -20 },
  { 1891, 13, 13, 13, 0, -20 },
  { 1913, 11, 3, 10, -3, 2 },
  { 1918, 6, 4, 9, 4, -21 },
  { 1921, 14, 16, 13, 0, -16 },
  { 1949, 13, 21, 13, 0, -21 },
  { 1984, 11, 16, 11, 1, -16 },
  { 2006, 15, 21, 13, 0, -21 },
  { 2046, 11, 16, 12, 1, -16 },
  { 2068, 14, 28, 8, -3, -21 },
  { 2117, 15, 23, 13, -1, -16 },
  { 2161, 13, 21, 13, 0, -21 },
  { 2196, 8, 22, 7, 0, -22 },
  { 2218, 12, 29, 7, -4, -22 },
  { 2262, 14, 21, 13, 0, -21 },
  { 2299, 8, 21, 7, 0, -21 },
  { 2320, 19, 16, 19, 0, -16 },
  { 2358, 13, 16, 13, 0, -16 },
  { 2384, 11, 16, 13, 1, -16 },
  { 2406, 15, 23, 13, -2, -16 },
  { 2450, 14, 23, 13, 0, -16 },
  { 2491, 11, 16, 9, 0, -16 },
  { 2513, 11, 16, 10, 0, -16 },
  { 2535, 9, 19, 9, 1, -19 },
  { 2557, 12, 15, 13, 1, -15 },
  { 2580, 11, 15, 12, 2, -15 },
  { 2601, 18, 15, 18, 1, -15 },
  { 2635, 14, 15, 12, -1, -15 },
  { 2662, 16, 22, 12, -2, -15 },
  { 2706, 12, 15, 10, -1, -15 },
  { 2729, 12, 24, 10, 0, -20 },
  { 2765, 4, 28, 11, 3, -22 },
  { 2779, 11, 24, 10, -2, -20 },
  { 2812, 12, 5, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC28PT7B_H_
