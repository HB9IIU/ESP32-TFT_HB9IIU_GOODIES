#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x76, 0x66, 0x60, 0xCC, 0x7D, 0x6D, 0xB6, 0x1A, 0x2C, 0x53,
  0xF2, 0xC5, 0x7F, 0x2C, 0x59, 0xA0, 0x08, 0x38, 0xFB, 0xA7, 0x07, 0x07,
  0x0E, 0xE9, 0xF0, 0x81, 0x00, 0x73, 0x79, 0x2D, 0x97, 0x8A, 0xBF, 0xF4,
  0x5A, 0x6B, 0x25, 0x33, 0x80, 0x1C, 0x36, 0x34, 0x3C, 0x39, 0x7E, 0xDE,
  0xDC, 0xFC, 0x7E, 0x6F, 0x60, 0x19, 0x88, 0xC6, 0x23, 0x18, 0xC6, 0x31,
  0x80, 0x10, 0xC6, 0x31, 0x88, 0xC6, 0x33, 0x19, 0x80, 0x32, 0xCF, 0x8F,
  0xF1, 0x60, 0x21, 0x3F, 0xF2, 0x10, 0x76, 0x6C, 0x7F, 0xF0, 0x07, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x1C, 0xF6, 0xDB, 0x6D,
  0xBC, 0xF6, 0xF9, 0xC0, 0x19, 0xFE, 0xE3, 0x18, 0xC6, 0x63, 0x00, 0x3D,
  0xF2, 0xC3, 0x18, 0x63, 0x18, 0xFB, 0xE0, 0x3C, 0xF0, 0xC3, 0x38, 0xE1,
  0xC6, 0xFB, 0xC0, 0x0C, 0x31, 0xCF, 0x6D, 0x6F, 0xFF, 0x18, 0xC0, 0x3E,
  0x78, 0x83, 0x07, 0x8B, 0x83, 0x0C, 0xF9, 0xE0, 0x1E, 0x78, 0xC3, 0x47,
  0xCD, 0xB3, 0x66, 0x78, 0xE0, 0x3E, 0xFC, 0x30, 0x61, 0x83, 0x0C, 0x18,
  0x61, 0xC0, 0x3C, 0x7D, 0x93, 0x63, 0x8F, 0x33, 0x66, 0xF8, 0xE0, 0x3C,
  0xF6, 0xDB, 0x6D, 0xF2, 0xC6, 0xFB, 0xC0, 0x27, 0x20, 0x00, 0xCC, 0x11,
  0xC4, 0x00, 0x01, 0x8C, 0x66, 0x00, 0x0B, 0xF9, 0xC3, 0x84, 0xF8, 0x01,
  0xF0, 0xC3, 0xC3, 0xCE, 0xE2, 0x00, 0x39, 0xF0, 0xC6, 0x31, 0x86, 0x00,
  0x63, 0x00, 0x0F, 0x08, 0xC9, 0x2D, 0xD5, 0xAA, 0xB7, 0x5B, 0xBE, 0xC0,
  0x21, 0x0F, 0x00, 0x0E, 0x1C, 0x78, 0xF1, 0x66, 0xCF, 0xBF, 0x67, 0xCC,
  0x3C, 0x7C, 0xDB, 0x37, 0xCF, 0x9B, 0x76, 0xFD, 0xF0, 0x1E, 0x7C, 0xC3,
  0x06, 0x0C, 0x38, 0x70, 0x78, 0xF0, 0x3C, 0x7C, 0xDB, 0x36, 0x6C, 0xD9,
  0xF6, 0xFD, 0xE0, 0x3C, 0xF3, 0x18, 0x79, 0xE6, 0x38, 0xFB, 0xC0, 0x3C,
  0xF3, 0x18, 0x79, 0xE6, 0x38, 0xC3, 0x00, 0x1F, 0x3E, 0x30, 0x60, 0x6E,
  0x6E, 0xE6, 0x66, 0x7C, 0x7C, 0x33, 0x33, 0x33, 0x66, 0x7E, 0x7E, 0x66,
  0xEE, 0xCC, 0xCC, 0x3E, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x31, 0xF0,
  0x0C, 0x30, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x3C, 0xE0, 0x33, 0x36,
  0x3C, 0x6C, 0x78, 0x78, 0x78, 0xFC, 0xCC, 0xCC, 0x31, 0x8C, 0xC6, 0x31,
  0x9C, 0xFF, 0x80, 0x38, 0xE7, 0x38, 0xE7, 0x3D, 0xE7, 0xAC, 0xFF, 0x1F,
  0xE6, 0xEC, 0xDD, 0x9B, 0x70, 0x31, 0x9D, 0x8E, 0xCF, 0x67, 0xB3, 0xD1,
  0xB9, 0x9C, 0xCE, 0x67, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0x67, 0x66, 0xE6,
  0x6E, 0x7C, 0x78, 0x3C, 0x7C, 0xDB, 0x36, 0xEF, 0x9C, 0x70, 0xC1, 0x80,
  0x1E, 0x3F, 0x73, 0x63, 0x67, 0x66, 0xE6, 0x6E, 0x7C, 0x78, 0x18, 0x1C,
  0x3C, 0x7C, 0xDB, 0x36, 0xCF, 0x1E, 0x6C, 0xCD, 0x98, 0x3E, 0xF9, 0x83,
  0x87, 0x07, 0x06, 0x4C, 0xF9, 0xE0, 0xFF, 0xF3, 0x18, 0x61, 0x86, 0x18,
  0xC3, 0x00, 0x33, 0x33, 0x76, 0x66, 0x66, 0x66, 0x66, 0xEC, 0x7C, 0x78,
  0xC7, 0x9B, 0x36, 0x6D, 0x9B, 0x3C, 0x78, 0xE1, 0xC0, 0xCC, 0xF3, 0x3D,
  0xDB, 0x76, 0xDD, 0xBF, 0xCF, 0xF3, 0xB8, 0xEE, 0x33, 0x80, 0x3B, 0x8D,
  0x87, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x6C, 0x77, 0x00, 0xCF, 0x99,
  0xE3, 0xC7, 0x0E, 0x18, 0x30, 0x61, 0x80, 0x1F, 0x3E, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x70, 0x7C, 0xFC, 0x1C, 0x43, 0x0C, 0x30, 0xC2, 0x18, 0x61,
  0x86, 0x3C, 0xC9, 0x36, 0xDB, 0x64, 0x3C, 0x61, 0x86, 0x18, 0x43, 0x0C,
  0x30, 0xC2, 0x38, 0x18, 0x63, 0x8B, 0x6F, 0x30, 0xF8, 0xCD, 0x80, 0x36,
  0xFD, 0xB3, 0x6C, 0xD9, 0xBE, 0x3C, 0x30, 0xC3, 0x1B, 0x7D, 0xB6, 0xDB,
  0xCF, 0xEF, 0x80, 0x1D, 0xE6, 0x18, 0xC3, 0x0F, 0x1C, 0x06, 0x0C, 0x19,
  0xB7, 0xED, 0x9B, 0x66, 0xCD, 0xF1, 0xA0, 0x19, 0xF6, 0xDF, 0xF3, 0x0E,
  0x9E, 0x07, 0x0E, 0x0C, 0x1E, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x30, 0xB0, 0xE0, 0x36, 0xFD, 0xB3, 0x6C, 0xD9, 0xBE, 0x3C, 0x19, 0x73,
  0xC0, 0x30, 0xC3, 0x1B, 0x7D, 0xB6, 0xDB, 0xCF, 0x2D, 0x80, 0x33, 0x06,
  0x66, 0x66, 0xCC, 0xC0, 0x0C, 0x30, 0x06, 0x18, 0x61, 0x86, 0x30, 0xC3,
  0x0C, 0xF3, 0x80, 0x30, 0x60, 0xC3, 0x36, 0xCF, 0x1E, 0x3C, 0xF9, 0xB3,
  0x70, 0x33, 0x36, 0x66, 0x66, 0xCC, 0xC0, 0x6D, 0xBF, 0xDB, 0x6D, 0xB6,
  0xDE, 0x6F, 0x67, 0xB6, 0x6D, 0xF6, 0xDB, 0x6F, 0x3C, 0xB6, 0x19, 0xF6,
  0xDB, 0xCF, 0x3F, 0x9C, 0x36, 0x7C, 0xD9, 0xB3, 0x6C, 0xDF, 0x3E, 0x60,
  0xC3, 0x00, 0x36, 0xFD, 0xB3, 0x6C, 0xD9, 0xBE, 0x3C, 0x18, 0x30, 0xE0,
  0x6B, 0xDC, 0xC6, 0x63, 0x18, 0x3B, 0xD8, 0xE3, 0x1F, 0xDE, 0x31, 0xDE,
  0xC6, 0x31, 0x9E, 0x70, 0x66, 0xC9, 0xB3, 0x66, 0xD9, 0xBE, 0x34, 0xCF,
  0x6D, 0xBC, 0xF3, 0x8E, 0x30, 0xD9, 0xED, 0xBE, 0xDF, 0x4E, 0xE7, 0x73,
  0x31, 0xB8, 0x37, 0x36, 0x3C, 0x1C, 0x18, 0x3C, 0x6C, 0xEC, 0x33, 0x36,
  0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0x30, 0xF0, 0xE0, 0x3E, 0x78, 0x30,
  0xC3, 0x06, 0x1E, 0x7C, 0x1C, 0x63, 0x0C, 0x33, 0x8E, 0x18, 0x61, 0x86,
  0x18, 0xFF, 0xFC, 0x38, 0xE1, 0x86, 0x18, 0x71, 0x8C, 0x31, 0xCE, 0x38,
  0xE7, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 6, 4, 6, 1, -10 },
  { 9, 7, 10, 7, 0, -10 },
  { 18, 7, 12, 6, 0, -11 },
  { 29, 9, 10, 10, 1, -10 },
  { 41, 8, 10, 8, 0, -10 },
  { 51, 3, 4, 3, 1, -10 },
  { 53, 5, 12, 4, 0, -10 },
  { 61, 5, 12, 4, -1, -10 },
  { 69, 6, 6, 6, 1, -11 },
  { 74, 5, 6, 7, 1, -8 },
  { 78, 4, 4, 3, -1, -2 },
  { 80, 4, 2, 4, 0, -5 },
  { 81, 2, 2, 3, 0, -2 },
  { 82, 8, 10, 5, -1, -10 },
  { 92, 6, 10, 6, 0, -10 },
  { 100, 5, 10, 6, 1, -10 },
  { 107, 6, 10, 6, 0, -10 },
  { 115, 6, 10, 6, 0, -10 },
  { 123, 6, 10, 6, 0, -10 },
  { 131, 7, 10, 6, 0, -10 },
  { 140, 7, 10, 6, 0, -10 },
  { 149, 7, 10, 6, 0, -10 },
  { 158, 7, 10, 6, 0, -10 },
  { 167, 6, 10, 6, 0, -10 },
  { 175, 4, 8, 4, 0, -8 },
  { 179, 5, 10, 4, -1, -8 },
  { 186, 5, 6, 7, 1, -8 },
  { 190, 5, 4, 7, 1, -7 },
  { 193, 6, 6, 7, 1, -8 },
  { 198, 6, 10, 5, 0, -10 },
  { 206, 9, 11, 9, 0, -10 },
  { 219, 7, 10, 7, -1, -10 },
  { 228, 7, 10, 7, 0, -10 },
  { 237, 7, 10, 6, 0, -10 },
  { 246, 7, 10, 7, 0, -10 },
  { 255, 6, 10, 6, 0, -10 },
  { 263, 6, 10, 6, 0, -10 },
  { 271, 8, 10, 8, 0, -10 },
  { 281, 8, 10, 8, 0, -10 },
  { 291, 7, 10, 5, -1, -10 },
  { 300, 6, 13, 4, -2, -10 },
  { 310, 8, 10, 7, 0, -10 },
  { 320, 5, 10, 5, 0, -10 },
  { 327, 11, 10, 10, 0, -10 },
  { 341, 9, 10, 8, 0, -10 },
  { 353, 8, 10, 8, 0, -10 },
  { 363, 7, 10, 7, 0, -10 },
  { 372, 8, 12, 8, 0, -10 },
  { 384, 7, 10, 7, 0, -10 },
  { 393, 7, 10, 6, 0, -10 },
  { 402, 6, 10, 6, 1, -10 },
  { 410, 8, 10, 7, 0, -10 },
  { 420, 7, 10, 7, 1, -10 },
  { 429, 10, 10, 10, 1, -10 },
  { 442, 9, 10, 7, -1, -10 },
  { 454, 7, 10, 6, 1, -10 },
  { 463, 8, 10, 6, -1, -10 },
  { 473, 6, 12, 4, -1, -10 },
  { 482, 3, 10, 5, 1, -10 },
  { 486, 6, 12, 4, -1, -10 },
  { 495, 6, 6, 6, 0, -10 },
  { 500, 5, 1, 5, -1, 1 },
  { 501, 3, 3, 4, 2, -11 },
  { 503, 7, 8, 7, 0, -8 },
  { 510, 6, 11, 7, 0, -11 },
  { 519, 6, 8, 5, 0, -8 },
  { 525, 7, 11, 7, 0, -11 },
  { 535, 6, 8, 6, 0, -8 },
  { 541, 8, 14, 4, -2, -11 },
  { 555, 7, 11, 7, 0, -8 },
  { 565, 6, 11, 7, 0, -11 },
  { 574, 4, 11, 3, 0, -11 },
  { 580, 6, 14, 3, -2, -11 },
  { 591, 7, 11, 6, 0, -11 },
  { 601, 4, 11, 3, 0, -11 },
  { 607, 9, 8, 10, 0, -8 },
  { 616, 6, 8, 7, 0, -8 },
  { 622, 6, 8, 6, 0, -8 },
  { 628, 7, 11, 7, -1, -8 },
  { 638, 7, 11, 7, 0, -8 },
  { 648, 5, 8, 5, 0, -8 },
  { 653, 5, 8, 5, 0, -8 },
  { 658, 5, 9, 4, 0, -9 },
  { 664, 7, 8, 7, 0, -8 },
  { 671, 6, 8, 6, 1, -8 },
  { 677, 9, 8, 9, 1, -8 },
  { 686, 8, 8, 6, -1, -8 },
  { 694, 8, 11, 6, -1, -8 },
  { 705, 7, 8, 5, -1, -8 },
  { 712, 6, 12, 5, 0, -10 },
  { 721, 1, 14, 5, 2, -11 },
  { 723, 6, 12, 5, -1, -10 },
  { 732, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC14PT7B_H_
