#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x7B, 0xDE, 0xE7, 0x39, 0xCE,
  0x77, 0xBD, 0xCE, 0x70, 0x03, 0xB8, 0x19, 0x81, 0xCC, 0x0E, 0xE0, 0x67,
  0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x1C, 0xC0, 0xEE, 0x06, 0x71, 0xFF, 0xEF,
  0xFE, 0x19, 0xC1, 0xCC, 0x0E, 0xE0, 0x67, 0x07, 0x30, 0x00, 0x00, 0x80,
  0x10, 0x07, 0xE0, 0xFF, 0x1F, 0xE3, 0xF4, 0x3A, 0x03, 0xE0, 0x1E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x05, 0xC4, 0x5C, 0x67, 0xCF, 0xF8, 0xFF, 0x87,
  0xE0, 0x08, 0x01, 0x80, 0x1E, 0x0E, 0x1F, 0x8E, 0x0F, 0xC7, 0x0E, 0xE7,
  0x06, 0x73, 0x83, 0x3B, 0x83, 0x99, 0x81, 0xDD, 0xCE, 0xEE, 0xDF, 0xBE,
  0xEF, 0xDE, 0xEE, 0xE0, 0x77, 0x70, 0x73, 0x38, 0x39, 0x9C, 0x39, 0xCC,
  0x18, 0x6E, 0x1C, 0x3E, 0x1C, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0x80, 0xFF,
  0x07, 0xBC, 0x1E, 0xE0, 0x7B, 0x81, 0xFC, 0x03, 0xE0, 0x1F, 0x3C, 0xFE,
  0xE7, 0xFF, 0x9D, 0xFE, 0xF3, 0xF3, 0xCF, 0x8F, 0x3E, 0x3F, 0xF8, 0xFF,
  0xF1, 0xFB, 0xC0, 0x7B, 0xDC, 0xE7, 0x3B, 0x80, 0x07, 0x03, 0x83, 0x83,
  0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x80, 0x07, 0x03, 0x81,
  0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x00, 0x0E, 0x03,
  0x84, 0xE3, 0xF6, 0xFF, 0xCF, 0xF3, 0xE1, 0xF8, 0xF7, 0x09, 0xE0, 0x40,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x3B, 0xDC, 0xEF, 0x70, 0x7E, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x87, 0xF1, 0xFC,
  0xF7, 0x79, 0xDE, 0x77, 0x1F, 0xC7, 0xF3, 0xFC, 0xFE, 0x3F, 0x8E, 0xE7,
  0xB9, 0xEE, 0xF3, 0xFC, 0xFE, 0x1F, 0x00, 0x03, 0x87, 0xC7, 0xE7, 0xE7,
  0xF7, 0xF9, 0xBC, 0x9E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x00, 0x03, 0xE0, 0xFF, 0x1F, 0xF0, 0xCF, 0x08, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0xFC, 0xFF, 0xCF, 0xFC, 0x0F, 0xC1, 0xFE, 0x1F, 0xE1,
  0x9F, 0x00, 0xE0, 0x1E, 0x01, 0xE1, 0xFC, 0x1F, 0x01, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x87, 0x8F, 0xF8, 0xFF, 0x0F, 0xE0, 0x00, 0xF0,
  0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xFC, 0x0D, 0xC1, 0xFC, 0x3B, 0xC3,
  0x3C, 0x73, 0x8F, 0xFE, 0xFF, 0xEF, 0xFC, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xF8, 0x3F, 0xC3, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x87, 0x8F,
  0xF8, 0xFF, 0x0F, 0xE0, 0x03, 0xE1, 0xFC, 0x7F, 0x8F, 0x03, 0xC0, 0xF0,
  0x1E, 0xC3, 0xFC, 0xFF, 0x9F, 0xFB, 0xCF, 0x79, 0xEE, 0x39, 0xCF, 0x39,
  0xE7, 0xF8, 0xFF, 0x0F, 0x80, 0x3F, 0xF3, 0xFE, 0x3F, 0xE4, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0xFE, 0x1F,
  0xF1, 0xCF, 0x3C, 0xF3, 0xCE, 0x1D, 0xE1, 0xFC, 0x0F, 0x81, 0xF8, 0x7F,
  0xC7, 0xBC, 0xF1, 0xCF, 0x1C, 0xF3, 0xCF, 0xF8, 0x7F, 0x83, 0xE0, 0x07,
  0xC1, 0xFC, 0x7F, 0x9E, 0xF3, 0xCE, 0x71, 0xCE, 0x7B, 0xCF, 0x79, 0xE7,
  0xFC, 0xFF, 0x0E, 0xE0, 0x3C, 0x0F, 0x01, 0xE7, 0xF8, 0xFE, 0x1F, 0x80,
  0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C, 0xF3, 0x80, 0x0E,
  0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x8E, 0x1C,
  0x78, 0xE0, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xE7, 0xF1, 0xF0, 0x3E, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xC1, 0xF8, 0xFE, 0x7E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x1F,
  0x3F, 0xDF, 0xEC, 0xF0, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E,
  0x00, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x70, 0x00, 0x01, 0xF8, 0x07, 0xFC,
  0x0F, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x33, 0xF7, 0x77, 0xF7, 0x66, 0x77,
  0xEE, 0x67, 0xCE, 0x66, 0xCC, 0xE6, 0xCC, 0xEE, 0xCC, 0xEC, 0xCF, 0xFC,
  0xCF, 0x78, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xE0, 0x7F, 0xE0, 0x1F, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3B, 0x81, 0xDC, 0x1E, 0xE0,
  0xE7, 0x07, 0x78, 0x7B, 0xC3, 0x9E, 0x3F, 0xF1, 0xFF, 0x9F, 0xFC, 0xF1,
  0xE7, 0x0F, 0x78, 0x7F, 0xC3, 0xC0, 0x0F, 0xC0, 0xFF, 0x87, 0xFC, 0x3D,
  0xF1, 0xC7, 0x8E, 0x38, 0xF3, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x1E, 0x78,
  0xF3, 0xC7, 0x9E, 0x38, 0xF1, 0xCF, 0x9F, 0xF8, 0xFF, 0x87, 0xF8, 0x00,
  0x07, 0xE0, 0xFF, 0x1F, 0xE3, 0xE6, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0x0F, 0xF0,
  0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x87, 0xFC, 0x3D, 0xF1, 0xC7, 0x8E,
  0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F,
  0x3C, 0xF1, 0xCF, 0x9F, 0xF8, 0xFF, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xFC,
  0x7F, 0x8F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xFE, 0x3F, 0x87, 0xF1, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0xF8, 0xFF, 0x1F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x7F, 0x8F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE2, 0x3F, 0x87, 0xF1,
  0xFE, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x03,
  0xF0, 0x7F, 0xC7, 0xFC, 0x7C, 0x63, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF3, 0xF7, 0x9F, 0xBC, 0xF9, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9F,
  0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x0E, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xF1,
  0xE1, 0xC3, 0xC3, 0x87, 0x0F, 0x1E, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF1,
  0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1C, 0x3C, 0x78, 0x70, 0xF1,
  0xE1, 0xE3, 0xC0, 0x0F, 0xE3, 0xFC, 0x3F, 0x03, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01,
  0xF0, 0xFF, 0x1F, 0xE0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x07, 0xE1, 0xF8, 0x3E, 0x00,
  0x0E, 0x3E, 0x3C, 0x78, 0x79, 0xE0, 0xF7, 0x81, 0xCF, 0x03, 0xBC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xBC,
  0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF1, 0xC1, 0xE3, 0xC0, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xC3, 0xFE, 0xFF, 0x7F, 0x80, 0x0F, 0x03, 0xE3, 0xE0, 0xFC,
  0x7C, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x8F, 0xE7, 0xE1,
  0xDC, 0xFC, 0x3B, 0xBB, 0x87, 0x77, 0xF1, 0xEF, 0xDE, 0x3D, 0xFB, 0x87,
  0xBE, 0x70, 0xE7, 0xDE, 0x1C, 0xFB, 0xC7, 0x9E, 0x78, 0xF3, 0xCE, 0x1C,
  0x73, 0xC0, 0x0F, 0x0E, 0x3E, 0x1C, 0x7C, 0x38, 0xF8, 0xF1, 0xF1, 0xE3,
  0xF3, 0x8F, 0xE7, 0x1D, 0xDE, 0x3B, 0xBC, 0x77, 0x71, 0xEF, 0xE3, 0xDF,
  0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7C, 0x78, 0xF8, 0xF1, 0xF1, 0xC1, 0xE0,
  0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x7D, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xEF,
  0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xF3, 0xCF,
  0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFC, 0x3D,
  0xF1, 0xC7, 0x8E, 0x3C, 0xF1, 0xC7, 0x9E, 0x3D, 0xF1, 0xFF, 0x1F, 0xF0,
  0xFE, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x7D, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xEF,
  0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xF3, 0xCF,
  0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0xC1, 0xFE, 0x1F, 0xF1, 0xEF, 0x1C, 0x71, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0xB8, 0x7B, 0x87, 0x3C, 0x73, 0xCF, 0x3C,
  0xF3, 0xCF, 0x1E, 0x07, 0xE1, 0xFF, 0x1F, 0xE3, 0xEE, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC8, 0x38,
  0xC7, 0x8F, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x78, 0x1C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3,
  0x87, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xE3, 0x87, 0x3C, 0x79, 0xE3,
  0xCF, 0x1E, 0x78, 0xE3, 0xCF, 0x1F, 0xF0, 0x7F, 0x83, 0xF8, 0x00, 0xF0,
  0xFF, 0x0F, 0xF0, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x38, 0xF7,
  0x8F, 0x70, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3B, 0xCF, 0x9E, 0xF3,
  0xE7, 0xBC, 0xF9, 0xCF, 0x7E, 0xF3, 0x9F, 0xB8, 0xEE, 0xDE, 0x3B, 0xF7,
  0x8E, 0xFD, 0xC3, 0xF7, 0xF0, 0xFD, 0xFC, 0x3E, 0x7E, 0x0F, 0x9F, 0x83,
  0xE7, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x00, 0x0E, 0x3E, 0x1E, 0x78, 0x3D,
  0xE0, 0x7B, 0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xB8, 0x0E, 0x70, 0x3C,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC0, 0xF0, 0xFF, 0x1E, 0x71, 0xC7, 0x3C, 0x73,
  0x87, 0x78, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0xF8, 0xFF, 0xC7,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x03, 0xF0, 0xFC, 0x3E, 0x00, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x70, 0x07, 0xC3, 0xF0, 0xFC,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC1, 0xF0, 0xFC, 0x3F, 0x00,
  0x01, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0x71, 0xCE, 0x78,
  0xEE, 0x1F, 0x83, 0x80, 0xFF, 0xFF, 0xC0, 0xF7, 0x9C, 0x70, 0x0E, 0x71,
  0xF7, 0x3F, 0xF3, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1E, 0xF1, 0xCF,
  0x3C, 0xF3, 0xCF, 0xFC, 0x7F, 0xC7, 0xB8, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x3B, 0x8F, 0xF9, 0xFF, 0x3C, 0xE7, 0x1C, 0xE3, 0xBC, 0x77,
  0x9E, 0xE3, 0xDC, 0x77, 0x9E, 0xFF, 0xDF, 0xF3, 0xBC, 0x00, 0x07, 0x87,
  0xF3, 0xFC, 0xF2, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x11,
  0xFC, 0x7F, 0x0F, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x07, 0x38, 0x7F, 0xC7, 0xFE, 0x3D, 0xE3, 0xCF, 0x1E, 0x78, 0xE3, 0xC7,
  0x1E, 0x78, 0xE3, 0xC7, 0x1E, 0x78, 0x7F, 0xC3, 0xFC, 0x1E, 0xE0, 0x07,
  0x83, 0xF8, 0x7F, 0x9E, 0x77, 0x9E, 0xF7, 0x9F, 0xF3, 0xF8, 0xF0, 0x1E,
  0x01, 0xC2, 0x3F, 0xC7, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0x80, 0x3C, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00,
  0x07, 0xB8, 0x7D, 0xC7, 0xFE, 0x3D, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7,
  0x1E, 0x78, 0xE3, 0xCF, 0x1E, 0x78, 0xFF, 0xC3, 0xFE, 0x1E, 0xE0, 0x07,
  0x00, 0x78, 0x83, 0xC7, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x3B, 0x8F, 0xF9, 0xFF, 0x3D, 0xE7, 0x1C, 0xE7,
  0xBC, 0xF7, 0x9E, 0xE3, 0x9C, 0x77, 0x9E, 0xF3, 0xDE, 0x7B, 0x8E, 0x00,
  0x0E, 0x3C, 0x78, 0x60, 0x03, 0x8F, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8F,
  0x1C, 0x78, 0xF1, 0xE3, 0x80, 0x01, 0xC0, 0xF0, 0x3C, 0x06, 0x00, 0x00,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x0F, 0x83, 0xE0, 0xF0,
  0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x3C, 0xF3,
  0xC7, 0xBC, 0x3B, 0xC1, 0xDC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x1E, 0xF0, 0xF3, 0x87, 0x9E, 0x38, 0xF0, 0x0E, 0x3C, 0x78, 0xF1,
  0xC3, 0x8F, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE3,
  0x80, 0x19, 0xC7, 0x1D, 0xFF, 0xCF, 0xFF, 0xE7, 0xBE, 0xF3, 0x9E, 0x79,
  0xCF, 0x3D, 0xE7, 0x9C, 0xF3, 0x8E, 0x71, 0xCF, 0x39, 0xE7, 0xBC, 0xF3,
  0xDE, 0x79, 0xCF, 0x38, 0xE7, 0x1C, 0xF0, 0x19, 0xC7, 0x7C, 0xFF, 0x9E,
  0xF3, 0x8E, 0x73, 0xDE, 0x7B, 0xCF, 0x71, 0xCE, 0x39, 0xCF, 0x79, 0xEF,
  0x3D, 0xC7, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x9E, 0xF7, 0x8E, 0xF3, 0xDC,
  0x7B, 0x8F, 0x71, 0xFE, 0x39, 0xCF, 0x3F, 0xC7, 0xF8, 0x7C, 0x00, 0x06,
  0x70, 0x77, 0xC3, 0xFE, 0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x78, 0xE3, 0xCF,
  0x1C, 0x78, 0xE3, 0x8F, 0xBC, 0x7F, 0xE3, 0xFE, 0x1D, 0xE0, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x00, 0x0F, 0x71, 0xF7, 0x3F,
  0xF3, 0xDE, 0x79, 0xE7, 0x9E, 0x71, 0xE7, 0x1E, 0xF1, 0xCF, 0x1C, 0xF3,
  0xCF, 0xFC, 0x7F, 0x87, 0xB8, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x19, 0xCE, 0xE3, 0xF8, 0xFE, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x0F, 0x0F, 0xF3, 0xF9,
  0xE2, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xC8, 0xF3, 0xFC, 0xFE,
  0x3F, 0x00, 0x0C, 0x1C, 0x1C, 0x3F, 0x7E, 0xFE, 0x78, 0x78, 0x70, 0x70,
  0xF0, 0xF0, 0xF0, 0xE0, 0xFC, 0xFC, 0x7C, 0x39, 0xEF, 0x3D, 0xE7, 0xB8,
  0xE7, 0x1C, 0xE7, 0xBC, 0xF7, 0x9C, 0xE3, 0x9C, 0xF3, 0x9E, 0x7F, 0xCF,
  0xF1, 0xEE, 0x00, 0xE3, 0xF8, 0xEE, 0x7B, 0x9E, 0xE7, 0x3B, 0xCE, 0xE3,
  0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x73, 0xC7, 0x73,
  0xCF, 0x73, 0xCF, 0x77, 0xCE, 0xF7, 0xDE, 0xFF, 0xDC, 0xFF, 0xDC, 0xFF,
  0xFC, 0xFD, 0xF8, 0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1,
  0xE0, 0x1E, 0x78, 0xF7, 0x87, 0xBC, 0x3F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xF7, 0x87, 0x3C, 0x79, 0xE0,
  0x0E, 0x3C, 0x38, 0xF0, 0xE7, 0x83, 0x9E, 0x0E, 0x70, 0x3B, 0xC0, 0xEE,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x1F,
  0xE3, 0xFC, 0x7F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x81, 0xE0, 0x3F, 0xCF, 0xF1, 0xFE, 0x00, 0x01, 0xC1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x0F, 0x87,
  0xC1, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0xC1, 0xE1, 0xF1, 0xF8,
  0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x1F, 0x0F, 0x07, 0x00, 0x78, 0x3F,
  0xFF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 8, 18, 6, 0, -18 },
  { 19, 10, 7, 11, 2, -18 },
  { 28, 13, 18, 13, 0, -18 },
  { 58, 12, 20, 11, 0, -19 },
  { 88, 17, 18, 19, 1, -18 },
  { 127, 14, 18, 14, 0, -18 },
  { 159, 5, 7, 6, 2, -18 },
  { 164, 9, 22, 7, 0, -18 },
  { 189, 9, 22, 7, -2, -18 },
  { 214, 10, 11, 11, 2, -19 },
  { 228, 11, 12, 12, 1, -15 },
  { 245, 5, 6, 6, -1, -3 },
  { 249, 7, 3, 7, 0, -8 },
  { 252, 4, 4, 6, 0, -4 },
  { 254, 13, 18, 10, -1, -18 },
  { 284, 10, 18, 11, 1, -18 },
  { 307, 9, 18, 11, 2, -18 },
  { 328, 12, 18, 11, -1, -18 },
  { 355, 12, 18, 11, 0, -18 },
  { 382, 12, 18, 11, 0, -18 },
  { 409, 12, 18, 11, 0, -18 },
  { 436, 11, 18, 11, 1, -18 },
  { 461, 12, 18, 11, 1, -18 },
  { 488, 12, 18, 11, 0, -18 },
  { 515, 11, 18, 11, 0, -18 },
  { 540, 6, 14, 6, 0, -14 },
  { 551, 7, 17, 6, -1, -14 },
  { 566, 11, 12, 12, 1, -15 },
  { 583, 11, 8, 12, 1, -13 },
  { 594, 11, 12, 12, 1, -15 },
  { 611, 9, 18, 9, 1, -18 },
  { 632, 16, 20, 17, 1, -18 },
  { 672, 13, 18, 12, -2, -18 },
  { 702, 13, 18, 12, 0, -18 },
  { 732, 12, 18, 11, 1, -18 },
  { 759, 13, 18, 13, 0, -18 },
  { 789, 11, 18, 10, 0, -18 },
  { 814, 11, 18, 10, 0, -18 },
  { 839, 13, 18, 13, 1, -18 },
  { 869, 15, 18, 14, 0, -18 },
  { 903, 11, 18, 9, -1, -18 },
  { 928, 11, 23, 7, -4, -18 },
  { 960, 15, 18, 12, 0, -18 },
  { 994, 9, 18, 10, 0, -18 },
  { 1015, 19, 18, 18, 0, -18 },
  { 1058, 15, 18, 15, 0, -18 },
  { 1092, 13, 18, 14, 1, -18 },
  { 1122, 13, 18, 12, 0, -18 },
  { 1152, 13, 22, 14, 1, -18 },
  { 1188, 12, 18, 12, 0, -18 },
  { 1215, 12, 18, 11, 0, -18 },
  { 1242, 10, 18, 10, 2, -18 },
  { 1265, 13, 18, 13, 1, -18 },
  { 1295, 12, 18, 12, 2, -18 },
  { 1322, 18, 18, 18, 2, -18 },
  { 1363, 15, 18, 12, -1, -18 },
  { 1397, 12, 18, 11, 2, -18 },
  { 1424, 13, 18, 10, -1, -18 },
  { 1454, 10, 22, 7, -1, -18 },
  { 1482, 6, 18, 10, 2, -18 },
  { 1496, 10, 22, 7, -2, -18 },
  { 1524, 11, 11, 11, 0, -18 },
  { 1540, 9, 2, 9, -2, 2 },
  { 1543, 5, 4, 8, 4, -19 },
  { 1546, 12, 14, 12, 0, -14 },
  { 1567, 11, 19, 12, 0, -19 },
  { 1594, 10, 14, 10, 0, -14 },
  { 1612, 13, 19, 12, 0, -19 },
  { 1643, 11, 14, 11, 0, -14 },
  { 1663, 13, 25, 7, -3, -19 },
  { 1704, 13, 20, 12, -1, -14 },
  { 1737, 11, 19, 12, 0, -19 },
  { 1764, 7, 19, 6, 0, -19 },
  { 1781, 10, 25, 6, -3, -19 },
  { 1813, 13, 19, 11, 0, -19 },
  { 1844, 7, 19, 6, 0, -19 },
  { 1861, 17, 14, 17, 0, -14 },
  { 1891, 11, 14, 12, 0, -14 },
  { 1911, 11, 14, 12, 0, -14 },
  { 1931, 13, 20, 12, -2, -14 },
  { 1964, 12, 20, 12, 0, -14 },
  { 1994, 10, 14, 8, 0, -14 },
  { 2012, 10, 14, 9, 0, -14 },
  { 2030, 8, 17, 8, 1, -17 },
  { 2047, 11, 14, 12, 1, -14 },
  { 2067, 10, 14, 11, 2, -14 },
  { 2085, 16, 14, 16, 1, -14 },
  { 2113, 13, 14, 11, -1, -14 },
  { 2136, 14, 20, 11, -2, -14 },
  { 2171, 11, 14, 9, -1, -14 },
  { 2191, 10, 22, 9, 0, -18 },
  { 2219, 3, 25, 10, 3, -19 },
  { 2229, 9, 22, 9, -1, -18 },
  { 2254, 11, 4, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC25PT7B_H_
