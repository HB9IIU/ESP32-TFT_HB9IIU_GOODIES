#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x7E, 0x7D, 0xF9, 0xF7, 0xCF,
  0xDF, 0x3F, 0xFC, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF9, 0xF3, 0xC7,
  0xC0, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3C, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x81, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF3, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xB3, 0x03,
  0xEC, 0x40, 0xFB, 0x00, 0x3E, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xBF, 0x10, 0x27, 0xC6, 0x1B, 0xE1, 0xF7, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0x01, 0xFE, 0x07,
  0xC0, 0xFF, 0xC1, 0xE0, 0x3C, 0xF0, 0xF0, 0x1E, 0x3C, 0x3C, 0x07, 0x8F,
  0x1E, 0x01, 0xE3, 0xC7, 0x80, 0xF9, 0xF3, 0xC0, 0x3C, 0x79, 0xF0, 0x0F,
  0x1E, 0x78, 0x03, 0xCF, 0xBE, 0x7C, 0xF3, 0xCF, 0x3F, 0xBF, 0xF7, 0xDF,
  0xFF, 0xF9, 0xE7, 0xFD, 0xFC, 0xF3, 0xCF, 0x3E, 0x3C, 0xF3, 0xC0, 0x1E,
  0x78, 0xF0, 0x0F, 0x9E, 0x3C, 0x03, 0xC7, 0x8F, 0x01, 0xF1, 0xE7, 0xC0,
  0x78, 0xF9, 0xE0, 0x3E, 0x3C, 0x78, 0x0F, 0x0F, 0x3E, 0x07, 0x83, 0xFF,
  0x01, 0xE0, 0x7F, 0x80, 0xF0, 0x1F, 0xE0, 0x7C, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE3,
  0xF0, 0xFF, 0x8F, 0x87, 0xFF, 0x7E, 0x3F, 0xFD, 0xF1, 0xFB, 0xFF, 0xC7,
  0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC3,
  0xF8, 0x3F, 0xBF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xF1, 0xF8, 0x7E, 0xFD, 0xF3, 0xE7, 0xDF, 0xBE, 0x7C, 0xF9, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x82, 0x1E, 0x07, 0x3C, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFE, 0x1F, 0xFC, 0x7F, 0x81, 0xFF, 0x07, 0xFF, 0x0F, 0x9F, 0x0F,
  0x3E, 0x0C, 0x78, 0x08, 0x40, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x8F, 0x87, 0xC7, 0xE3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xEF, 0xFC, 0x7C, 0xFB, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0xFC, 0x7E, 0x7E, 0x3E, 0x3F, 0x3F,
  0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xCF, 0xC3, 0xE7, 0xE1, 0xF3, 0xE1, 0xF9,
  0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F, 0x0F,
  0xCF, 0x87, 0xC7, 0xC7, 0xE3, 0xE7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xDF, 0x1C, 0xF8,
  0x4F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x1F, 0xC0, 0xC1, 0xF8, 0x10, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0x83,
  0xF0, 0x40, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x08,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x88, 0x0F, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xF7,
  0xC0, 0x3F, 0xF0, 0x1E, 0xFC, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xE3, 0xE0,
  0xF1, 0xF8, 0x3C, 0x7E, 0x1E, 0x1F, 0x0F, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x21, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x20, 0x1F, 0x8C, 0x0F, 0xE3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE7, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F,
  0x8F, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFF, 0x0F, 0xEF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F,
  0x0F, 0x8F, 0xC3, 0xE7, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x7E, 0x1F, 0x8F, 0x87, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF1, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0x03,
  0xEF, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x03, 0x83, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x3E, 0x00, 0x00, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xE3,
  0x0F, 0xC8, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x3E,
  0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x1F, 0x8F, 0x1E, 0x1F, 0xF3, 0x8E,
  0x1F, 0xF1, 0xCF, 0x1E, 0x78, 0xE7, 0x1E, 0x3C, 0x77, 0x8F, 0x1E, 0x7B,
  0xCF, 0x1E, 0x3D, 0xC7, 0x8F, 0x1F, 0xE3, 0xC7, 0x8E, 0xF3, 0xC3, 0xC7,
  0x79, 0xE3, 0xC7, 0xBC, 0xF1, 0xE3, 0x9E, 0x79, 0xF3, 0xCF, 0x3F, 0xFF,
  0xC7, 0x8F, 0xFF, 0xC3, 0xC7, 0xE7, 0xC1, 0xE0, 0x40, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x07, 0xE1, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x7C, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0xF8,
  0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F,
  0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xC3, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x83, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7C, 0xFF, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7F,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xE0, 0xFC, 0x7E, 0x1F,
  0xC7, 0xE3, 0xF8, 0x7E, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xF8, 0x30, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE1, 0xFE, 0x3F, 0x1F,
  0xF1, 0xF8, 0xFF, 0x8F, 0xC7, 0xFC, 0x7E, 0x3F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7C,
  0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0x80, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0xF7, 0xC1, 0xF7, 0xCF, 0xFE, 0x0F, 0xBE, 0x7B, 0xF0, 0x7D, 0xF7, 0xDF,
  0x03, 0xEF, 0xBE, 0xF8, 0x3F, 0x7F, 0xEF, 0xC1, 0xF3, 0xFF, 0x7E, 0x0F,
  0x9F, 0xF3, 0xE0, 0x7C, 0xFF, 0x9F, 0x07, 0xE7, 0xF8, 0xF8, 0x3F, 0x3F,
  0xCF, 0xC1, 0xF1, 0xFC, 0x7E, 0x0F, 0x8F, 0xE3, 0xE0, 0x7C, 0x7F, 0x1F,
  0x07, 0xE3, 0xF1, 0xF8, 0x3F, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF8, 0x3E,
  0x07, 0xF8, 0x3E, 0x07, 0xF8, 0x3E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E,
  0x0F, 0xFC, 0x7C, 0x0F, 0xFC, 0x7C, 0x0F, 0xFC, 0x7C, 0x1F, 0x7C, 0xFC,
  0x1F, 0x7C, 0xF8, 0x1F, 0x7C, 0xF8, 0x1F, 0x3E, 0xF8, 0x1F, 0x3E, 0xF8,
  0x3F, 0x3F, 0xF8, 0x3E, 0x3F, 0xF0, 0x3E, 0x3F, 0xF0, 0x3E, 0x3F, 0xF0,
  0x7E, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7C, 0x1F, 0xE0, 0x7C, 0x1F, 0xE0,
  0x7C, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x3F, 0x3F, 0x81, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7C, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x3F, 0x3F, 0x81, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x8F, 0xC7,
  0xE1, 0xFB, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC,
  0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xE7, 0x83, 0xF8, 0x20, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0xC0, 0x7E, 0x1C, 0x3F, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0x01,
  0xFB, 0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x7E, 0x3E, 0x0F,
  0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE3, 0xF0, 0x7C, 0x7E,
  0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x1F, 0xBF, 0x07,
  0xE0, 0xFD, 0xF8, 0x3F, 0x07, 0xCF, 0xC3, 0xF8, 0x7E, 0x7E, 0x1F, 0xC3,
  0xF3, 0xF0, 0xFE, 0x3F, 0x1F, 0x8F, 0xF1, 0xF8, 0xFC, 0x7F, 0x8F, 0x87,
  0xE7, 0xFC, 0xFC, 0x3F, 0x3F, 0xE7, 0xE1, 0xF9, 0xFE, 0x3E, 0x0F, 0x9F,
  0xF3, 0xF0, 0x7C, 0xF7, 0x9F, 0x03, 0xEF, 0xBD, 0xF8, 0x1F, 0x7D, 0xEF,
  0xC0, 0xFB, 0xCF, 0x7C, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7E,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F,
  0xDF, 0x87, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xF3, 0xF0, 0xF9, 0xF0, 0x7D,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x0F, 0x0F, 0x83, 0xE3,
  0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xF0, 0x7F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0xFD, 0xF9, 0xF3, 0xF3, 0xE3, 0xC0, 0x03,
  0xC0, 0x01, 0xF9, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xCF,
  0xE7, 0xE1, 0xF9, 0xF8, 0x7C, 0x7E, 0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8,
  0xFE, 0x3F, 0x7F, 0x0F, 0xFF, 0xC3, 0xFD, 0xF0, 0x7F, 0x7C, 0x0F, 0x9E,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xCE, 0x03, 0xEF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xDF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFB, 0xF8, 0x3C, 0xFC, 0x00, 0x00, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC7, 0xF1, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x21, 0xFD, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x03,
  0xCF, 0xC0, 0x7E, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xF3, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E,
  0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0xDF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0x7C, 0x03, 0xE7, 0x80, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x3F, 0x7C, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x18, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x9F, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0xFE, 0x0F, 0x87, 0xE1, 0xF8, 0x7C,
  0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x3F, 0x83, 0xF7,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFB, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x08, 0x0F, 0xC0, 0xF1, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xCE, 0x03, 0xEF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xF7, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x0F,
  0x8F, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x1F, 0x87, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF1,
  0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x80, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3E, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x10, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8,
  0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x00, 0x00, 0x8E, 0x07, 0x03, 0xCF, 0xE7, 0xE0, 0xF7, 0xFB,
  0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xF7, 0xFB, 0xF1, 0xF8,
  0xFC, 0x7C, 0x7C, 0x3E, 0x1F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF3,
  0xF1, 0xF0, 0xFC, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x9F, 0x8F, 0xC7,
  0xE7, 0xE3, 0xF1, 0xF9, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F,
  0x87, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0xF8, 0x7C, 0x3E, 0x3E,
  0x1F, 0x0F, 0x80, 0x00, 0x0E, 0x03, 0xCF, 0xC0, 0xF7, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF1, 0xF8,
  0xF8, 0x7E, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x7E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8,
  0x7E, 0xF8, 0xFC, 0xFD, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x00, 0x03, 0x80, 0x3E, 0xFC, 0x03, 0xDF, 0xE0, 0x3D, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFD, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3E, 0xFE, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xF9, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xCF, 0xE3, 0xE1, 0xF9, 0xF8,
  0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E,
  0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0xFC, 0x3F, 0x7F, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xBE, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x1F, 0x7C, 0x3D, 0xF8, 0x7B,
  0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xF1, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC7, 0xE1, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x81, 0xF9, 0xEF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x8F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7F, 0x43, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x8F,
  0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3,
  0xE1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xE3, 0xF3, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFD, 0xF0, 0x7E, 0x78, 0x00,
  0xFC, 0x1F, 0xFE, 0x1F, 0xBF, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF3, 0xF0, 0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x7F, 0x1F,
  0xFE, 0x3F, 0x8F, 0xBF, 0x1F, 0xC7, 0xDF, 0x9F, 0xE7, 0xEF, 0xCF, 0xF3,
  0xE7, 0xEF, 0xF9, 0xF3, 0xE7, 0xF9, 0xF1, 0xF3, 0xFC, 0xF8, 0xFB, 0xFE,
  0xFC, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBE, 0x1F, 0xFB, 0xFE, 0x0F, 0xF9,
  0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xC3, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x07,
  0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x01,
  0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xBF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x07, 0xFA, 0x00, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 28, 10, 0, -28 },
  { 43, 14, 10, 16, 4, -28 },
  { 61, 21, 28, 20, 0, -28 },
  { 135, 18, 32, 17, 0, -30 },
  { 207, 26, 28, 29, 2, -28 },
  { 298, 22, 28, 22, 0, -28 },
  { 375, 7, 10, 9, 4, -28 },
  { 384, 14, 34, 11, 0, -28 },
  { 444, 13, 35, 11, -3, -29 },
  { 501, 15, 17, 17, 3, -30 },
  { 533, 16, 19, 19, 2, -23 },
  { 571, 9, 10, 10, -2, -5 },
  { 583, 11, 5, 12, 0, -13 },
  { 590, 7, 6, 10, 0, -6 },
  { 596, 20, 28, 15, -2, -28 },
  { 666, 17, 28, 17, 1, -28 },
  { 726, 13, 28, 18, 4, -28 },
  { 772, 19, 28, 17, -1, -28 },
  { 839, 18, 28, 17, 0, -28 },
  { 902, 18, 28, 18, 0, -28 },
  { 965, 18, 28, 17, 0, -28 },
  { 1028, 18, 28, 17, 1, -28 },
  { 1091, 19, 28, 17, 1, -28 },
  { 1158, 18, 28, 17, 0, -28 },
  { 1221, 18, 28, 17, 0, -28 },
  { 1284, 10, 22, 10, 0, -22 },
  { 1312, 12, 27, 10, -2, -22 },
  { 1353, 17, 18, 19, 1, -23 },
  { 1392, 16, 13, 19, 2, -20 },
  { 1418, 16, 18, 19, 2, -23 },
  { 1454, 15, 28, 14, 1, -28 },
  { 1507, 25, 31, 26, 1, -28 },
  { 1604, 19, 28, 19, -2, -28 },
  { 1671, 20, 28, 19, 0, -28 },
  { 1741, 19, 28, 18, 1, -28 },
  { 1808, 20, 28, 21, 0, -28 },
  { 1878, 18, 28, 16, 0, -28 },
  { 1941, 18, 28, 15, 0, -28 },
  { 2004, 21, 28, 21, 1, -28 },
  { 2078, 23, 28, 21, 0, -28 },
  { 2159, 18, 28, 13, -2, -28 },
  { 2222, 18, 36, 10, -6, -28 },
  { 2303, 23, 28, 19, 0, -28 },
  { 2384, 13, 28, 15, 0, -28 },
  { 2430, 29, 28, 28, 0, -28 },
  { 2532, 24, 28, 23, 0, -28 },
  { 2616, 21, 28, 22, 1, -28 },
  { 2690, 20, 28, 18, 0, -28 },
  { 2760, 21, 35, 22, 1, -28 },
  { 2852, 19, 28, 19, 0, -28 },
  { 2919, 19, 28, 16, -1, -28 },
  { 2986, 16, 28, 16, 3, -28 },
  { 3042, 21, 28, 21, 1, -28 },
  { 3116, 19, 28, 19, 4, -28 },
  { 3183, 29, 28, 28, 3, -28 },
  { 3285, 23, 28, 18, -2, -28 },
  { 3366, 17, 28, 18, 4, -28 },
  { 3426, 21, 28, 16, -2, -28 },
  { 3500, 16, 34, 11, -2, -28 },
  { 3568, 8, 28, 15, 4, -28 },
  { 3596, 16, 34, 11, -3, -28 },
  { 3664, 18, 18, 17, 0, -28 },
  { 3705, 15, 4, 14, -4, 3 },
  { 3713, 7, 6, 12, 6, -30 },
  { 3719, 18, 22, 18, 1, -22 },
  { 3769, 18, 30, 18, 0, -30 },
  { 3837, 15, 22, 15, 1, -22 },
  { 3879, 20, 30, 18, 1, -30 },
  { 3954, 16, 22, 17, 1, -22 },
  { 3998, 20, 39, 11, -4, -30 },
  { 4096, 20, 31, 18, -1, -22 },
  { 4174, 18, 30, 18, 0, -30 },
  { 4242, 11, 30, 9, 0, -30 },
  { 4284, 16, 39, 9, -5, -30 },
  { 4362, 20, 30, 18, 0, -30 },
  { 4437, 11, 30, 9, 0, -30 },
  { 4479, 26, 22, 27, 0, -22 },
  { 4551, 18, 22, 18, 0, -22 },
  { 4601, 16, 22, 18, 1, -22 },
  { 4645, 20, 31, 18, -2, -22 },
  { 4723, 18, 31, 18, 1, -22 },
  { 4793, 15, 22, 13, 0, -22 },
  { 4835, 15, 22, 15, 0, -22 },
  { 4877, 13, 26, 12, 1, -26 },
  { 4920, 18, 21, 18, 1, -21 },
  { 4968, 17, 21, 17, 2, -21 },
  { 5013, 25, 21, 25, 2, -21 },
  { 5079, 21, 21, 17, -2, -21 },
  { 5135, 22, 30, 17, -3, -21 },
  { 5218, 17, 21, 14, -2, -21 },
  { 5263, 16, 34, 13, 0, -28 },
  { 5331, 5, 39, 15, 5, -30 },
  { 5356, 15, 34, 13, -2, -28 },
  { 5420, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC39PT7B_H_
