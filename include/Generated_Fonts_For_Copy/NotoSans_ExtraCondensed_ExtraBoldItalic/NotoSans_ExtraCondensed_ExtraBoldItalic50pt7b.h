#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x3F,
  0x9F, 0xEF, 0xF3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE,
  0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x3F,
  0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xF6, 0x78, 0x07, 0xE6, 0x18, 0x07, 0xE6, 0x00, 0x07,
  0xEE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x37, 0xF0, 0x00,
  0x37, 0xF0, 0x40, 0x33, 0xF0, 0x20, 0x37, 0xF0, 0x78, 0x77, 0xF0, 0x7E,
  0x6F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0x80, 0x7C, 0x03, 0xFF, 0xE0, 0x7E, 0x01, 0xF3, 0xF0, 0x3E, 0x01,
  0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0xFC, 0x3F, 0x00, 0x7C, 0x7E, 0x1F, 0x00,
  0x7E, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x8F, 0xC0,
  0x0F, 0x87, 0xC7, 0xC0, 0x07, 0xC7, 0xE7, 0xE0, 0x03, 0xE3, 0xE3, 0xE1,
  0xF1, 0xF1, 0xF3, 0xE3, 0xFC, 0xF9, 0xFB, 0xF3, 0xFF, 0x7F, 0xF9, 0xF3,
  0xFF, 0xBF, 0xF9, 0xF9, 0xFF, 0xFF, 0xFC, 0xF9, 0xF9, 0xF7, 0xFC, 0xFC,
  0xF8, 0xF9, 0xF8, 0x7C, 0xFC, 0x7C, 0x00, 0x7E, 0x7C, 0x3E, 0x00, 0x3E,
  0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x8F, 0xC0, 0x1F,
  0x0F, 0x87, 0xC0, 0x1F, 0x87, 0xC3, 0xE0, 0x0F, 0x83, 0xE3, 0xF0, 0x0F,
  0xC1, 0xF1, 0xF0, 0x07, 0xC0, 0xF8, 0xF8, 0x07, 0xE0, 0x7F, 0xF8, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x01,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0x07, 0xFF, 0x8F, 0xE0, 0xFF,
  0xF8, 0xFE, 0x1F, 0xFF, 0xDF, 0xC3, 0xFF, 0xFD, 0xFC, 0x3F, 0x9F, 0xFF,
  0x87, 0xF1, 0xFF, 0xF8, 0x7F, 0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0xF0, 0xFE,
  0x0F, 0xFE, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0x00,
  0x00, 0x00, 0x3F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE,
  0x7F, 0x3F, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x20, 0x7C,
  0x07, 0x1F, 0x80, 0xF3, 0xF0, 0x5F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x3F, 0x07, 0xC7, 0xF0, 0x78, 0xFC,
  0x06, 0x0F, 0x00, 0x41, 0x80, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFC, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0x80, 0x1E, 0x7F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F,
  0x9F, 0xC1, 0xFE, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xCF, 0xF0, 0xFF, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xDF, 0xC7, 0xDF, 0xE1, 0xCF, 0xE0, 0xC7, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xF3, 0xFE, 0x01, 0xE0, 0xFF, 0x00, 0xE0, 0x7F, 0x80,
  0x20, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x78, 0xFF, 0x80, 0xC0, 0xFF, 0x01,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x08, 0x01, 0xFE, 0x1C,
  0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3D, 0xFC, 0x00,
  0x7D, 0xFC, 0x00, 0xFB, 0xF8, 0x00, 0xFB, 0xF8, 0x01, 0xF3, 0xF8, 0x03,
  0xE3, 0xF8, 0x03, 0xE7, 0xF0, 0x07, 0xC7, 0xF0, 0x0F, 0x87, 0xF0, 0x1F,
  0x87, 0xF0, 0x1F, 0x07, 0xF0, 0x3E, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x38, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x0C, 0x01, 0xFE, 0x1E, 0x0F,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x81, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x20, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE7, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFD, 0xFE,
  0x0F, 0xE3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xE1, 0xFC, 0x3F,
  0xE7, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFE, 0x7F, 0x07, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3,
  0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F,
  0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC7, 0xFC, 0x3F, 0xDF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x01,
  0xFD, 0xFC, 0x00, 0xE3, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x10, 0x1F, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE,
  0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0x80, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xC7,
  0xF8, 0x60, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x7F, 0x07, 0x83, 0xF0, 0xFF, 0xF3, 0xE1, 0xF0, 0xFF,
  0xF1, 0xF1, 0xF0, 0xFF, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x78, 0x7C,
  0x3E, 0x3E, 0x7C, 0x7E, 0x3E, 0x1E, 0x3E, 0x3E, 0x1F, 0x0F, 0x3E, 0x1F,
  0x0F, 0x8F, 0x9F, 0x1F, 0x07, 0xC7, 0xCF, 0x8F, 0x87, 0xC3, 0xE7, 0xC7,
  0xC3, 0xE1, 0xE3, 0xC7, 0xE1, 0xF0, 0xF3, 0xE3, 0xE1, 0xF8, 0xF9, 0xF1,
  0xF0, 0xF8, 0x78, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x7E, 0x7E, 0x7C, 0x3E,
  0x3F, 0xFF, 0xFE, 0x1F, 0x0F, 0xFF, 0xFE, 0x0F, 0x87, 0xF9, 0xFE, 0x07,
  0xC1, 0xF8, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x0F, 0xC0, 0x03, 0x00,
  0x03, 0xFE, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03,
  0xFB, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xE3, 0xFE,
  0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xCF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xF8, 0x7F, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFE, 0x78, 0x0F, 0xF8, 0x08, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x80, 0xFF, 0x87,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFF,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x83, 0xF8,
  0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xF1, 0xF0, 0x1F, 0xF0,
  0x08, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x87, 0xFF, 0x1F, 0xC3, 0xFF, 0xCF, 0xF0, 0xFF,
  0xE3, 0xFC, 0x3F, 0xF8, 0xFF, 0x0F, 0xFE, 0x3F, 0xC3, 0xFF, 0x8F, 0xF0,
  0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE,
  0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01,
  0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF9,
  0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x7E, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x3F, 0xFE, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0xFD, 0xFC, 0x07, 0xF7, 0xE7,
  0xE7, 0xF0, 0x1F, 0xDF, 0x9F, 0xBF, 0x80, 0x7F, 0x7E, 0xFC, 0xFE, 0x01,
  0xFD, 0xFB, 0xF3, 0xF8, 0x0F, 0xE7, 0xFF, 0x8F, 0xE0, 0x3F, 0x8F, 0xFE,
  0x7F, 0x80, 0xFE, 0x3F, 0xF9, 0xFC, 0x03, 0xF8, 0xFF, 0xC7, 0xF0, 0x0F,
  0xC3, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xE3,
  0xF8, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFE,
  0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xC1,
  0xFC, 0x03, 0xFF, 0x83, 0xF8, 0x0F, 0xFF, 0x07, 0xF0, 0x1F, 0xFE, 0x0F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xC0, 0x7F, 0xFC, 0x7F, 0x00, 0xFF, 0xF8, 0xFE,
  0x03, 0xFB, 0xF1, 0xFC, 0x07, 0xF7, 0xE3, 0xF8, 0x0F, 0xEF, 0xC7, 0xE0,
  0x1F, 0x9F, 0x9F, 0xC0, 0x3F, 0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0x7F, 0x01,
  0xFC, 0x7E, 0xFE, 0x03, 0xF8, 0xFD, 0xF8, 0x07, 0xE1, 0xFB, 0xF0, 0x1F,
  0xC3, 0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0xC0, 0x7F, 0x0F, 0xFF, 0x80, 0xFE,
  0x0F, 0xFE, 0x01, 0xF8, 0x1F, 0xFC, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0x80, 0x7E, 0x01,
  0xFF, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xCF,
  0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE,
  0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC,
  0x3F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE7, 0xFE, 0x07, 0xF0, 0xFF,
  0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0xBF, 0x80, 0x3F, 0x9F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF1, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE,
  0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xF8, 0x38, 0x07, 0xF8, 0x04, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x0C, 0x01, 0xFE, 0x07, 0x01, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x03, 0xFD,
  0xFE, 0x03, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC0, 0x7F, 0x9F, 0xC0, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0xC7,
  0xF0, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xC3, 0xFC, 0x1F,
  0xC3, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0xF1,
  0xFC, 0x07, 0xF1, 0xFF, 0xC7, 0xF0, 0x1F, 0xCF, 0xFF, 0x3F, 0xC0, 0x7F,
  0x3F, 0xFC, 0xFE, 0x01, 0xFC, 0xFF, 0xF3, 0xF8, 0x07, 0xF7, 0xEF, 0xDF,
  0xE0, 0x1F, 0xDF, 0xBF, 0x7F, 0x00, 0x7F, 0xFC, 0xFD, 0xFC, 0x01, 0xFB,
  0xF3, 0xFF, 0xE0, 0x07, 0xEF, 0xCF, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F,
  0xC7, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC,
  0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F,
  0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xF7, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x43, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFD,
  0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF9, 0xF8, 0x03, 0xF1, 0xFC, 0x07, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x1F, 0xE7, 0xF8,
  0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0xFC,
  0x1F, 0xFB, 0xF8, 0x3F, 0xF7, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xF9, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF1, 0xFE,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xC7, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0x01,
  0xFC, 0x7C, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0xF0, 0x03, 0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFF, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7E, 0xFF, 0xC0, 0x7E, 0xFF, 0x80, 0x7C, 0x7F, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xF1, 0x81, 0xFC, 0x08, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x02, 0x0F, 0xF0, 0x60, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x3E, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xEF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFD, 0xF8, 0x07, 0xFC, 0xFC, 0x01,
  0xFC, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0x9F, 0xC1, 0xFC, 0xFE,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x43, 0xFC, 0x1E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x02, 0x3F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xCF,
  0xC0, 0x3F, 0xEF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81,
  0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x10, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x80, 0x1F,
  0xC0, 0x70, 0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0xF8, 0x03, 0xFB, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFD, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x09, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF3, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x7E,
  0x7F, 0x8F, 0xF0, 0x0F, 0xDF, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xE7,
  0xF8, 0x3F, 0xC7, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0xCF, 0xF0, 0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0x9F,
  0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xE0, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xE1,
  0xFE, 0x7F, 0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0x3F, 0xC0, 0x0F, 0xDF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xF8,
  0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFD, 0xFF, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x82, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFC, 0xFC, 0x0F, 0xFB, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F,
  0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7E, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0x7F, 0x01, 0xFD, 0xFC, 0x00, 0x43, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x83,
  0xF7, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xF0, 0x60, 0xFE, 0x04, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x88, 0x07,
  0xF1, 0x81, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x18, 0x00,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xF3, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xEF, 0xC0,
  0xFF, 0x9F, 0x80, 0xFE, 0x3E, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFE, 0x1F, 0xF0, 0xFE, 0xFE, 0x1F, 0xF0, 0xFE, 0xFE, 0x3F, 0xF1, 0xFC,
  0xFE, 0x3F, 0xF1, 0xFC, 0xFE, 0x3F, 0xF1, 0xF8, 0xFE, 0x7F, 0xE3, 0xF8,
  0xFE, 0x7F, 0xE3, 0xF8, 0xFE, 0x7F, 0xE3, 0xF0, 0xFE, 0xFF, 0xE7, 0xF0,
  0xFC, 0xFB, 0xE7, 0xE0, 0xFD, 0xFB, 0xEF, 0xE0, 0xFD, 0xFB, 0xEF, 0xE0,
  0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x80,
  0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x3F, 0x87, 0xF8, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xEF,
  0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x4F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x00, 0x7F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xF0, 0x07, 0xFE, 0x80, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 37, 13, 0, -36 },
  { 71, 19, 13, 21, 5, -36 },
  { 102, 27, 36, 25, 0, -36 },
  { 224, 24, 41, 22, 0, -38 },
  { 347, 33, 36, 37, 3, -36 },
  { 496, 28, 37, 28, 0, -36 },
  { 626, 9, 13, 12, 5, -36 },
  { 641, 17, 44, 14, 1, -36 },
  { 735, 17, 45, 14, -4, -37 },
  { 831, 19, 22, 21, 4, -38 },
  { 884, 21, 24, 24, 2, -30 },
  { 947, 12, 14, 12, -3, -7 },
  { 968, 14, 7, 15, 0, -17 },
  { 981, 8, 9, 12, 0, -8 },
  { 990, 27, 36, 19, -3, -36 },
  { 1112, 22, 37, 22, 1, -36 },
  { 1214, 17, 36, 23, 5, -36 },
  { 1291, 25, 36, 22, -2, -36 },
  { 1404, 23, 37, 22, 0, -36 },
  { 1511, 24, 36, 23, -1, -36 },
  { 1619, 23, 37, 22, 0, -36 },
  { 1726, 23, 37, 22, 1, -36 },
  { 1833, 24, 36, 22, 1, -36 },
  { 1941, 23, 37, 22, 0, -36 },
  { 2048, 23, 37, 22, 0, -36 },
  { 2155, 13, 29, 13, 0, -28 },
  { 2203, 16, 35, 13, -3, -28 },
  { 2273, 21, 24, 24, 2, -30 },
  { 2336, 21, 17, 24, 2, -26 },
  { 2381, 21, 24, 24, 2, -30 },
  { 2444, 19, 37, 18, 1, -36 },
  { 2532, 33, 40, 34, 1, -36 },
  { 2697, 25, 36, 25, -3, -36 },
  { 2810, 25, 36, 25, 0, -36 },
  { 2923, 24, 37, 23, 2, -36 },
  { 3034, 26, 36, 26, 0, -36 },
  { 3151, 23, 36, 20, 0, -36 },
  { 3255, 23, 36, 20, 0, -36 },
  { 3359, 26, 37, 27, 2, -36 },
  { 3480, 29, 36, 27, 0, -36 },
  { 3611, 23, 36, 17, -2, -36 },
  { 3715, 23, 47, 13, -8, -36 },
  { 3851, 29, 36, 24, 0, -36 },
  { 3982, 17, 36, 20, 0, -36 },
  { 4059, 38, 36, 36, 0, -36 },
  { 4230, 31, 36, 29, 0, -36 },
  { 4370, 26, 37, 28, 2, -36 },
  { 4491, 25, 36, 24, 0, -36 },
  { 4604, 26, 45, 28, 2, -36 },
  { 4751, 25, 36, 24, 0, -36 },
  { 4864, 25, 37, 21, -1, -36 },
  { 4980, 20, 36, 21, 4, -36 },
  { 5070, 26, 37, 26, 2, -36 },
  { 5191, 24, 36, 24, 5, -36 },
  { 5299, 38, 36, 36, 3, -36 },
  { 5470, 30, 36, 23, -3, -36 },
  { 5605, 22, 36, 23, 5, -36 },
  { 5704, 26, 36, 21, -2, -36 },
  { 5821, 20, 44, 14, -2, -36 },
  { 5931, 11, 36, 19, 5, -36 },
  { 5981, 21, 44, 14, -4, -36 },
  { 6097, 24, 23, 22, -1, -36 },
  { 6166, 19, 4, 18, -5, 4 },
  { 6176, 10, 8, 16, 7, -38 },
  { 6186, 23, 29, 24, 1, -28 },
  { 6270, 24, 39, 24, -1, -38 },
  { 6387, 20, 29, 19, 1, -28 },
  { 6460, 25, 39, 24, 1, -38 },
  { 6582, 21, 29, 22, 1, -28 },
  { 6659, 26, 50, 15, -6, -38 },
  { 6822, 25, 40, 24, -1, -28 },
  { 6947, 24, 38, 24, -1, -38 },
  { 7061, 15, 38, 12, -1, -38 },
  { 7133, 20, 50, 12, -6, -38 },
  { 7258, 26, 38, 23, -1, -38 },
  { 7382, 16, 38, 12, -1, -38 },
  { 7458, 35, 28, 35, -1, -28 },
  { 7581, 23, 28, 24, 0, -28 },
  { 7662, 21, 29, 23, 1, -28 },
  { 7739, 26, 40, 24, -3, -28 },
  { 7869, 23, 40, 24, 1, -28 },
  { 7984, 19, 28, 17, 0, -28 },
  { 8051, 19, 29, 19, 0, -28 },
  { 8120, 15, 34, 16, 2, -33 },
  { 8184, 23, 28, 24, 1, -27 },
  { 8265, 21, 27, 21, 3, -27 },
  { 8336, 32, 27, 32, 3, -27 },
  { 8444, 27, 27, 22, -3, -27 },
  { 8536, 27, 39, 21, -3, -27 },
  { 8668, 22, 27, 18, -2, -27 },
  { 8743, 21, 44, 17, 0, -36 },
  { 8859, 6, 49, 19, 6, -38 },
  { 8896, 20, 44, 17, -3, -36 },
  { 9006, 21, 9, 24, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC50PT7B_H_
