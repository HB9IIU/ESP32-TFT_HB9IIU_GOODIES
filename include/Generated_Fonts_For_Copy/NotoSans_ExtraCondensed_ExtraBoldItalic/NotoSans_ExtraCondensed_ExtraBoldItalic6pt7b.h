#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x7F, 0xE0, 0x4D, 0x2C, 0x5F, 0x75, 0x6B, 0xF0, 0x80,
  0x6A, 0x80, 0x56, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A,
  0x40, 0x76, 0xE0, 0xEA, 0xE9, 0x60, 0x69, 0x60, 0x6B, 0xA0, 0x79, 0x60,
  0x7A, 0xE0, 0x69, 0x40, 0x6B, 0x60, 0x77, 0x60, 0xC8, 0xCA, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xDA, 0x7F, 0xFE, 0x6F, 0xD0, 0x7E, 0xE0, 0x72, 0x60,
  0x76, 0xE0, 0x7A, 0x60, 0x7A, 0x40, 0x72, 0xF0, 0x7E, 0xAA, 0x6A, 0x60,
  0x29, 0x2C, 0x6B, 0x50, 0x6B, 0x5A, 0xBD, 0xA0, 0x56, 0xAA, 0x76, 0xF0,
  0x77, 0x40, 0x76, 0xF6, 0x77, 0x70, 0x79, 0x60, 0xE9, 0x40, 0x76, 0xE0,
  0xFA, 0xAD, 0xBD, 0xC0, 0x69, 0x60, 0xEA, 0x6A, 0x60, 0x6A, 0x80, 0xF0,
  0x5A, 0x80, 0x54, 0xE0, 0x80, 0xF7, 0x00, 0x4A, 0xDC, 0xEC, 0x27, 0xDC,
  0xFB, 0x00, 0x25, 0x25, 0x80, 0xF7, 0x60, 0x4A, 0xDC, 0x5A, 0x80, 0x25,
  0x25, 0x80, 0x4B, 0xEC, 0x5A, 0x80, 0xFB, 0xD0, 0xF7, 0x00, 0xF7, 0x00,
  0xF7, 0x40, 0xF7, 0x20, 0xE8, 0xDC, 0x6B, 0xB7, 0x00, 0xBB, 0x00, 0xFE,
  0xA0, 0xEB, 0x00, 0xB9, 0x40, 0xEC, 0x5A, 0x80, 0xFC, 0xD6, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 3, 3, 3, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 1, 0, -1 },
  { 23, 3, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 1, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 2, 3, 2, 0, -3 },
  { 45, 2, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 4, 4, 4, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 2, 0, -4 },
  { 64, 3, 4, 2, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 4, 4, 3, 0, -4 },
  { 70, 3, 4, 2, 0, -4 },
  { 72, 3, 5, 2, -1, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 2, 4, 2, 0, -4 },
  { 77, 5, 4, 4, 0, -4 },
  { 80, 4, 4, 3, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 5, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 2, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 2, 4, 3, 1, -4 },
  { 97, 5, 4, 4, 0, -4 },
  { 100, 3, 4, 3, 0, -4 },
  { 102, 2, 4, 3, 1, -4 },
  { 103, 3, 4, 2, 0, -4 },
  { 105, 2, 5, 2, 0, -4 },
  { 107, 1, 4, 2, 1, -4 },
  { 108, 2, 5, 2, 0, -4 },
  { 110, 3, 2, 3, 0, -4 },
  { 111, 3, 1, 2, -1, 0 },
  { 112, 1, 1, 2, 1, -5 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 2, 3, 2, 0, -3 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 3, 3, 3, 0, -3 },
  { 122, 3, 6, 2, -1, -5 },
  { 125, 3, 4, 3, 0, -3 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 2, 5, 1, 0, -5 },
  { 131, 3, 6, 1, -1, -5 },
  { 134, 3, 5, 3, 0, -5 },
  { 136, 2, 5, 1, 0, -5 },
  { 138, 4, 3, 4, 0, -3 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 3, 4, 3, 0, -3 },
  { 146, 3, 4, 3, 0, -3 },
  { 148, 2, 3, 2, 0, -3 },
  { 149, 2, 3, 2, 0, -3 },
  { 150, 2, 4, 2, 0, -4 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 4, 3, 4, 0, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 3, 4, 3, 0, -3 },
  { 161, 2, 3, 2, 0, -3 },
  { 162, 2, 5, 2, 0, -4 },
  { 164, 1, 6, 2, 1, -5 },
  { 165, 2, 5, 2, 0, -4 },
  { 167, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC6PT7B_H_
