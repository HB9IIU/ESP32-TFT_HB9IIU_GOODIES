#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0,
  0x03, 0x00, 0x00, 0x7F, 0x1F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFE,
  0x7E, 0x3F, 0x3F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x07, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xEC, 0xE0, 0x1F, 0xB8,
  0xC0, 0x7F, 0x60, 0x00, 0xFE, 0xC0, 0x01, 0xFD, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1B, 0xF0, 0x00, 0x77, 0xE0, 0x40, 0xCF, 0xC1, 0xC1, 0x9F, 0x83, 0xE3,
  0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x10, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC,
  0x07, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3E, 0x7C, 0x0F, 0x80, 0x7C, 0x7C,
  0x1F, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x7E, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0xFC, 0x00, 0xF8, 0xF8,
  0xF8, 0x00, 0xF8, 0xF9, 0xF8, 0x00, 0xF8, 0xF9, 0xF0, 0xF8, 0xF1, 0xF3,
  0xE3, 0xFC, 0xFB, 0xF3, 0xE7, 0xFE, 0xFF, 0xE7, 0xCF, 0xFE, 0xFF, 0xE7,
  0xCF, 0xFE, 0xFF, 0xCF, 0x9F, 0x3F, 0x7F, 0x9F, 0x9F, 0x1F, 0x1E, 0x1F,
  0x3E, 0x1F, 0x00, 0x3F, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x7C,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x7C, 0x01, 0xF0, 0x7C, 0x7C, 0x03, 0xF0, 0x7C, 0x7C, 0x03, 0xE0,
  0x7E, 0xF8, 0x07, 0xE0, 0x7F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x20, 0x7F, 0xE3, 0xF8, 0x3F, 0xFC, 0x7F, 0x0F, 0xFF,
  0xCF, 0xC1, 0xFF, 0xFB, 0xF8, 0x7F, 0x7F, 0xFF, 0x1F, 0xCF, 0xFF, 0xC3,
  0xF8, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x3F,
  0xF0, 0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xBF,
  0xC0, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x61, 0xF8, 0x1E, 0x7C, 0x07, 0xDF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0xC1, 0xFD, 0xF8, 0xFF, 0x7E, 0x0F, 0x9F, 0xC1, 0xC3, 0xE0,
  0x30, 0xF0, 0x08, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x3F, 0xFC, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xFF,
  0xC0, 0x1C, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x30, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0xFE, 0x7F, 0x07,
  0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0, 0xFE, 0x7F,
  0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF, 0x1F, 0xBF, 0x87,
  0x9F, 0xC3, 0x8F, 0xE0, 0x87, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0x01, 0xF0,
  0xFF, 0x00, 0xE0, 0xFF, 0x00, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x10, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0x7F, 0xC0, 0x60, 0x7F, 0x01, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x20, 0x07, 0xF0, 0xC0, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7B, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xDF, 0xC0, 0x0F, 0xBF,
  0x00, 0x3E, 0x7E, 0x00, 0x79, 0xFC, 0x01, 0xF3, 0xF8, 0x07, 0xC7, 0xF0,
  0x1F, 0x0F, 0xC0, 0x3E, 0x3F, 0x80, 0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x07,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE4, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x41, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x88, 0x01, 0xFC, 0x38, 0x1F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xE1, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC2, 0x00, 0x7E,
  0x7E, 0x03, 0xFB, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x3F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7E, 0x07,
  0xF3, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF8,
  0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xFC, 0x7F,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xBF, 0x83, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F,
  0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F,
  0xC7, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xDF, 0xC0, 0x7E, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x03, 0x00, 0x00, 0x38,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0x7C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xF3, 0xFC, 0x30, 0x7F, 0x10, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x81,
  0xF8, 0x7C, 0x3E, 0x0F, 0xFC, 0x78, 0x7C, 0x3F, 0xF8, 0xF1, 0xF0, 0xFF,
  0xF1, 0xE3, 0xE3, 0xF3, 0xE3, 0xCF, 0x8F, 0x87, 0x87, 0x9F, 0x1F, 0x1F,
  0x0F, 0x3C, 0x7C, 0x3E, 0x3E, 0xF8, 0xF8, 0x7C, 0x7D, 0xF1, 0xF0, 0xF8,
  0xFB, 0xC7, 0xC3, 0xE1, 0xE7, 0x8F, 0x87, 0xC3, 0xDF, 0x1F, 0x0F, 0x8F,
  0xBE, 0x3E, 0x1F, 0x1E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF9, 0xF8, 0xF1,
  0xF1, 0xFF, 0xFF, 0xE3, 0xE3, 0xFF, 0xFF, 0x87, 0xC3, 0xF9, 0xFE, 0x0F,
  0x87, 0xE3, 0xF8, 0x1F, 0x01, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0xBF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7E,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC7,
  0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x18, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x30, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE3, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8,
  0x7F, 0x03, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xFE, 0x1F, 0xE3, 0xFE,
  0x0F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x1C, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xFC, 0x7F, 0x0F, 0xFE,
  0x7F, 0x87, 0xFE, 0x3F, 0xC3, 0xFF, 0x1F, 0xE3, 0xFF, 0x8F, 0xE1, 0xFF,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF8,
  0x7F, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x01, 0xF8, 0x3F,
  0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x80, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF8, 0xFD, 0xF8,
  0x0F, 0xDF, 0x8F, 0xFF, 0x80, 0xFD, 0xF8, 0xFB, 0xF8, 0x0F, 0xDF, 0x9F,
  0xBF, 0x81, 0xFD, 0xF9, 0xFB, 0xF0, 0x1F, 0xDF, 0xBF, 0x7F, 0x01, 0xF9,
  0xFB, 0xF7, 0xF0, 0x1F, 0x9F, 0xFE, 0x7F, 0x03, 0xF9, 0xFF, 0xE7, 0xF0,
  0x3F, 0x9F, 0xFC, 0x7E, 0x03, 0xF9, 0xFF, 0xCF, 0xE0, 0x3F, 0x1F, 0xF8,
  0xFE, 0x03, 0xF1, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xF8, 0xFC, 0x07, 0xF1,
  0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xF1, 0xFC, 0x07, 0xE1, 0xFE, 0x1F, 0xC0,
  0x7E, 0x1F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x03,
  0xF8, 0x0F, 0xFC, 0x0F, 0xC0, 0x3F, 0xF0, 0x3F, 0x01, 0xFF, 0xC1, 0xFC,
  0x07, 0xFF, 0x07, 0xF0, 0x1F, 0xFE, 0x1F, 0xC0, 0x7F, 0xF8, 0x7E, 0x01,
  0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0x8F, 0xE0, 0x3F, 0x7E, 0x3F, 0x80, 0xFD,
  0xF8, 0xFE, 0x03, 0xF7, 0xF3, 0xF0, 0x0F, 0xCF, 0xCF, 0xC0, 0x7F, 0x3F,
  0x7F, 0x01, 0xFC, 0xFD, 0xFC, 0x07, 0xE3, 0xF7, 0xE0, 0x1F, 0x8F, 0xDF,
  0x80, 0xFE, 0x3F, 0xFE, 0x03, 0xF8, 0x7F, 0xF8, 0x0F, 0xE1, 0xFF, 0xE0,
  0x3F, 0x07, 0xFF, 0x00, 0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0x7F, 0xF0, 0x1F,
  0xC0, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xE0,
  0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F,
  0xE7, 0xF8, 0x0F, 0xF3, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8,
  0x07, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x3F,
  0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3,
  0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F,
  0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03,
  0xFC, 0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x81, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF0,
  0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x38, 0x07, 0xF8, 0x08, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x40, 0x0F, 0xE0, 0x70, 0x1F, 0xE0, 0x7C, 0x3F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x81,
  0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F,
  0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x01,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0x0F, 0xE7,
  0xF0, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x81,
  0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x0F,
  0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xF8, 0x7F, 0x07,
  0xF1, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xF8, 0xFE, 0x07, 0xE3, 0xFF, 0x8F,
  0xE0, 0x7E, 0x3F, 0xF9, 0xFC, 0x07, 0xE7, 0xFF, 0x9F, 0xC0, 0x7E, 0x7F,
  0xF9, 0xF8, 0x07, 0xE7, 0xDF, 0xBF, 0x80, 0x7E, 0xFD, 0xFB, 0xF8, 0x07,
  0xEF, 0xDF, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFF,
  0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF,
  0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80,
  0xFC, 0xFE, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xEF, 0xE0, 0x07, 0xE0,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC7,
  0xF1, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x00, 0xF0, 0x00, 0x0F, 0xF3,
  0xF0, 0x7F, 0xCF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF9, 0xFE, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE,
  0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x3F, 0xC3, 0xFD, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x7F, 0xDF, 0x81, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC7, 0x00, 0x7F, 0x7F, 0x01, 0xFB, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F,
  0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0x87, 0xF9, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xF7, 0xFE, 0x0F, 0xDF, 0xF0, 0x3E, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xF8, 0xC1, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0x0F, 0xE0, 0xC1, 0xFF, 0x78, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xF1, 0xFC,
  0x03, 0xFD, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x87, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0,
  0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xDF, 0x80, 0x3F, 0x9F, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC7, 0xF3,
  0xF8, 0x3F, 0x3F, 0x87, 0xF7, 0xF0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0x0F, 0xF0,
  0x70, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x88,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x3F, 0x01, 0xFF, 0xBF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xF1, 0xFE,
  0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0,
  0x3F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x80, 0x3F, 0x80,
  0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xCF,
  0x00, 0x7F, 0x7F, 0x01, 0xFB, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC,
  0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0,
  0x00, 0x78, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F,
  0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x01, 0xE0, 0x38, 0x03, 0xE7, 0xF8, 0xFF, 0x01, 0xF7, 0xFE, 0xFF, 0xC0,
  0xFB, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xCF, 0xF9, 0xFC, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x1F, 0xC0, 0x7C, 0xFF, 0x81,
  0xF7, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC7, 0xF3,
  0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x3F, 0xCF, 0xF7,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x04, 0x38, 0x00, 0x7C, 0x7F, 0x00, 0x3E, 0x7F, 0xC0,
  0x1F, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xCF, 0xF0, 0x07,
  0xE7, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xF3, 0xF0, 0x3F, 0xEF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x87, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC3, 0xFD,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xDF, 0x81, 0xFF, 0xFE,
  0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x21, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xEF, 0xE0, 0xFD,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0xC0, 0xFE,
  0x08, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x88, 0x0F, 0xE1, 0xF7, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xFF,
  0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF0, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF9, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xDF, 0x80, 0xFE, 0x7E, 0x00, 0xFE,
  0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF,
  0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0xC0, 0xFD, 0xF8,
  0x0F, 0xDF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0xFE, 0xFC, 0x1F, 0xE1, 0xFD,
  0xF8, 0x7F, 0xC3, 0xF3, 0xF0, 0xFF, 0x8F, 0xE7, 0xE1, 0xFF, 0x1F, 0x8F,
  0xC7, 0xFE, 0x3F, 0x1F, 0x8F, 0xFC, 0xFE, 0x3F, 0x3F, 0xF9, 0xF8, 0x7E,
  0x7F, 0xE7, 0xF0, 0xFC, 0xFF, 0xCF, 0xC1, 0xFB, 0xFF, 0x9F, 0x83, 0xF7,
  0xDF, 0x7F, 0x07, 0xEF, 0xBE, 0xFC, 0x0F, 0xFE, 0x7D, 0xF8, 0x1F, 0xFC,
  0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7,
  0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F,
  0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F,
  0x81, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F,
  0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xF9, 0xFC,
  0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x17,
  0xFE, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 35, 12, 0, -34 },
  { 63, 18, 12, 20, 5, -34 },
  { 90, 25, 34, 24, 0, -34 },
  { 197, 23, 39, 21, 0, -36 },
  { 310, 32, 35, 36, 3, -35 },
  { 450, 27, 35, 27, 0, -35 },
  { 569, 9, 12, 12, 5, -34 },
  { 583, 16, 43, 13, 1, -35 },
  { 669, 17, 43, 13, -4, -35 },
  { 761, 18, 21, 20, 4, -37 },
  { 809, 20, 24, 23, 2, -29 },
  { 869, 12, 14, 12, -3, -7 },
  { 890, 14, 6, 14, 0, -16 },
  { 901, 8, 9, 12, 0, -8 },
  { 910, 26, 35, 18, -3, -35 },
  { 1024, 21, 35, 21, 1, -35 },
  { 1116, 17, 34, 22, 4, -34 },
  { 1189, 24, 35, 21, -2, -35 },
  { 1294, 22, 35, 21, 0, -35 },
  { 1391, 23, 34, 22, -1, -34 },
  { 1489, 22, 34, 21, 0, -34 },
  { 1583, 22, 35, 21, 1, -35 },
  { 1680, 23, 34, 21, 1, -34 },
  { 1778, 22, 35, 21, 0, -35 },
  { 1875, 22, 35, 21, 0, -35 },
  { 1972, 12, 28, 12, 0, -27 },
  { 2014, 15, 34, 12, -3, -27 },
  { 2078, 20, 23, 23, 2, -29 },
  { 2136, 20, 16, 23, 2, -25 },
  { 2176, 20, 23, 23, 2, -29 },
  { 2234, 18, 36, 17, 1, -35 },
  { 2315, 31, 39, 32, 1, -35 },
  { 2467, 24, 34, 24, -3, -34 },
  { 2569, 24, 34, 24, 0, -34 },
  { 2671, 23, 35, 22, 2, -35 },
  { 2772, 25, 34, 25, 0, -34 },
  { 2879, 22, 34, 20, 0, -34 },
  { 2973, 22, 34, 19, 0, -34 },
  { 3067, 25, 35, 26, 2, -35 },
  { 3177, 28, 34, 26, 0, -34 },
  { 3296, 22, 34, 16, -2, -34 },
  { 3390, 21, 44, 12, -7, -34 },
  { 3506, 28, 34, 23, 0, -34 },
  { 3625, 16, 34, 19, 0, -34 },
  { 3693, 36, 34, 34, 0, -34 },
  { 3846, 30, 34, 28, 0, -34 },
  { 3974, 25, 35, 27, 2, -35 },
  { 4084, 24, 34, 23, 0, -34 },
  { 4186, 25, 43, 27, 2, -35 },
  { 4321, 24, 34, 23, 0, -34 },
  { 4423, 24, 35, 20, -1, -35 },
  { 4528, 20, 34, 20, 3, -34 },
  { 4613, 25, 34, 25, 2, -34 },
  { 4720, 24, 34, 23, 4, -34 },
  { 4822, 36, 34, 35, 3, -34 },
  { 4975, 29, 34, 22, -3, -34 },
  { 5099, 22, 34, 22, 4, -34 },
  { 5193, 25, 34, 20, -2, -34 },
  { 5300, 19, 43, 14, -2, -35 },
  { 5403, 10, 35, 18, 5, -35 },
  { 5447, 20, 43, 14, -4, -35 },
  { 5555, 23, 21, 22, -1, -34 },
  { 5616, 18, 4, 17, -5, 4 },
  { 5625, 10, 8, 15, 7, -37 },
  { 5635, 22, 27, 23, 1, -27 },
  { 5710, 22, 36, 23, 0, -36 },
  { 5809, 19, 27, 18, 1, -27 },
  { 5874, 24, 36, 23, 1, -36 },
  { 5982, 20, 27, 21, 1, -27 },
  { 6050, 25, 49, 14, -5, -37 },
  { 6204, 24, 39, 23, -1, -27 },
  { 6321, 22, 36, 23, 0, -36 },
  { 6420, 14, 37, 11, 0, -37 },
  { 6485, 20, 49, 12, -6, -37 },
  { 6608, 24, 36, 22, 0, -36 },
  { 6716, 14, 36, 11, 0, -36 },
  { 6779, 33, 27, 33, 0, -27 },
  { 6891, 22, 27, 23, 0, -27 },
  { 6966, 20, 27, 22, 1, -27 },
  { 7034, 25, 38, 23, -3, -27 },
  { 7153, 22, 39, 23, 1, -27 },
  { 7261, 19, 27, 16, 0, -27 },
  { 7326, 19, 27, 18, 0, -27 },
  { 7391, 15, 32, 15, 2, -32 },
  { 7451, 22, 26, 23, 1, -26 },
  { 7523, 20, 26, 20, 3, -26 },
  { 7588, 31, 26, 31, 2, -26 },
  { 7689, 25, 26, 21, -2, -26 },
  { 7771, 26, 38, 21, -3, -26 },
  { 7895, 21, 26, 17, -2, -26 },
  { 7964, 20, 42, 16, 0, -34 },
  { 8069, 6, 48, 18, 6, -37 },
  { 8105, 19, 42, 16, -3, -34 },
  { 8205, 20, 8, 23, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC48PT7B_H_
