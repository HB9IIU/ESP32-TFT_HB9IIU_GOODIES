#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC0, 0x02,
  0x1E, 0x3C, 0x70, 0x77, 0x77, 0x77, 0xE7, 0xE6, 0xEE, 0x07, 0x60, 0x66,
  0x06, 0xE0, 0xEC, 0x0C, 0xC3, 0xFF, 0x7F, 0xE1, 0x98, 0x1B, 0x8F, 0xFC,
  0xFF, 0xCF, 0xFC, 0x77, 0x06, 0x60, 0x66, 0x0E, 0xE0, 0x01, 0x00, 0x80,
  0xFC, 0x7F, 0x3F, 0x8E, 0xA3, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x2E,
  0x4B, 0xBF, 0xCF, 0xF1, 0xF8, 0x10, 0x04, 0x00, 0x1C, 0x38, 0x7C, 0x61,
  0xF9, 0xC3, 0x73, 0x0E, 0xEE, 0x1D, 0xD8, 0x33, 0x76, 0x7E, 0xDE, 0xFB,
  0x7E, 0xE6, 0xCC, 0x19, 0xB8, 0x77, 0x70, 0xCE, 0xC3, 0x9D, 0x86, 0x3E,
  0x1C, 0x3C, 0x07, 0x80, 0xFC, 0x1D, 0xC1, 0xDC, 0x1D, 0xC1, 0xF8, 0x1F,
  0x81, 0xE0, 0x3E, 0x77, 0xFE, 0x77, 0xEE, 0x7C, 0xE3, 0xCF, 0xFC, 0xFF,
  0xC7, 0xDE, 0x77, 0x7E, 0xEE, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70,
  0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0xF0, 0x1C, 0x1C, 0xD8, 0xFF, 0xFF,
  0x3F, 0x7C, 0xEE, 0x6E, 0x08, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF,
  0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3B, 0x9C, 0xEE, 0x70, 0x7F, 0xFF,
  0xC0, 0x2F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0x0F, 0x0F, 0x8F, 0xEF, 0x77, 0x3B, 0x9F, 0x8F, 0xC7, 0xE7, 0xF3,
  0xB9, 0xDD, 0xEE, 0xE7, 0xF3, 0xF0, 0xF0, 0x07, 0x0F, 0x1E, 0x3E, 0xFE,
  0xEE, 0x5C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x07,
  0x81, 0xF8, 0x7F, 0x84, 0x70, 0x8E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0x1F, 0xE7, 0xFC, 0x0F, 0x87, 0xF1,
  0xFC, 0x47, 0x01, 0xC0, 0xF0, 0x78, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0x1E,
  0x87, 0x3F, 0xCF, 0xE3, 0xF0, 0x01, 0xC0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83,
  0xE1, 0xB8, 0xCE, 0x37, 0x19, 0xCF, 0xFB, 0xFE, 0xFF, 0x83, 0x80, 0xE0,
  0x38, 0x0F, 0xC7, 0xF1, 0xFC, 0x70, 0x18, 0x0E, 0x03, 0xF0, 0xFE, 0x3F,
  0x81, 0xE0, 0x38, 0x1E, 0x87, 0x3F, 0xCF, 0xE3, 0xF0, 0x07, 0xC3, 0xE1,
  0xF8, 0xE0, 0x78, 0x1C, 0x07, 0xF3, 0xFC, 0xF7, 0x39, 0xCE, 0x73, 0x9C,
  0xEF, 0x3F, 0x8F, 0xE1, 0xF0, 0x3F, 0xCF, 0xF7, 0xFC, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0x80, 0x07, 0x87, 0xF1, 0xFC, 0xE7, 0x39, 0xCE, 0xF1, 0xF8, 0x7C, 0x3F,
  0x1F, 0xE7, 0x3B, 0x8E, 0xE3, 0xBD, 0xCF, 0xF1, 0xF8, 0x0F, 0x07, 0xE3,
  0xFC, 0xE7, 0x39, 0xDE, 0x77, 0x3D, 0xEF, 0x7F, 0x8F, 0xE1, 0x38, 0x1C,
  0x0F, 0x3F, 0x8F, 0xE3, 0xE0, 0x38, 0xF3, 0x84, 0x00, 0x00, 0x00, 0x23,
  0xCF, 0x38, 0x1C, 0x3C, 0x70, 0x40, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC3,
  0x87, 0x1C, 0x38, 0x00, 0x00, 0x81, 0xC7, 0xEF, 0xCF, 0x87, 0x81, 0xF8,
  0x3F, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x80, 0x78, 0x3F, 0x07, 0xE0, 0xF8, 0x3C, 0xFD, 0xF8, 0xF0, 0x60, 0x00,
  0x1E, 0x7E, 0x7F, 0x47, 0x07, 0x0E, 0x1C, 0x3C, 0x70, 0x70, 0x70, 0x00,
  0x40, 0xE0, 0xE0, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xE0, 0x71,
  0x9E, 0x66, 0x7E, 0xCD, 0xD9, 0xB3, 0x33, 0x6E, 0x6C, 0xD9, 0xD9, 0xB3,
  0x33, 0x7E, 0xCE, 0xF7, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x20, 0x3F, 0xC0,
  0x1E, 0x00, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x6E, 0x1D, 0xC3, 0xB8,
  0xE7, 0x1C, 0xE7, 0x9C, 0xFF, 0x9F, 0xF7, 0x9E, 0xE3, 0xFC, 0x7F, 0x0F,
  0x1F, 0x83, 0xF8, 0x7F, 0x8E, 0x73, 0xCE, 0x73, 0xCE, 0xF1, 0xFC, 0x7F,
  0x8E, 0x79, 0xC7, 0x39, 0xE7, 0x3D, 0xFF, 0x3F, 0xC7, 0xF0, 0x07, 0x87,
  0xF3, 0xFC, 0xF2, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3F, 0x87, 0xE1, 0xF8, 0x1F, 0x01, 0xFC, 0x1F, 0xE1, 0xDE,
  0x3C, 0xE3, 0x8F, 0x38, 0xE3, 0x8E, 0x78, 0xE7, 0x9E, 0x71, 0xE7, 0x1C,
  0x73, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x3C,
  0x0E, 0x03, 0xF8, 0xFC, 0x7F, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0x8F,
  0xE3, 0xF8, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xFC,
  0x7F, 0x1F, 0xC7, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0x07, 0xC1,
  0xFC, 0x7F, 0x9E, 0x27, 0x80, 0xE0, 0x3C, 0x07, 0xBE, 0xE7, 0xDC, 0xFB,
  0x8F, 0x71, 0xCE, 0x39, 0xFF, 0x1F, 0xE1, 0xF8, 0x1E, 0x38, 0xE3, 0xC7,
  0x1C, 0x38, 0xE3, 0xC7, 0x1C, 0x78, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xC7,
  0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x78, 0xE3, 0xC7, 0x1C, 0x78, 0x1F, 0xC7,
  0xF0, 0xF0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x0F, 0xE3, 0xF8, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x0F, 0x0F, 0x83, 0xE0, 0xE0, 0x00, 0x1C, 0x78, 0xE3,
  0x87, 0x38, 0x3B, 0xC3, 0xFC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1D, 0xC0, 0xEF, 0x07, 0x78, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0x1C,
  0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x1F, 0xFF,
  0xFF, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xE3, 0xE3, 0xF3, 0xF1,
  0xF9, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x6E, 0x3B, 0xF7, 0x1D, 0xF7,
  0x0E, 0xFB, 0x87, 0x79, 0xC7, 0x3C, 0xE3, 0x9E, 0xF1, 0xCE, 0x70, 0x1E,
  0x1C, 0x78, 0xE1, 0xE3, 0x87, 0x8E, 0x3F, 0x38, 0xFD, 0xC3, 0xF7, 0x0F,
  0xDC, 0x37, 0x71, 0xCD, 0xC7, 0x3E, 0x1C, 0xF8, 0x73, 0xE3, 0x8F, 0x8E,
  0x3E, 0x38, 0x70, 0x07, 0x83, 0xF8, 0xFF, 0x9C, 0x77, 0x8E, 0xE1, 0xFC,
  0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x87, 0x71, 0xEE, 0x39, 0xFF, 0x1F, 0xC3,
  0xF0, 0x1F, 0x83, 0xF8, 0x7F, 0x8E, 0x73, 0xCE, 0x71, 0xCE, 0x79, 0xDE,
  0x7F, 0xCF, 0xF1, 0xF8, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x07,
  0x83, 0xF8, 0xFF, 0x9C, 0x77, 0x8E, 0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC,
  0x3F, 0x87, 0x71, 0xEE, 0x39, 0xFF, 0x3F, 0xC3, 0xF0, 0x0E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x1F, 0x03, 0xF8, 0x7F, 0x8E, 0xF3, 0xDE, 0x73, 0xCE,
  0x71, 0xFE, 0x3F, 0x8F, 0xE1, 0xDC, 0x3B, 0x87, 0x79, 0xEF, 0x38, 0xE7,
  0x1C, 0x07, 0x87, 0xF3, 0xFC, 0xF2, 0x38, 0x0E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x70, 0x1C, 0x87, 0x3F, 0xCF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC7, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0x38, 0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x79, 0xE7, 0x1C,
  0x71, 0xC7, 0x1C, 0xF3, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xE7, 0x8F, 0xF0,
  0xFF, 0x07, 0xE0, 0xE1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x39, 0xCE, 0x39,
  0xC7, 0x78, 0xEE, 0x1D, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0x71, 0xC3, 0xB8, 0xE3, 0x9C, 0x71, 0xCE, 0x79, 0xE7, 0x3C, 0xE3,
  0xBE, 0x71, 0xDF, 0x70, 0xEF, 0xB8, 0x7F, 0xDC, 0x3F, 0xFC, 0x1F, 0x7E,
  0x0F, 0xBE, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7, 0x81, 0xE3, 0xC0, 0x1E,
  0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xF0,
  0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xB8, 0x3D, 0xC1, 0xCF, 0x1C,
  0x78, 0xE1, 0xF8, 0xEE, 0x7B, 0xDC, 0x7F, 0x1F, 0x87, 0xE1, 0xF0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0x0F, 0xF1, 0xFE,
  0x1F, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0xF8, 0xFF, 0x8F, 0xF0, 0x0F, 0x87, 0xC3,
  0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x7C, 0x3E, 0x1F, 0x00, 0xE7, 0x38, 0xC6, 0x39,
  0xCE, 0x73, 0x8C, 0x63, 0x9C, 0xE7, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x30,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x1C, 0x3E, 0x1E, 0x1F, 0x00, 0x03, 0x01, 0xC0, 0x70, 0x3C, 0x1F, 0x86,
  0xE3, 0xB9, 0xC6, 0x71, 0xF8, 0x70, 0xFF, 0xFF, 0xF3, 0x9C, 0x70, 0x1E,
  0xE7, 0xF8, 0xEF, 0x3C, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7, 0x9C, 0xF7, 0x9E,
  0xF1, 0xFC, 0x3D, 0x80, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0xE3,
  0xFC, 0xF7, 0x39, 0xDC, 0x77, 0x1D, 0xCF, 0x73, 0x9C, 0xEF, 0x7B, 0xFC,
  0xFE, 0x00, 0x0F, 0x9F, 0xCF, 0x4F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x3F, 0x1F, 0x87, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1,
  0xFC, 0x3F, 0xC3, 0xBC, 0x79, 0xC7, 0x1C, 0x73, 0x87, 0x38, 0xF3, 0x8F,
  0x38, 0xF7, 0x87, 0xF0, 0x7B, 0x00, 0x0F, 0x87, 0xE3, 0x9D, 0xC6, 0x73,
  0x9F, 0xC7, 0xE3, 0x80, 0xE0, 0x1C, 0xC7, 0xF0, 0xF8, 0x01, 0xC0, 0x7C,
  0x1F, 0x03, 0x80, 0x70, 0x1F, 0x87, 0xE0, 0xFC, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x7C,
  0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x71, 0xFE, 0x1D, 0xE3, 0xCE, 0x39, 0xE3,
  0x9C, 0x39, 0xC7, 0x9C, 0x7B, 0xC7, 0xFC, 0x3F, 0x83, 0xF8, 0x03, 0x80,
  0x38, 0xC7, 0x0F, 0xF0, 0xFE, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0E, 0xE3, 0xFC, 0xFF, 0x39, 0xDE, 0x77, 0x39, 0xCE, 0x73, 0x9C, 0xEE,
  0x3B, 0x9C, 0xE7, 0x00, 0x0C, 0x71, 0xC2, 0x00, 0xE3, 0x8E, 0x39, 0xE7,
  0x1C, 0x71, 0xCE, 0x38, 0xE0, 0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x17, 0x0F, 0x87, 0x80, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x73, 0xCE, 0x71, 0xDC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xF0,
  0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x80, 0x1C, 0x71, 0xC7, 0x3C, 0xE3, 0x8E,
  0x39, 0xE7, 0x1C, 0x71, 0xCE, 0x38, 0xE0, 0x3F, 0xBC, 0x7F, 0xFC, 0xFF,
  0xF9, 0xCE, 0x77, 0x3C, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9D,
  0xCE, 0x7B, 0x9C, 0xE7, 0x39, 0xC0, 0x3B, 0x8F, 0xF3, 0xFC, 0xE7, 0x79,
  0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xB8, 0xEE, 0x73, 0x9C, 0x0F, 0x0F, 0xE3,
  0xBD, 0xE7, 0x71, 0xDC, 0xF7, 0x3B, 0xCE, 0xF3, 0x9D, 0xC7, 0xF0, 0xF8,
  0x1D, 0xC3, 0xFC, 0x7B, 0x8E, 0x73, 0x8E, 0x71, 0xCE, 0x79, 0xCE, 0x39,
  0xCF, 0xF9, 0xFE, 0x3B, 0x87, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00,
  0x1E, 0xE7, 0xF8, 0xEF, 0x3C, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7, 0x9C, 0xF3,
  0x9F, 0xF1, 0xFC, 0x3F, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x00,
  0x3B, 0x9F, 0x8F, 0xC7, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x00, 0x1F, 0x9F, 0x9E, 0xCE, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0E,
  0x7F, 0x3F, 0x1F, 0x00, 0x18, 0x30, 0xE3, 0xFF, 0xCE, 0x1C, 0x38, 0xF1,
  0xC3, 0x87, 0x0E, 0x9F, 0x3E, 0x00, 0x39, 0xE7, 0x38, 0xE7, 0x1C, 0xE7,
  0x1C, 0xE7, 0x1C, 0xE3, 0x9C, 0x77, 0x9F, 0xF1, 0xFC, 0x3D, 0x80, 0xE3,
  0xF8, 0xEE, 0x73, 0x9C, 0x6E, 0x1B, 0x86, 0xE1, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xC0, 0xE7, 0x9F, 0x9E, 0x7E, 0x7B, 0xBB, 0xEE, 0xEF, 0xB3, 0xBF,
  0xCF, 0xFF, 0x3E, 0xF8, 0xFB, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0x1C,
  0xF1, 0xDC, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x07, 0xF0, 0x73, 0x8F, 0x38, 0x1C, 0x78, 0xE3, 0x83, 0x38, 0x19, 0xC0,
  0xDE, 0x06, 0xE0, 0x37, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xC7, 0xE3,
  0xF8, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1F, 0xCF, 0xF3, 0xF8,
  0x01, 0x83, 0xC3, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x7C, 0x38, 0x3C,
  0x0F, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x78, 0x3C, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x07, 0x0F, 0x1E, 0x3C, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xF0, 0x70,
  0xFE, 0x7F, 0xF1, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 9, 2, -16 },
  { 21, 12, 16, 11, 0, -16 },
  { 45, 10, 18, 10, 0, -17 },
  { 68, 15, 16, 16, 1, -16 },
  { 98, 12, 16, 12, 0, -16 },
  { 122, 4, 6, 5, 2, -16 },
  { 125, 8, 19, 6, 0, -16 },
  { 144, 8, 19, 6, -2, -16 },
  { 163, 8, 10, 9, 2, -17 },
  { 173, 9, 11, 11, 1, -13 },
  { 186, 5, 6, 5, -1, -3 },
  { 190, 6, 3, 7, 0, -7 },
  { 193, 4, 4, 5, 0, -4 },
  { 195, 11, 16, 8, -1, -16 },
  { 217, 9, 16, 10, 1, -16 },
  { 235, 8, 16, 10, 2, -16 },
  { 251, 11, 16, 10, -1, -16 },
  { 273, 10, 16, 10, 0, -16 },
  { 293, 10, 16, 10, 0, -16 },
  { 313, 10, 16, 10, 0, -16 },
  { 333, 10, 16, 10, 1, -16 },
  { 353, 10, 16, 10, 1, -16 },
  { 373, 10, 16, 10, 0, -16 },
  { 393, 10, 16, 10, 0, -16 },
  { 413, 6, 12, 6, 0, -12 },
  { 422, 7, 15, 6, -1, -12 },
  { 436, 9, 10, 11, 1, -13 },
  { 448, 9, 7, 11, 1, -11 },
  { 456, 9, 10, 11, 1, -13 },
  { 468, 8, 16, 8, 1, -16 },
  { 484, 15, 18, 15, 0, -16 },
  { 518, 11, 16, 11, -1, -16 },
  { 540, 11, 16, 11, 0, -16 },
  { 562, 10, 16, 10, 1, -16 },
  { 582, 12, 16, 12, 0, -16 },
  { 606, 10, 16, 9, 0, -16 },
  { 626, 10, 16, 9, 0, -16 },
  { 646, 11, 16, 12, 1, -16 },
  { 668, 13, 16, 12, 0, -16 },
  { 694, 10, 16, 8, -1, -16 },
  { 714, 10, 21, 6, -3, -16 },
  { 741, 13, 16, 11, 0, -16 },
  { 767, 7, 16, 9, 0, -16 },
  { 781, 17, 16, 16, 0, -16 },
  { 815, 14, 16, 13, 0, -16 },
  { 843, 11, 16, 12, 1, -16 },
  { 865, 11, 16, 10, 0, -16 },
  { 887, 11, 20, 12, 1, -16 },
  { 915, 11, 16, 11, 0, -16 },
  { 937, 10, 16, 9, 0, -16 },
  { 957, 9, 16, 9, 2, -16 },
  { 975, 12, 16, 12, 1, -16 },
  { 999, 11, 16, 11, 2, -16 },
  { 1021, 17, 16, 16, 1, -16 },
  { 1055, 13, 16, 10, -1, -16 },
  { 1081, 10, 16, 10, 2, -16 },
  { 1101, 12, 16, 9, -1, -16 },
  { 1125, 9, 20, 6, -1, -16 },
  { 1148, 5, 16, 8, 2, -16 },
  { 1158, 9, 20, 6, -2, -16 },
  { 1181, 10, 10, 10, 0, -16 },
  { 1194, 8, 2, 8, -2, 2 },
  { 1196, 5, 4, 7, 3, -17 },
  { 1199, 11, 12, 10, 0, -12 },
  { 1216, 10, 17, 10, 0, -17 },
  { 1238, 9, 12, 8, 0, -12 },
  { 1252, 12, 17, 10, 0, -17 },
  { 1278, 10, 12, 10, 0, -12 },
  { 1293, 11, 22, 6, -2, -17 },
  { 1324, 12, 17, 10, -1, -12 },
  { 1350, 10, 17, 10, 0, -17 },
  { 1372, 6, 17, 5, 0, -17 },
  { 1385, 9, 22, 5, -3, -17 },
  { 1410, 11, 17, 10, 0, -17 },
  { 1434, 6, 17, 5, 0, -17 },
  { 1447, 15, 12, 15, 0, -12 },
  { 1470, 10, 12, 10, 0, -12 },
  { 1485, 10, 12, 10, 0, -12 },
  { 1500, 11, 17, 10, -1, -12 },
  { 1524, 11, 17, 10, 0, -12 },
  { 1548, 9, 12, 7, 0, -12 },
  { 1562, 9, 12, 8, 0, -12 },
  { 1576, 7, 15, 7, 1, -15 },
  { 1590, 11, 12, 10, 0, -12 },
  { 1607, 10, 12, 9, 1, -12 },
  { 1622, 14, 12, 14, 1, -12 },
  { 1643, 12, 12, 9, -1, -12 },
  { 1661, 13, 17, 9, -2, -12 },
  { 1689, 10, 12, 8, -1, -12 },
  { 1704, 9, 19, 8, 0, -16 },
  { 1726, 2, 22, 8, 3, -17 },
  { 1732, 8, 19, 8, -1, -16 },
  { 1751, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC22PT7B_H_
