#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x7C, 0xFB, 0xE7, 0x9F, 0x7C,
  0xF3, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7, 0x9E, 0x3C, 0xF3, 0xC0, 0x00, 0xE3,
  0x80, 0x39, 0xE0, 0x1E, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0xF3, 0x80,
  0x38, 0xE4, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x73, 0xC0, 0x3C,
  0xF0, 0x0F, 0x38, 0x03, 0x8E, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x07, 0x3C, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x1E, 0x70, 0x07,
  0x1C, 0x01, 0xCF, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0xF8, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xDC, 0x1E, 0x44, 0x1E, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0x78, 0x43, 0x78, 0x63, 0x78, 0x7B, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0,
  0x7F, 0xC0, 0x1F, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0x01,
  0xE0, 0x7E, 0x07, 0x03, 0xF8, 0x3C, 0x1E, 0xF0, 0xE0, 0x73, 0xC7, 0x81,
  0xCF, 0x1C, 0x0F, 0x3C, 0xF0, 0x3C, 0xE3, 0x80, 0xE3, 0x9E, 0x03, 0x9E,
  0xF0, 0x0E, 0x7B, 0x9F, 0xBF, 0xDE, 0xFE, 0xFE, 0x73, 0xFD, 0xFB, 0xDE,
  0xF3, 0x8E, 0x73, 0xC0, 0x7B, 0xCF, 0x01, 0xCF, 0x3C, 0x0F, 0x38, 0xE0,
  0x78, 0xE3, 0x81, 0xE3, 0x9E, 0x0F, 0x0E, 0x70, 0x38, 0x3F, 0xC1, 0xE0,
  0xFE, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0xF0, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x9F, 0x1F, 0xE7, 0xCF, 0xFD, 0xE7,
  0xDF, 0xF9, 0xF7, 0xFC, 0xF8, 0xFF, 0x3E, 0x3F, 0x8F, 0x8F, 0xE3, 0xE3,
  0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0x7C, 0x7D, 0xF7,
  0xDE, 0x79, 0xEF, 0xBC, 0xF0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C,
  0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x1E,
  0x08, 0xE0, 0xE7, 0x07, 0xFB, 0xBF, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xC1,
  0xFE, 0x1F, 0x78, 0x7B, 0xE1, 0x8E, 0x04, 0x40, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xBF,
  0xDF, 0xFF, 0xF0, 0x7B, 0xFF, 0xBE, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x1F, 0x7C, 0x79, 0xF3,
  0xE7, 0xCF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDE, 0x1E, 0xF8, 0x7B,
  0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF1, 0xF3, 0xC7, 0xCF, 0x1E, 0x3C, 0xF8,
  0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0xFE, 0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0xFC, 0x77, 0xC2, 0x7C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFF, 0x0F, 0xBF, 0x06, 0x1F, 0x04, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF0, 0xF7, 0xE1, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE4, 0x0F, 0x8F, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xFC, 0x0E, 0xF0, 0x3B,
  0xE0, 0xF7, 0xC3, 0xCF, 0x87, 0x1E, 0x1E, 0x3C, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC3,
  0xFF, 0x82, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF2, 0x07,
  0xE6, 0x0F, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7E,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFC, 0x43, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x40, 0xFB, 0xE1, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x9F, 0x9F,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0x1F, 0x7C,
  0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0x07, 0xFE, 0x0F, 0xBE, 0x3E,
  0x7C, 0xF8, 0x79, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0xFF, 0x0F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFB, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF9,
  0xF9, 0xF3, 0xE3, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0xF0, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xC7, 0xFC,
  0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x03, 0xF0,
  0x0F, 0x00, 0x30, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xFF, 0x39, 0xF2,
  0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0x81, 0xE0, 0x78, 0x07, 0x87, 0x00, 0x1C, 0x78, 0xF8, 0xE7, 0x8F,
  0xE7, 0x38, 0xFF, 0x3B, 0xCF, 0x39, 0xDC, 0x73, 0xCE, 0xE7, 0x1C, 0x7F,
  0x38, 0xE3, 0xF3, 0xC7, 0x3B, 0x9E, 0x79, 0xDC, 0xE3, 0xCE, 0xE7, 0x1C,
  0xE7, 0x3F, 0xFF, 0x39, 0xFB, 0xF1, 0xC7, 0x9F, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x08, 0x0F, 0x87, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xEF, 0x01, 0xEF, 0x03, 0xEF, 0x03,
  0xCF, 0x07, 0xCF, 0x07, 0xCF, 0x0F, 0x8F, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0xF8, 0x1F, 0x07, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFB, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F,
  0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF8, 0x78,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xDC, 0x1F, 0x84, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x20, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0xFC, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC,
  0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F, 0x1F, 0x8F, 0xBF,
  0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xEF, 0x07, 0xE0, 0x41, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC7, 0xF1, 0xF1, 0xFC, 0x7C, 0xFF, 0x3F, 0x3F, 0xCF, 0x8F,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xC3, 0xC3, 0xF1, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x02, 0x3E, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC0,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0x8F, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x83,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0xF7, 0xC3, 0xFE, 0x7B,
  0xC1, 0xF7, 0x3F, 0xE0, 0xF3, 0xFD, 0xF0, 0x79, 0xFE, 0xF8, 0x7C, 0xFE,
  0x78, 0x3E, 0x7F, 0x3C, 0x1F, 0x3F, 0x3E, 0x0F, 0x1F, 0x9F, 0x07, 0x8F,
  0x8F, 0x87, 0xC7, 0xC7, 0x83, 0xE3, 0xE7, 0xC1, 0xF1, 0xE3, 0xE0, 0x07,
  0xC0, 0xF0, 0x7C, 0x0F, 0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE1, 0xF0,
  0xFE, 0x1E, 0x0F, 0xE1, 0xE1, 0xFE, 0x3E, 0x1F, 0xF3, 0xE1, 0xEF, 0x3C,
  0x1E, 0xF3, 0xC1, 0xEF, 0x3C, 0x3E, 0xF7, 0xC3, 0xEF, 0x7C, 0x3C, 0xFF,
  0x83, 0xC7, 0xF8, 0x7C, 0x7F, 0x87, 0xC7, 0xF8, 0x7C, 0x7F, 0x87, 0x87,
  0xF0, 0x78, 0x7F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xFD, 0xF8, 0xF8, 0x7C,
  0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81,
  0xF7, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7C,
  0x1F, 0x3E, 0x1F, 0x9F, 0x9F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7C, 0xFC, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xCF, 0xC7, 0xCF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFD, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x9F, 0x87,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x0F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3D, 0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x78, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0x00, 0x7C, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7C, 0x30, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x10,
  0x3E, 0x0E, 0x3F, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xF8, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xF1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xF3, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0,
  0xFB, 0xE0, 0xFB, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xF7, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x7C, 0x1E, 0x0F, 0xBE, 0x1F, 0x0F, 0x9F, 0x0F, 0x87, 0xCF, 0x87, 0xC3,
  0xE7, 0x87, 0xE3, 0xE3, 0xC3, 0xF1, 0xF1, 0xE3, 0xF8, 0xF0, 0xF1, 0xFC,
  0xF8, 0x78, 0xFE, 0x7C, 0x3C, 0xFF, 0x7C, 0x1E, 0x7F, 0x3E, 0x0F, 0x7B,
  0x9E, 0x07, 0xBD, 0xDF, 0x03, 0xDF, 0xEF, 0x81, 0xFE, 0xF7, 0x81, 0xFF,
  0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xC7, 0x8F,
  0x8F, 0x3E, 0x1E, 0x7C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE0, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x00, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7F, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x3C, 0xF8, 0x78, 0xF1,
  0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0xBC, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF9, 0xE7, 0xCF, 0x3C, 0x0F, 0x9E, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF,
  0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x7C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3,
  0xE3, 0xE7, 0x87, 0xCF, 0x1F, 0x1F, 0x3E, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xE0, 0xFB, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8,
  0xF9, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1F, 0x7C, 0x3E, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7B, 0xF0,
  0xF7, 0xC0, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC7, 0xE2, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x43, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x0F, 0xBE,
  0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C,
  0xF8, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0,
  0xF1, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7D, 0xE0, 0x07, 0xF0,
  0x7F, 0xC7, 0xFE, 0x7C, 0xF7, 0xC7, 0xBC, 0x3D, 0xE3, 0xFF, 0xFE, 0xFF,
  0xE7, 0xFE, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x13, 0xE7, 0x9F, 0xFC,
  0x7F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x09, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE7, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0x87, 0xC7, 0xC7, 0xC3, 0xF3, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xBC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x86,
  0x0F, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0xBE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xF9, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x1E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3,
  0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF0, 0x07, 0x81,
  0xF0, 0xF8, 0x3E, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0xBF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x3F, 0x1F, 0x3E, 0x0F,
  0x9F, 0x07, 0x9F, 0x03, 0xDF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0x9F,
  0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x00, 0x07, 0xC1,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x1E, 0x7C, 0xF8, 0x7B, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0x3E, 0x7C, 0xF8, 0xF9, 0xF3, 0xE3,
  0xC7, 0xCF, 0x8F, 0x1F, 0x3C, 0x7C, 0x7D, 0xF1, 0xF1, 0xE7, 0xC7, 0x8F,
  0x9F, 0x1E, 0x3E, 0x78, 0xF8, 0xF9, 0xE3, 0xE3, 0xCF, 0x8F, 0x8F, 0x3E,
  0x3C, 0x7C, 0xF8, 0xF1, 0xF3, 0xC7, 0xC7, 0xC0, 0x1E, 0x7C, 0x3D, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3C,
  0x3C, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x1F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF1, 0xE1, 0xE0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F,
  0xFE, 0x7C, 0x7D, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xE3, 0xEF,
  0x0F, 0xBC, 0x3E, 0xF1, 0xF3, 0xE7, 0xCF, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFC, 0x00, 0x07, 0x9F, 0x03, 0xDF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1E, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xCF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E,
  0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8, 0xF8,
  0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3E, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x1E, 0x78, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xCF,
  0xFC, 0x7E, 0xE3, 0xE2, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x43, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0x87,
  0xF8, 0x00, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x3F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E,
  0x0F, 0xF3, 0xFC, 0x7F, 0x1F, 0xC0, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1,
  0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3C, 0x3C, 0x78, 0xF9, 0xF1,
  0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xE0, 0xFB, 0xC0, 0xF8, 0x7F, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF9,
  0xF3, 0xE7, 0x8F, 0xBE, 0x3E, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0x78, 0x3F,
  0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x00,
  0xF8, 0xF8, 0xFF, 0xCF, 0xC7, 0xBC, 0x7E, 0x7D, 0xE3, 0xF3, 0xEF, 0x3F,
  0x9E, 0x79, 0xFD, 0xF3, 0xDF, 0xEF, 0x1E, 0xFF, 0x78, 0xF7, 0x7F, 0xC7,
  0xFB, 0xFC, 0x3F, 0xDD, 0xE1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F,
  0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x00,
  0x0F, 0x8F, 0xC1, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F, 0x78, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xE7, 0x80, 0xF9, 0xF0,
  0x7C, 0x7C, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x3E, 0xF0, 0x07,
  0xBC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x27, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80,
  0x00, 0x04, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x1F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xF0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x10, 0x05, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 24, 8, 0, -24 },
  { 31, 13, 9, 14, 3, -24 },
  { 46, 18, 24, 17, 0, -24 },
  { 100, 16, 27, 15, 0, -25 },
  { 154, 22, 24, 25, 2, -24 },
  { 220, 18, 24, 18, 0, -24 },
  { 274, 6, 9, 8, 3, -24 },
  { 281, 12, 29, 9, 0, -24 },
  { 325, 12, 29, 9, -3, -24 },
  { 369, 13, 14, 14, 2, -25 },
  { 392, 14, 16, 16, 1, -20 },
  { 420, 8, 10, 8, -2, -5 },
  { 430, 9, 4, 10, 0, -11 },
  { 435, 6, 5, 8, 0, -5 },
  { 439, 18, 24, 13, -2, -24 },
  { 493, 14, 24, 15, 1, -24 },
  { 535, 12, 24, 15, 3, -24 },
  { 571, 16, 24, 15, -1, -24 },
  { 619, 15, 24, 15, 0, -24 },
  { 664, 15, 24, 15, 0, -24 },
  { 709, 15, 24, 15, 0, -24 },
  { 754, 15, 24, 15, 1, -24 },
  { 799, 16, 24, 15, 1, -24 },
  { 847, 15, 24, 15, 0, -24 },
  { 892, 15, 24, 15, 0, -24 },
  { 937, 8, 18, 8, 0, -18 },
  { 955, 10, 23, 8, -2, -18 },
  { 984, 14, 16, 16, 1, -20 },
  { 1012, 14, 11, 16, 1, -17 },
  { 1032, 14, 16, 16, 1, -20 },
  { 1060, 12, 24, 12, 1, -24 },
  { 1096, 21, 27, 22, 1, -24 },
  { 1167, 16, 24, 16, -2, -24 },
  { 1215, 17, 24, 16, 0, -24 },
  { 1266, 16, 24, 15, 1, -24 },
  { 1314, 17, 24, 17, 0, -24 },
  { 1365, 15, 24, 13, 0, -24 },
  { 1410, 15, 24, 13, 0, -24 },
  { 1455, 18, 24, 18, 1, -24 },
  { 1509, 19, 24, 18, 0, -24 },
  { 1566, 15, 24, 11, -1, -24 },
  { 1611, 15, 31, 9, -5, -24 },
  { 1670, 19, 24, 16, 0, -24 },
  { 1727, 11, 24, 13, 0, -24 },
  { 1760, 25, 24, 24, 0, -24 },
  { 1835, 20, 24, 19, 0, -24 },
  { 1895, 17, 24, 18, 1, -24 },
  { 1946, 17, 24, 16, 0, -24 },
  { 1997, 17, 30, 18, 1, -24 },
  { 2061, 16, 24, 16, 0, -24 },
  { 2109, 17, 24, 14, -1, -24 },
  { 2160, 14, 24, 14, 2, -24 },
  { 2202, 18, 24, 17, 1, -24 },
  { 2256, 16, 24, 16, 3, -24 },
  { 2304, 25, 24, 24, 2, -24 },
  { 2379, 20, 24, 15, -2, -24 },
  { 2439, 15, 24, 15, 3, -24 },
  { 2484, 17, 24, 14, -1, -24 },
  { 2535, 13, 29, 9, -1, -24 },
  { 2583, 8, 24, 13, 3, -24 },
  { 2607, 13, 29, 9, -2, -24 },
  { 2655, 15, 15, 15, 0, -24 },
  { 2684, 12, 3, 12, -3, 3 },
  { 2689, 6, 5, 10, 5, -25 },
  { 2693, 15, 18, 16, 1, -18 },
  { 2727, 15, 25, 16, 0, -25 },
  { 2774, 13, 18, 13, 1, -18 },
  { 2804, 16, 25, 16, 1, -25 },
  { 2854, 13, 18, 15, 1, -18 },
  { 2884, 17, 33, 10, -4, -25 },
  { 2955, 17, 26, 16, -1, -18 },
  { 3011, 15, 25, 16, 0, -25 },
  { 3058, 10, 25, 8, 0, -25 },
  { 3090, 14, 33, 8, -4, -25 },
  { 3148, 17, 25, 15, 0, -25 },
  { 3202, 10, 25, 8, 0, -25 },
  { 3234, 22, 18, 23, 0, -18 },
  { 3284, 15, 18, 16, 0, -18 },
  { 3318, 14, 18, 15, 1, -18 },
  { 3350, 17, 26, 16, -2, -18 },
  { 3406, 16, 26, 16, 0, -18 },
  { 3458, 13, 18, 11, 0, -18 },
  { 3488, 13, 18, 12, 0, -18 },
  { 3518, 10, 22, 10, 1, -22 },
  { 3546, 15, 18, 16, 1, -18 },
  { 3580, 14, 18, 14, 2, -18 },
  { 3612, 21, 18, 21, 2, -18 },
  { 3660, 18, 18, 14, -2, -18 },
  { 3701, 18, 26, 14, -2, -18 },
  { 3760, 14, 18, 12, -1, -18 },
  { 3792, 14, 29, 11, 0, -24 },
  { 3843, 4, 33, 13, 4, -25 },
  { 3860, 13, 29, 11, -2, -24 },
  { 3908, 14, 6, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC33PT7B_H_
