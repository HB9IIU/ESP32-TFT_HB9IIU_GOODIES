#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x7E, 0xFC,
  0xFD, 0xF9, 0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0xBF, 0x3F, 0x7C, 0x7C,
  0xF8, 0xF9, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x7C, 0xF8, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xDB, 0x81, 0xF2, 0x10,
  0x3E, 0xC0, 0x07, 0xD8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0D, 0xF8, 0x81, 0xBE, 0x18, 0x37, 0xC3, 0x85, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x0F, 0xF0, 0x1E, 0x01, 0xFF, 0x03, 0xE0, 0x3E, 0xF0, 0x3C,
  0x03, 0xCF, 0x87, 0x80, 0x7C, 0xF8, 0xF8, 0x07, 0x8F, 0x0F, 0x00, 0x78,
  0xF1, 0xF0, 0x07, 0x8F, 0x1E, 0x00, 0xF8, 0xF3, 0xE0, 0x0F, 0x9F, 0x3C,
  0x00, 0xF1, 0xE7, 0xC7, 0x8F, 0x1E, 0x79, 0xFC, 0xFB, 0xCF, 0xBF, 0xEF,
  0xFD, 0xF3, 0xFE, 0x7F, 0x9E, 0x7D, 0xE3, 0xF3, 0xE7, 0x9F, 0x0C, 0x3C,
  0xF9, 0xE0, 0x07, 0xCF, 0x1E, 0x00, 0x78, 0xF1, 0xE0, 0x0F, 0x9F, 0x1E,
  0x00, 0xF1, 0xF1, 0xE0, 0x1F, 0x1F, 0x3E, 0x01, 0xE1, 0xE3, 0xC0, 0x3C,
  0x1F, 0x7C, 0x07, 0xC1, 0xFF, 0x80, 0x78, 0x0F, 0xF8, 0x0F, 0x80, 0xFF,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0x87,
  0xFE, 0x7E, 0x1F, 0xFC, 0xFC, 0x7F, 0xFD, 0xF0, 0xFD, 0xFF, 0xE3, 0xF3,
  0xFF, 0x87, 0xC7, 0xFF, 0x1F, 0x87, 0xFC, 0x3F, 0x0F, 0xF8, 0x7E, 0x0F,
  0xE0, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0x7F, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x02,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x63, 0xE0, 0x7B, 0xE1, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x0F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF8, 0x7E, 0xF8, 0x3C, 0x7C, 0x1C, 0x78, 0x08, 0x60, 0x00,
  0x40, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1,
  0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F, 0x00, 0x3F, 0xF7, 0xFE, 0x7F,
  0xE7, 0xFE, 0x7F, 0xEF, 0xFE, 0x18, 0xFD, 0xFF, 0xFF, 0xFF, 0xBE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFC, 0xF8, 0x7E,
  0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x3E, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0xBF, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFD, 0xF1, 0xEF, 0xC7, 0x3F, 0x08, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xC7, 0xF0,
  0x30, 0x7E, 0x02, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0xC3, 0xF8, 0x20, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC4, 0x03, 0xF8, 0xC0, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x7E, 0x03,
  0xCF, 0x80, 0x7B, 0xF0, 0x1E, 0x7E, 0x07, 0xCF, 0xC0, 0xF1, 0xF8, 0x3C,
  0x3E, 0x0F, 0x8F, 0xC1, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x63, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x20, 0x1F,
  0xC7, 0x07, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFB, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xBE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0,
  0xFC, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x3F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC,
  0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0,
  0xF8, 0xFC, 0x3F, 0x1F, 0xCF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF3, 0xF0, 0xFC, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E,
  0x3F, 0x8F, 0xE7, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0x7E, 0x03, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0x80, 0x00, 0xE0, 0x1F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x81,
  0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xE0, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0xF1, 0xFF, 0xE3, 0xDF, 0xC6, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x7C, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F,
  0x07, 0xE1, 0xC3, 0xC3, 0xFF, 0x3C, 0x78, 0xFF, 0xC7, 0x9E, 0x3E, 0x78,
  0xF3, 0xC7, 0x8F, 0x1E, 0xF1, 0xE1, 0xE3, 0x9E, 0x3C, 0x78, 0xF3, 0xCF,
  0x8F, 0x1E, 0x79, 0xE1, 0xE3, 0xDE, 0x3C, 0x3C, 0x7B, 0xC7, 0x8F, 0x1E,
  0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x7C, 0x71, 0xE3, 0xCF, 0x9E, 0x3C, 0x7F,
  0xFF, 0x87, 0x8F, 0xEF, 0xE0, 0xF0, 0xF8, 0xF8, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x04, 0x00, 0x7F, 0x1F,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xBF, 0x01, 0xFB, 0xF0, 0x1F, 0xBF, 0x01, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x83, 0xF3, 0xF0, 0x3F,
  0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC7, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xF0, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x0C, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF3,
  0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F,
  0xE3, 0xF0, 0x7F, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7E,
  0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x7F, 0x0F, 0xDF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0x03, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0xC7, 0xF1,
  0xFF, 0x1F, 0x87, 0xFC, 0x7E, 0x1F, 0xF1, 0xF8, 0xFF, 0x87, 0xE0, 0x7E,
  0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x5F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF8,
  0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0,
  0x0F, 0xDF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE3,
  0xEF, 0x81, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x3E,
  0xFC, 0x0F, 0xBE, 0x7D, 0xF8, 0x1F, 0x7D, 0xF3, 0xE0, 0x7E, 0xFB, 0xEF,
  0xC0, 0xFD, 0xFF, 0x9F, 0x81, 0xF3, 0xFF, 0x3F, 0x03, 0xE7, 0xFC, 0x7C,
  0x0F, 0xCF, 0xF9, 0xF8, 0x1F, 0x8F, 0xF3, 0xF0, 0x3F, 0x1F, 0xC7, 0xE0,
  0x7C, 0x3F, 0x8F, 0xC0, 0xF8, 0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x7E, 0x07,
  0xE1, 0xF0, 0xFC, 0x0F, 0xC3, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0x81,
  0xFC, 0x0F, 0xC1, 0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xF0, 0x7F, 0xC1, 0xF0,
  0x3F, 0xE1, 0xF8, 0x1F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x3E,
  0x07, 0xFE, 0x1F, 0x03, 0xFF, 0x9F, 0x81, 0xFF, 0xCF, 0xC1, 0xFB, 0xE7,
  0xE0, 0xFD, 0xF3, 0xE0, 0x7C, 0xF9, 0xF0, 0x3E, 0x7D, 0xF8, 0x1F, 0x3F,
  0xFC, 0x1F, 0x8F, 0xFE, 0x0F, 0xC7, 0xFE, 0x07, 0xC3, 0xFF, 0x03, 0xE1,
  0xFF, 0x83, 0xF0, 0xFF, 0xC1, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0xE0, 0x7C,
  0x0F, 0xF0, 0x3E, 0x07, 0xF8, 0x3F, 0x03, 0xFC, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0x83, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x3F, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xF1, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7F,
  0x0F, 0xCF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8,
  0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x3F,
  0x80, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F, 0x83,
  0xF8, 0x7F, 0x3F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7E, 0x7F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xE1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0xC0, 0xFE, 0x04, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x40, 0x3F, 0x86,
  0x03, 0xF0, 0x78, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1,
  0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0,
  0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFD, 0xF0, 0x0F, 0xBF, 0x00,
  0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0xFD, 0xF0, 0x3F, 0x03, 0xF7,
  0xC0, 0xFC, 0x1F, 0x9F, 0x07, 0xF0, 0x7E, 0x7C, 0x1F, 0xC3, 0xF1, 0xF0,
  0x7F, 0x0F, 0xCF, 0xC3, 0xFC, 0x3F, 0x3F, 0x0F, 0xF1, 0xF8, 0xFC, 0x7F,
  0xC7, 0xE3, 0xF1, 0xFF, 0x1F, 0x0F, 0xC7, 0xFC, 0xFC, 0x3F, 0x3F, 0xF3,
  0xF0, 0xFC, 0xFF, 0x9F, 0x83, 0xF7, 0xDE, 0x7E, 0x0F, 0xDF, 0x79, 0xF8,
  0x3F, 0x7D, 0xEF, 0xC0, 0xFF, 0xEF, 0xBF, 0x03, 0xFF, 0xBE, 0xF8, 0x0F,
  0xBC, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x03, 0xFE,
  0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF8, 0x01,
  0xFB, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x0F,
  0xDF, 0x80, 0x1F, 0x8F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xFF, 0x07,
  0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x1F, 0x87, 0xC7, 0xE1,
  0xFB, 0xF0, 0x7E, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE1,
  0xF0, 0xF8, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xF7, 0xE0, 0xFC, 0xF8, 0x3E,
  0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07,
  0xFE, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x7E, 0x7E, 0x3E, 0x1F, 0x1F, 0x01, 0xC3, 0xE0, 0xFE, 0xFC, 0x3F, 0xDF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x3F, 0x8F, 0xC7, 0xF3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFE, 0xF8, 0x0F, 0x9F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xCF, 0x01, 0xFB, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC7, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF7, 0xF8, 0x3C,
  0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0x8C, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x30, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xC7, 0xE0,
  0x3F, 0xBF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xBE, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC,
  0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0x3E, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F,
  0xFF, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x02,
  0x3F, 0x8E, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x27,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x0F, 0xEF, 0xC0, 0xFF, 0x7C,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F,
  0x81, 0xF9, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xEF, 0x80, 0x3E, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x20, 0x1F, 0x81, 0xC1, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xCF, 0x01, 0xFB, 0xF0, 0x3E, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x80, 0x03, 0xE0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x13, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8,
  0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x8F, 0x07,
  0xC0, 0xFB, 0xF8, 0xFE, 0x0F, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFC, 0xFF, 0x7F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x0F, 0xC3, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xE3,
  0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x7E, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF8,
  0x7C, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0xC7,
  0xE1, 0xF8, 0xF8, 0x7E, 0x1F, 0x00, 0x0F, 0x8F, 0x01, 0xF3, 0xF0, 0x3E,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF0, 0xFC,
  0x3E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0,
  0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F,
  0x80, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF9,
  0xFC, 0xFC, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC,
  0x7E, 0x7E, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0x00, 0x03, 0xE3, 0xC0, 0x1F, 0x3F, 0x00, 0xFB, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xF9, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0xFE, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x3F, 0x8F, 0xC7, 0xF3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFE, 0xF8, 0x0F, 0xBF, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0x8F, 0x0F, 0x9F, 0x0F, 0xBE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF4, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x0C, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x81, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7F, 0x8F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF0, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFE, 0xF8, 0x1F, 0x9F, 0x00, 0xFC,
  0x0F, 0xDF, 0x07, 0xE7, 0xC1, 0xF9, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F,
  0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81,
  0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x7C, 0x3F, 0x87, 0xEF, 0x87, 0xF1, 0xF9, 0xF0, 0xFE,
  0x3F, 0x3E, 0x3F, 0xC7, 0xC7, 0xC7, 0xF9, 0xF9, 0xF9, 0xFE, 0x3F, 0x3F,
  0x3F, 0xC7, 0xC7, 0xE7, 0xF9, 0xF8, 0xFD, 0xFF, 0x3E, 0x1F, 0xBD, 0xE7,
  0xC3, 0xF7, 0xBD, 0xF8, 0x7F, 0xF7, 0xBE, 0x0F, 0xBC, 0xFF, 0xC1, 0xF7,
  0x9F, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xF0,
  0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFC,
  0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07,
  0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8,
  0x03, 0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x02, 0x7E, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x82,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 29, 10, 0, -29 },
  { 45, 15, 10, 17, 4, -29 },
  { 64, 22, 29, 21, 0, -29 },
  { 144, 19, 33, 18, 0, -31 },
  { 223, 28, 30, 31, 2, -30 },
  { 328, 23, 30, 23, 0, -30 },
  { 415, 8, 10, 10, 4, -29 },
  { 425, 14, 36, 11, 1, -30 },
  { 488, 14, 36, 11, -3, -30 },
  { 551, 16, 19, 17, 3, -32 },
  { 589, 17, 19, 20, 2, -24 },
  { 630, 9, 12, 10, -2, -6 },
  { 644, 12, 6, 12, 0, -14 },
  { 653, 7, 7, 10, 0, -7 },
  { 660, 21, 30, 16, -2, -30 },
  { 739, 18, 30, 18, 1, -30 },
  { 807, 14, 29, 19, 4, -29 },
  { 858, 20, 30, 18, -1, -30 },
  { 933, 19, 30, 18, 0, -30 },
  { 1005, 19, 29, 19, 0, -29 },
  { 1074, 19, 29, 18, 0, -29 },
  { 1143, 19, 30, 18, 1, -30 },
  { 1215, 20, 29, 18, 1, -29 },
  { 1288, 19, 30, 18, 0, -30 },
  { 1360, 19, 30, 18, 0, -30 },
  { 1432, 10, 23, 10, 0, -23 },
  { 1461, 12, 29, 10, -2, -23 },
  { 1505, 17, 20, 20, 2, -25 },
  { 1548, 17, 13, 20, 2, -21 },
  { 1576, 17, 20, 20, 2, -25 },
  { 1619, 15, 30, 14, 1, -30 },
  { 1676, 27, 33, 28, 1, -30 },
  { 1788, 20, 29, 20, -2, -29 },
  { 1861, 21, 29, 20, 0, -29 },
  { 1938, 20, 30, 19, 1, -30 },
  { 2013, 21, 29, 22, 0, -29 },
  { 2090, 19, 29, 17, 0, -29 },
  { 2159, 19, 29, 16, 0, -29 },
  { 2228, 22, 30, 22, 1, -30 },
  { 2311, 24, 29, 22, 0, -29 },
  { 2398, 19, 29, 14, -2, -29 },
  { 2467, 18, 38, 11, -6, -29 },
  { 2553, 24, 29, 20, 0, -29 },
  { 2640, 14, 29, 16, 0, -29 },
  { 2691, 31, 29, 29, 0, -29 },
  { 2804, 25, 29, 24, 0, -29 },
  { 2895, 22, 30, 23, 1, -30 },
  { 2978, 21, 29, 19, 0, -29 },
  { 3055, 22, 37, 23, 1, -30 },
  { 3157, 20, 29, 20, 0, -29 },
  { 3230, 20, 30, 17, -1, -30 },
  { 3305, 17, 29, 17, 3, -29 },
  { 3367, 22, 29, 22, 1, -29 },
  { 3447, 20, 29, 20, 4, -29 },
  { 3520, 30, 29, 30, 3, -29 },
  { 3629, 24, 29, 19, -2, -29 },
  { 3716, 18, 29, 19, 4, -29 },
  { 3782, 22, 29, 17, -2, -29 },
  { 3862, 17, 37, 12, -2, -30 },
  { 3941, 9, 30, 16, 4, -30 },
  { 3975, 17, 37, 12, -3, -30 },
  { 4054, 18, 18, 18, 0, -29 },
  { 4095, 15, 4, 14, -4, 3 },
  { 4103, 8, 6, 13, 6, -31 },
  { 4109, 19, 23, 19, 1, -23 },
  { 4164, 19, 31, 19, 0, -31 },
  { 4238, 16, 23, 16, 1, -23 },
  { 4284, 21, 31, 19, 1, -31 },
  { 4366, 17, 23, 18, 1, -23 },
  { 4415, 22, 41, 12, -5, -31 },
  { 4528, 21, 33, 19, -1, -23 },
  { 4615, 19, 31, 19, 0, -31 },
  { 4689, 12, 31, 10, 0, -31 },
  { 4736, 17, 41, 10, -5, -31 },
  { 4824, 21, 31, 19, 0, -31 },
  { 4906, 12, 31, 10, 0, -31 },
  { 4953, 28, 23, 29, 0, -23 },
  { 5034, 19, 23, 19, 0, -23 },
  { 5089, 17, 23, 19, 1, -23 },
  { 5138, 21, 33, 19, -2, -23 },
  { 5225, 19, 33, 19, 1, -23 },
  { 5304, 16, 23, 14, 0, -23 },
  { 5350, 16, 23, 15, 0, -23 },
  { 5396, 13, 27, 13, 1, -27 },
  { 5440, 19, 23, 19, 1, -23 },
  { 5495, 18, 23, 17, 2, -23 },
  { 5547, 27, 23, 26, 2, -23 },
  { 5625, 22, 23, 18, -2, -23 },
  { 5689, 23, 33, 18, -3, -23 },
  { 5784, 18, 23, 15, -2, -23 },
  { 5836, 17, 35, 14, 0, -29 },
  { 5911, 5, 41, 16, 5, -32 },
  { 5937, 16, 35, 14, -2, -29 },
  { 6007, 17, 7, 20, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC41PT7B_H_
